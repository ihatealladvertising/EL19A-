ASAP2_VERSION 1 3_BETA
/begin PROJECT TK_X91_EUR_VC ""
/begin HEADER "" /* key HEADER ++ "comment" Ç… Par.scomment */ PROJECT_NO TK_X91_EUR_VC /* key PROJECT_NO ++ project number Ç… car_eng_desti_lot */ VERSION "7V4YHZEB2" /* key VERSION ++ version number Ç… mProgver */ /end HEADER
/begin MODULE DIM ""
/begin MOD_COMMON "" DEPOSIT ABSOLUTE BYTE_ORDER MSB_FIRST /* ﬁ≤ƒµ∞¿ﬁ∞Ç™ÿÃﬂ⁄∞ΩÇ≥ÇÍÇÈ */ /end MOD_COMMON
/begin CHARACTERISTIC mCAFLHZR "ROM Const mCAFLHZR" VALUE 0x00010A28 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFLHZL "ROM Const mCAFLHZL" VALUE 0x00010A2C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFRHZR "ROM Const mCAFRHZR" VALUE 0x00010A30 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFRHZL "ROM Const mCAFRHZL" VALUE 0x00010A34 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFHF1L "ROM Const mCAFHF1L" VALUE 0x00010A38 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFHF1H "ROM Const mCAFHF1H" VALUE 0x00010A3C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFHF2L "ROM Const mCAFHF2L" VALUE 0x00010A40 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFHF2H "ROM Const mCAFHF2H" VALUE 0x00010A44 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFRLD1 "ROM Const mCAFRLD1" VALUE 0x00010A48 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFLRD1 "ROM Const mCAFLRD1" VALUE 0x00010A4C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFRLD2 "ROM Const mCAFRLD2" VALUE 0x00010A50 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAFLRD2 "ROM Const mCAFLRD2" VALUE 0x00010A54 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPSC "ROM Const mCAPSC" VALUE 0x00010A58 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPSOC1 "ROM Const mCAPSOC1" VALUE 0x00010A5C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPSSC1 "ROM Const mCAPSSC1" VALUE 0x00010A60 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPSOC2 "ROM Const mCAPSOC2" VALUE 0x00010A64 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPSSC2 "ROM Const mCAPSSC2" VALUE 0x00010A68 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAP12 "ROM Const mCAP12" VALUE 0x00010A6C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPCHR "ROM Const mCAPCHR" VALUE 0x00010A70 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPSC1 "ROM Const mCAPSC1" VALUE 0x00010A74 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAVCC1 "ROM Const mCAVCC1" VALUE 0x00010A78 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAVCC2 "ROM Const mCAVCC2" VALUE 0x00010A7C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCPRSSC "ROM Const mCPRSSC" VALUE 0x00010A80 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCPRSOC "ROM Const mCPRSOC" VALUE 0x00010A84 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCUPCRCV "ROM Const mCUPCRCV" VALUE 0x00010A88 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAPMUX "ROM Const mCAPMUX" VALUE 0x00010A8C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCESPLNK "ROM Const mCESPLNK" VALUE 0x00010A90 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAGBLNK "ROM Const mCAGBLNK" VALUE 0x00010A94 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAGBCLK "ROM Const mCAGBCLK" VALUE 0x00010A98 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCESPCPL "ROM Const mCESPCPL" VALUE 0x00010A9C REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCESPCLK "ROM Const mCESPCLK" VALUE 0x00010AA0 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAGBDLY "ROM Const mCAGBDLY" VALUE 0x00010AA4 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCAGBINT "ROM Const mCAGBINT" VALUE 0x00010AA8 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCSCHR "ROM Const mCCSCHR" VALUE 0x00010AAC REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCSTOT "ROM Const mCCSTOT" VALUE 0x00010AB0 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCVSCMP "ROM Const mCVSCMP" VALUE 0x00010AB4 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCSOOR "ROM Const mCCSOOR" VALUE 0x00010AB8 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCSOCS "ROM Const mCCSOCS" VALUE 0x00010ABC REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCSNOK "ROM Const mCCSNOK" VALUE 0x00010AC0 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCLUCMP "ROM Const mCCLUCMP" VALUE 0x00010AC4 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCBRKCMP "ROM Const mCBRKCMP" VALUE 0x00010AC8 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCRUCMP "ROM Const mCCRUCMP" VALUE 0x00010ACC REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCCLSW "ROM Const mCCLSW" VALUE 0x00010AD0 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINHNG6 "ROM Const mCINHNG6" VALUE 0x00010AD4 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINHNG5 "ROM Const mCINHNG5" VALUE 0x00010AD8 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINHNG4 "ROM Const mCINHNG4" VALUE 0x00010ADC REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINHNG3 "ROM Const mCINHNG3" VALUE 0x00010AE0 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINHNG2 "ROM Const mCINHNG2" VALUE 0x00010AE4 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINHNG1 "ROM Const mCINHNG1" VALUE 0x00010AE8 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINLNG6 "ROM Const mCINLNG6" VALUE 0x00010AEC REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINLNG5 "ROM Const mCINLNG5" VALUE 0x00010AF0 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINLNG4 "ROM Const mCINLNG4" VALUE 0x00010AF4 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINLNG3 "ROM Const mCINLNG3" VALUE 0x00010AF8 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINLNG2 "ROM Const mCINLNG2" VALUE 0x00010AFC REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mCINLNG1 "ROM Const mCINLNG1" VALUE 0x00010B00 REC_ULONG_C 0 COMP_0068 0 4294967295 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNOVHEAT "ROM Const mDGNOVHEAT" VALUE 0x00010B06 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCUNG "ROM Const mDGNCUNG" VALUE 0x00010B08 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2CLB1 "ROM Const mDGNO2CLB1" VALUE 0x00010B0A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2CLB2 "ROM Const mDGNO2CLB2" VALUE 0x00010B0C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMF6NG "ROM Const mDGNMF6NG" VALUE 0x00010B0E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMF5NG "ROM Const mDGNMF5NG" VALUE 0x00010B10 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMF4NG "ROM Const mDGNMF4NG" VALUE 0x00010B12 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMF3NG "ROM Const mDGNMF3NG" VALUE 0x00010B14 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMF2NG "ROM Const mDGNMF2NG" VALUE 0x00010B16 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMF1NG "ROM Const mDGNMF1NG" VALUE 0x00010B18 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMFMCNG "ROM Const mDGNMFMCNG" VALUE 0x00010B1A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCAT1NG "ROM Const mDGNCAT1NG" VALUE 0x00010B1C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCAT2NG "ROM Const mDGNCAT2NG" VALUE 0x00010B1E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMRNG "ROM Const mDGNMRNG" VALUE 0x00010B20 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMRNG2 "ROM Const mDGNMRNG2" VALUE 0x00010B22 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTWCLNG "ROM Const mDGNTWCLNG" VALUE 0x00010B24 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNNSNG "ROM Const mDGNNSNG" VALUE 0x00010B26 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVTCSV1 "ROM Const mDGNVTCSV1" VALUE 0x00010B28 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVTCSV2 "ROM Const mDGNVTCSV2" VALUE 0x00010B2A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVIASDN "ROM Const mDGNVIASDN" VALUE 0x00010B2C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDCS1NG "ROM Const mDGNDCS1NG" VALUE 0x00010B2E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDCS2NG "ROM Const mDGNDCS2NG" VALUE 0x00010B30 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDCS3NG "ROM Const mDGNDCS3NG" VALUE 0x00010B32 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDPS1NG "ROM Const mDGNDPS1NG" VALUE 0x00010B34 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDPS2NG "ROM Const mDGNDPS2NG" VALUE 0x00010B36 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDPS3NG "ROM Const mDGNDPS3NG" VALUE 0x00010B38 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNPPSNG "ROM Const mDGNPPSNG" VALUE 0x00010B3A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSYNCNG "ROM Const mDGNSYNCNG" VALUE 0x00010B3C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNALUNG "ROM Const mDGNALUNG" VALUE 0x00010B3E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNQCKNG "ROM Const mDGNQCKNG" VALUE 0x00010B40 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCALCNG "ROM Const mDGNCALCNG" VALUE 0x00010B42 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNADNG "ROM Const mDGNADNG" VALUE 0x00010B44 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNIC3NG "ROM Const mDGNIC3NG" VALUE 0x00010B46 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTPS4NG "ROM Const mDGNTPS4NG" VALUE 0x00010B48 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTHFBNG "ROM Const mDGNTHFBNG" VALUE 0x00010B4A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVAPXNG "ROM Const mDGNVAPXNG" VALUE 0x00010B4C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPOXNG "ROM Const mDGNAPOXNG" VALUE 0x00010B4E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTGTXNG "ROM Const mDGNTGTXNG" VALUE 0x00010B50 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSERVNG "ROM Const mDGNSERVNG" VALUE 0x00010B52 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNASTRNG "ROM Const mDGNASTRNG" VALUE 0x00010B54 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNQHAPNG "ROM Const mDGNQHAPNG" VALUE 0x00010B56 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTEPDNG "ROM Const mDGNTEPDNG" VALUE 0x00010B58 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTATENG "ROM Const mDGNTATENG" VALUE 0x00010B5A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTTEPNG "ROM Const mDGNTTEPNG" VALUE 0x00010B5C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRLONNG "ROM Const mDGNRLONNG" VALUE 0x00010B5E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRLOFNG "ROM Const mDGNRLOFNG" VALUE 0x00010B60 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDTSPNG "ROM Const mDGNDTSPNG" VALUE 0x00010B62 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVSPRNG "ROM Const mDGNVSPRNG" VALUE 0x00010B64 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNBSOFNG "ROM Const mDGNBSOFNG" VALUE 0x00010B66 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRTSPNG "ROM Const mDGNRTSPNG" VALUE 0x00010B68 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDFLTNG "ROM Const mDGNDFLTNG" VALUE 0x00010B6A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTHOPNG "ROM Const mDGNTHOPNG" VALUE 0x00010B6C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNBURNG "ROM Const mDGNBURNG" VALUE 0x00010B6E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSSOFNG "ROM Const mDGNSSOFNG" VALUE 0x00010B70 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTSKNGM "ROM Const mDGNTSKNGM" VALUE 0x00010B72 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNROMNGM "ROM Const mDGNROMNGM" VALUE 0x00010B74 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRAMNGM "ROM Const mDGNRAMNGM" VALUE 0x00010B76 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNWDTNGM "ROM Const mDGNWDTNGM" VALUE 0x00010B78 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTIMNGM "ROM Const mDGNTIMNGM" VALUE 0x00010B7A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNEPWNGM "ROM Const mDGNEPWNGM" VALUE 0x00010B7C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNEPRNGM "ROM Const mDGNEPRNGM" VALUE 0x00010B7E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRANGM2 "ROM Const mDGNRANGM2" VALUE 0x00010B80 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDC21NG "ROM Const mDGNDC21NG" VALUE 0x00010B82 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDC22NG "ROM Const mDGNDC22NG" VALUE 0x00010B84 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNDC23NG "ROM Const mDGNDC23NG" VALUE 0x00010B86 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLNG1 "ROM Const mDGNAFLNG1" VALUE 0x00010B88 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLNG2 "ROM Const mDGNAFLNG2" VALUE 0x00010B8A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLLS "ROM Const mDGNAFLLS" VALUE 0x00010B8C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLRS "ROM Const mDGNAFLRS" VALUE 0x00010B8E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLAV "ROM Const mDGNAFLAV" VALUE 0x00010B90 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRNG1 "ROM Const mDGNAFRNG1" VALUE 0x00010B92 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRNG2 "ROM Const mDGNAFRNG2" VALUE 0x00010B94 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRLS "ROM Const mDGNAFRLS" VALUE 0x00010B96 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRRS "ROM Const mDGNAFRRS" VALUE 0x00010B98 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRAV "ROM Const mDGNAFRAV" VALUE 0x00010B9A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNISCNGL "ROM Const mDGNISCNGL" VALUE 0x00010B9C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNISCNGH "ROM Const mDGNISCNGH" VALUE 0x00010B9E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R1O "ROM Const mDGNO2R1O" VALUE 0x00010BA0 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R2O "ROM Const mDGNO2R2O" VALUE 0x00010BA2 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R1L "ROM Const mDGNO2R1L" VALUE 0x00010BA4 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R2L "ROM Const mDGNO2R2L" VALUE 0x00010BA6 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R1R "ROM Const mDGNO2R1R" VALUE 0x00010BA8 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R2R "ROM Const mDGNO2R2R" VALUE 0x00010BAA REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R1H "ROM Const mDGNO2R1H" VALUE 0x00010BAC REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNO2R2H "ROM Const mDGNO2R2H" VALUE 0x00010BAE REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRO2HH1 "ROM Const mDGNRO2HH1" VALUE 0x00010BB0 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRO2HH2 "ROM Const mDGNRO2HH2" VALUE 0x00010BB2 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRO2HL1 "ROM Const mDGNRO2HL1" VALUE 0x00010BB4 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNRO2HL2 "ROM Const mDGNRO2HL2" VALUE 0x00010BB6 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNKN1NGL "ROM Const mDGNKN1NGL" VALUE 0x00010BB8 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNKN1NGH "ROM Const mDGNKN1NGH" VALUE 0x00010BBA REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNKN2NGL "ROM Const mDGNKN2NGL" VALUE 0x00010BBC REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNKN2NGH "ROM Const mDGNKN2NGH" VALUE 0x00010BBE REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFMNGR "ROM Const mDGNAFMNGR" VALUE 0x00010BC0 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFMNGL "ROM Const mDGNAFMNGL" VALUE 0x00010BC2 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFMNGH "ROM Const mDGNAFMNGH" VALUE 0x00010BC4 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNIGNGR "ROM Const mDGNIGNGR" VALUE 0x00010BC6 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTWNGL "ROM Const mDGNTWNGL" VALUE 0x00010BC8 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTWNGH "ROM Const mDGNTWNGH" VALUE 0x00010BCA REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTANGL "ROM Const mDGNTANGL" VALUE 0x00010BCC REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTANGH "ROM Const mDGNTANGH" VALUE 0x00010BCE REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTANGR "ROM Const mDGNTANGR" VALUE 0x00010BD0 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNEVCNGO "ROM Const mDGNEVCNGO" VALUE 0x00010BD2 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNEVCNGS "ROM Const mDGNEVCNGS" VALUE 0x00010BD4 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTHMNGR "ROM Const mDGNTHMNGR" VALUE 0x00010BD6 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMRNR "ROM Const mDGNMRNR" VALUE 0x00010BD8 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMRNL "ROM Const mDGNMRNL" VALUE 0x00010BDA REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMRNR2 "ROM Const mDGNMRNR2" VALUE 0x00010BDC REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMRNL2 "ROM Const mDGNMRNL2" VALUE 0x00010BDE REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVTCI1R "ROM Const mDGNVTCI1R" VALUE 0x00010BE0 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVTCI2R "ROM Const mDGNVTCI2R" VALUE 0x00010BE2 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNPRSNGL "ROM Const mDGNPRSNGL" VALUE 0x00010BE4 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNPRSNGH "ROM Const mDGNPRSNGH" VALUE 0x00010BE6 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAVCCSH "ROM Const mDGNAVCCSH" VALUE 0x00010BE8 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTP1NGH "ROM Const mDGNTP1NGH" VALUE 0x00010BEA REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTP1NGL "ROM Const mDGNTP1NGL" VALUE 0x00010BEC REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTP2NGH "ROM Const mDGNTP2NGH" VALUE 0x00010BEE REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTP2NGL "ROM Const mDGNTP2NGL" VALUE 0x00010BF0 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTP12NG "ROM Const mDGNTP12NG" VALUE 0x00010BF2 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTPLRLO "ROM Const mDGNTPLRLO" VALUE 0x00010BF4 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNTPLRNO "ROM Const mDGNTPLRNO" VALUE 0x00010BF6 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVMOOPN "ROM Const mDGNVMOOPN" VALUE 0x00010BF8 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVMOSHT "ROM Const mDGNVMOSHT" VALUE 0x00010BFA REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNMOTSHT "ROM Const mDGNMOTSHT" VALUE 0x00010BFC REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLHZR "ROM Const mDGNAFLHZR" VALUE 0x00010BFE REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLHZL "ROM Const mDGNAFLHZL" VALUE 0x00010C00 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRHZR "ROM Const mDGNAFRHZR" VALUE 0x00010C02 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRHZL "ROM Const mDGNAFRHZL" VALUE 0x00010C04 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFHF1L "ROM Const mDGNAFHF1L" VALUE 0x00010C06 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFHF1H "ROM Const mDGNAFHF1H" VALUE 0x00010C08 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFHF2L "ROM Const mDGNAFHF2L" VALUE 0x00010C0A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFHF2H "ROM Const mDGNAFHF2H" VALUE 0x00010C0C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRLD1 "ROM Const mDGNAFRLD1" VALUE 0x00010C0E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLRD1 "ROM Const mDGNAFLRD1" VALUE 0x00010C10 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFRLD2 "ROM Const mDGNAFRLD2" VALUE 0x00010C12 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAFLRD2 "ROM Const mDGNAFLRD2" VALUE 0x00010C14 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPSC "ROM Const mDGNAPSC" VALUE 0x00010C16 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPSOC1 "ROM Const mDGNAPSOC1" VALUE 0x00010C18 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPSSC1 "ROM Const mDGNAPSSC1" VALUE 0x00010C1A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPSOC2 "ROM Const mDGNAPSOC2" VALUE 0x00010C1C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPSSC2 "ROM Const mDGNAPSSC2" VALUE 0x00010C1E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAP12 "ROM Const mDGNAP12" VALUE 0x00010C20 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPCHR "ROM Const mDGNAPCHR" VALUE 0x00010C22 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPSC1 "ROM Const mDGNAPSC1" VALUE 0x00010C24 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAVCC1 "ROM Const mDGNAVCC1" VALUE 0x00010C26 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAVCC2 "ROM Const mDGNAVCC2" VALUE 0x00010C28 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNPRSSC "ROM Const mDGNPRSSC" VALUE 0x00010C2A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNPRSOC "ROM Const mDGNPRSOC" VALUE 0x00010C2C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNUPCRCV "ROM Const mDGNUPCRCV" VALUE 0x00010C2E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAPMUX "ROM Const mDGNAPMUX" VALUE 0x00010C30 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNESPLNK "ROM Const mDGNESPLNK" VALUE 0x00010C32 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAGBLNK "ROM Const mDGNAGBLNK" VALUE 0x00010C34 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAGBCLK "ROM Const mDGNAGBCLK" VALUE 0x00010C36 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNESPCPL "ROM Const mDGNESPCPL" VALUE 0x00010C38 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNESPCLK "ROM Const mDGNESPCLK" VALUE 0x00010C3A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAGBDLY "ROM Const mDGNAGBDLY" VALUE 0x00010C3C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNAGBINT "ROM Const mDGNAGBINT" VALUE 0x00010C3E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCSCHR "ROM Const mDGNCSCHR" VALUE 0x00010C40 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCSTOT "ROM Const mDGNCSTOT" VALUE 0x00010C42 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNVSCMP "ROM Const mDGNVSCMP" VALUE 0x00010C44 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCSOOR "ROM Const mDGNCSOOR" VALUE 0x00010C46 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCSOCS "ROM Const mDGNCSOCS" VALUE 0x00010C48 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCSNOK "ROM Const mDGNCSNOK" VALUE 0x00010C4A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCLUCMP "ROM Const mDGNCLUCMP" VALUE 0x00010C4C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNBRKCMP "ROM Const mDGNBRKCMP" VALUE 0x00010C4E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCRUCMP "ROM Const mDGNCRUCMP" VALUE 0x00010C50 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNCLSW "ROM Const mDGNCLSW" VALUE 0x00010C52 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINHNG6 "ROM Const mDGNINHNG6" VALUE 0x00010C54 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINHNG5 "ROM Const mDGNINHNG5" VALUE 0x00010C56 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINHNG4 "ROM Const mDGNINHNG4" VALUE 0x00010C58 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINHNG3 "ROM Const mDGNINHNG3" VALUE 0x00010C5A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINHNG2 "ROM Const mDGNINHNG2" VALUE 0x00010C5C REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINHNG1 "ROM Const mDGNINHNG1" VALUE 0x00010C5E REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINLNG6 "ROM Const mDGNINLNG6" VALUE 0x00010C60 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINLNG5 "ROM Const mDGNINLNG5" VALUE 0x00010C62 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINLNG4 "ROM Const mDGNINLNG4" VALUE 0x00010C64 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINLNG3 "ROM Const mDGNINLNG3" VALUE 0x00010C66 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINLNG2 "ROM Const mDGNINLNG2" VALUE 0x00010C68 REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNINLNG1 "ROM Const mDGNINLNG1" VALUE 0x00010C6A REC_UWORD_C 0 COMP_0091 0 65535 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[0] "Flag mDGNSW[0]" VALUE 0x0001020C REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[1] "Flag mDGNSW[1]" VALUE 0x0001020D REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[2] "Flag mDGNSW[2]" VALUE 0x0001020E REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[3] "Flag mDGNSW[3]" VALUE 0x0001020F REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[6] "Flag mDGNSW[6]" VALUE 0x00010212 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[8] "Flag mDGNSW[8]" VALUE 0x00010214 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[9] "Flag mDGNSW[9]" VALUE 0x00010215 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[13] "Flag mDGNSW[13]" VALUE 0x00010219 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[14] "Flag mDGNSW[14]" VALUE 0x0001021A REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[15] "Flag mDGNSW[15]" VALUE 0x0001021B REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[18] "Flag mDGNSW[18]" VALUE 0x0001021E REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[19] "Flag mDGNSW[19]" VALUE 0x0001021F REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[20] "Flag mDGNSW[20]" VALUE 0x00010220 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[23] "Flag mDGNSW[23]" VALUE 0x00010223 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[24] "Flag mDGNSW[24]" VALUE 0x00010224 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[26] "Flag mDGNSW[26]" VALUE 0x00010226 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[27] "Flag mDGNSW[27]" VALUE 0x00010227 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[30] "Flag mDGNSW[30]" VALUE 0x0001022A REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[31] "Flag mDGNSW[31]" VALUE 0x0001022B REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[35] "Flag mDGNSW[35]" VALUE 0x0001022F REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[36] "Flag mDGNSW[36]" VALUE 0x00010230 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[37] "Flag mDGNSW[37]" VALUE 0x00010231 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[38] "Flag mDGNSW[38]" VALUE 0x00010232 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[42] "Flag mDGNSW[42]" VALUE 0x00010236 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[43] "Flag mDGNSW[43]" VALUE 0x00010237 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[44] "Flag mDGNSW[44]" VALUE 0x00010238 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[48] "Flag mDGNSW[48]" VALUE 0x0001023C REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[49] "Flag mDGNSW[49]" VALUE 0x0001023D REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[50] "Flag mDGNSW[50]" VALUE 0x0001023E REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[51] "Flag mDGNSW[51]" VALUE 0x0001023F REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[52] "Flag mDGNSW[52]" VALUE 0x00010240 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[53] "Flag mDGNSW[53]" VALUE 0x00010241 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[54] "Flag mDGNSW[54]" VALUE 0x00010242 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[55] "Flag mDGNSW[55]" VALUE 0x00010243 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[56] "Flag mDGNSW[56]" VALUE 0x00010244 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[57] "Flag mDGNSW[57]" VALUE 0x00010245 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[58] "Flag mDGNSW[58]" VALUE 0x00010246 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[59] "Flag mDGNSW[59]" VALUE 0x00010247 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[60] "Flag mDGNSW[60]" VALUE 0x00010248 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[61] "Flag mDGNSW[61]" VALUE 0x00010249 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[62] "Flag mDGNSW[62]" VALUE 0x0001024A REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[68] "Flag mDGNSW[68]" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPSC "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPSOC1 "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPSSC1 "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPSOC2 "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPSSC2 "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAP12 "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPCHR "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPSC1 "0:Not DGN  1:DGN" VALUE 0x00010250 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[69] "Flag mDGNSW[69]" VALUE 0x00010251 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAVCC1 "0:Not DGN  1:DGN" VALUE 0x00010251 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAVCC2 "0:Not DGN  1:DGN" VALUE 0x00010251 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfPRSSC "0:Not DGN  1:DGN" VALUE 0x00010251 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfPRSOC "0:Not DGN  1:DGN" VALUE 0x00010251 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfUPCRCV "0:Not DGN  1:DGN" VALUE 0x00010251 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAPMUX "0:Not DGN  1:DGN" VALUE 0x00010251 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[70] "Flag mDGNSW[70]" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfESPLNK "0:Not DGN  1:DGN" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAGBLNK "0:Not DGN  1:DGN" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAGBCLK "0:Not DGN  1:DGN" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfESPCPL "0:Not DGN  1:DGN" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfESPCLK "0:Not DGN  1:DGN" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAGBDLY "0:Not DGN  1:DGN" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfAGBINT "0:Not DGN  1:DGN" VALUE 0x00010252 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[71] "Flag mDGNSW[71]" VALUE 0x00010253 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfCSCHR "0:Not DGN  1:DGN" VALUE 0x00010253 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfCSTOT "0:Not DGN  1:DGN" VALUE 0x00010253 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfVSCMP "0:Not DGN  1:DGN" VALUE 0x00010253 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfCSOOR "0:Not DGN  1:DGN" VALUE 0x00010253 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfCSOCS "0:Not DGN  1:DGN" VALUE 0x00010253 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfCSNOK "0:Not DGN  1:DGN" VALUE 0x00010253 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfCLUCMP "0:Not DGN  1:DGN" VALUE 0x00010254 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfBRKCMP "0:Not DGN  1:DGN" VALUE 0x00010254 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfCRUCMP "0:Not DGN  1:DGN" VALUE 0x00010254 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[73] "Flag mDGNSW[73]" VALUE 0x00010255 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINHNG6 "0:Not DGN  1:DGN" VALUE 0x00010255 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINHNG5 "0:Not DGN  1:DGN" VALUE 0x00010255 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINHNG4 "0:Not DGN  1:DGN" VALUE 0x00010255 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINHNG3 "0:Not DGN  1:DGN" VALUE 0x00010255 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINHNG2 "0:Not DGN  1:DGN" VALUE 0x00010255 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINHNG1 "0:Not DGN  1:DGN" VALUE 0x00010255 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mDGNSW[74] "Flag mDGNSW[74]" VALUE 0x00010256 REC_UBYTE_C 0 COMP_0283 0 255 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINLNG6 "0:Not DGN  1:DGN" VALUE 0x00010256 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINLNG5 "0:Not DGN  1:DGN" VALUE 0x00010256 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINLNG4 "0:Not DGN  1:DGN" VALUE 0x00010256 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINLNG3 "0:Not DGN  1:DGN" VALUE 0x00010256 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINLNG2 "0:Not DGN  1:DGN" VALUE 0x00010256 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfINLNG1 "0:Not DGN  1:DGN" VALUE 0x00010256 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFMNG "0:Not GST  1:GST" VALUE 0x0000C9B8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTWNG "0:Not GST  1:GST" VALUE 0x0000C9B8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVSPNG "0:Not GST  1:GST" VALUE 0x0000C9B8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGIGNG "0:Not GST  1:GST" VALUE 0x0000C9B9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGISCNG "0:Not GST  1:GST" VALUE 0x0000C9B9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGOVHEAT "0:Not GST  1:GST" VALUE 0x0000C9B9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCUNG "0:Not GST  1:GST" VALUE 0x0000C9BA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGKNKNG "0:Not GST  1:GST" VALUE 0x0000C9BA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2CLB1 "0:Not GST  1:GST" VALUE 0x0000C9BA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2CLB2 "0:Not GST  1:GST" VALUE 0x0000C9BA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTANG "0:Not GST  1:GST" VALUE 0x0000C9BB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMF6NG "0:Not GST  1:GST" VALUE 0x0000C9BD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMF5NG "0:Not GST  1:GST" VALUE 0x0000C9BD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMF4NG "0:Not GST  1:GST" VALUE 0x0000C9BD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMF3NG "0:Not GST  1:GST" VALUE 0x0000C9BD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMF2NG "0:Not GST  1:GST" VALUE 0x0000C9BD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMF1NG "0:Not GST  1:GST" VALUE 0x0000C9BD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMFMCNG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCAT1NG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCAT2NG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEPRSNG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVPNG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1NG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2NG "0:Not GST  1:GST" VALUE 0x0000C9BE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGPRESNG "0:Not GST  1:GST" VALUE 0x0000C9BF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNG2 "0:Not GST  1:GST" VALUE 0x0000C9BF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2HR1 "0:Not GST  1:GST" VALUE 0x0000C9C0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCDCNG "0:Not GST  1:GST" VALUE 0x0000C9C0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTWCLNG "0:Not GST  1:GST" VALUE 0x0000C9C0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2HR2 "0:Not GST  1:GST" VALUE 0x0000C9C1 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGNSNG "0:Not GST  1:GST" VALUE 0x0000C9C1 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVCNNG "0:Not GST  1:GST" VALUE 0x0000C9C1 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVPSYS "0:Not GST  1:GST" VALUE 0x0000C9C6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNGR "0:Not GST  1:GST" VALUE 0x0000C9C6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNGL "0:Not GST  1:GST" VALUE 0x0000C9C6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVPNG3 "0:Not GST  1:GST" VALUE 0x0000C9C6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNGR2 "0:Not GST  1:GST" VALUE 0x0000C9C7 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNGL2 "0:Not GST  1:GST" VALUE 0x0000C9C7 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGKNKNG2 "0:Not GST  1:GST" VALUE 0x0000C9C7 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVPNG2 "0:Not GST  1:GST" VALUE 0x0000C9C7 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2RO "0:Not GST  1:GST" VALUE 0x0000C9C8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2LO "0:Not GST  1:GST" VALUE 0x0000C9C8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2AV "0:Not GST  1:GST" VALUE 0x0000C9C8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1RO "0:Not GST  1:GST" VALUE 0x0000C9CA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1LO "0:Not GST  1:GST" VALUE 0x0000C9CA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1AV "0:Not GST  1:GST" VALUE 0x0000C9CA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGISCDN "0:Not GST  1:GST" VALUE 0x0000C9CA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTHMNG "0:Not GST  1:GST" VALUE 0x0000C9CA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCSV1 "0:Not GST  1:GST" VALUE 0x0000C9CB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCSV2 "0:Not GST  1:GST" VALUE 0x0000C9CB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVIASDN "0:Not GST  1:GST" VALUE 0x0000C9CC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVP2NG "0:Not GST  1:GST" VALUE 0x0000C9CF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDCS1NG "0:Not GST  1:GST" VALUE 0x0000C9D0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDCS2NG "0:Not GST  1:GST" VALUE 0x0000C9D0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDCS3NG "0:Not GST  1:GST" VALUE 0x0000C9D0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDPS1NG "0:Not GST  1:GST" VALUE 0x0000C9D0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDPS2NG "0:Not GST  1:GST" VALUE 0x0000C9D0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDPS3NG "0:Not GST  1:GST" VALUE 0x0000C9D0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGPPSNG "0:Not GST  1:GST" VALUE 0x0000C9D2 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGSYNCNG "0:Not GST  1:GST" VALUE 0x0000C9D3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGALUNG "0:Not GST  1:GST" VALUE 0x0000C9D3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGQCKNG "0:Not GST  1:GST" VALUE 0x0000C9D3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCALCNG "0:Not GST  1:GST" VALUE 0x0000C9D3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGADNG "0:Not GST  1:GST" VALUE 0x0000C9D3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGIC3NG "0:Not GST  1:GST" VALUE 0x0000C9D3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTPS4NG "0:Not GST  1:GST" VALUE 0x0000C9D7 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTHFBNG "0:Not GST  1:GST" VALUE 0x0000C9D8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVAPXNG "0:Not GST  1:GST" VALUE 0x0000C9D8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPOXNG "0:Not GST  1:GST" VALUE 0x0000C9D8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTGTXNG "0:Not GST  1:GST" VALUE 0x0000C9D8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGSERVNG "0:Not GST  1:GST" VALUE 0x0000C9D8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGASTRNG "0:Not GST  1:GST" VALUE 0x0000C9D8 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGQHAPNG "0:Not GST  1:GST" VALUE 0x0000C9D9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTEPDNG "0:Not GST  1:GST" VALUE 0x0000C9D9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTATENG "0:Not GST  1:GST" VALUE 0x0000C9D9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTTEPNG "0:Not GST  1:GST" VALUE 0x0000C9D9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRLONNG "0:Not GST  1:GST" VALUE 0x0000C9DA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRLOFNG "0:Not GST  1:GST" VALUE 0x0000C9DA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDTSPNG "0:Not GST  1:GST" VALUE 0x0000C9DA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVSPRNG "0:Not GST  1:GST" VALUE 0x0000C9DA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGBSOFNG "0:Not GST  1:GST" VALUE 0x0000C9DB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRTSPNG "0:Not GST  1:GST" VALUE 0x0000C9DC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDFLTNG "0:Not GST  1:GST" VALUE 0x0000C9DC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTHOPNG "0:Not GST  1:GST" VALUE 0x0000C9DC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGBURNG "0:Not GST  1:GST" VALUE 0x0000C9DC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGSSOFNG "0:Not GST  1:GST" VALUE 0x0000C9DC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTSKNGM "0:Not GST  1:GST" VALUE 0x0000C9DC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGROMNGM "0:Not GST  1:GST" VALUE 0x0000C9DD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRAMNGM "0:Not GST  1:GST" VALUE 0x0000C9DD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGWDTNGM "0:Not GST  1:GST" VALUE 0x0000C9DD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTIMNGM "0:Not GST  1:GST" VALUE 0x0000C9DD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEPWNGM "0:Not GST  1:GST" VALUE 0x0000C9DD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEPRNGM "0:Not GST  1:GST" VALUE 0x0000C9DD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRANGM2 "0:Not GST  1:GST" VALUE 0x0000C9DE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCOF1 "0:Not GST  1:GST" VALUE 0x0000C9DF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCOF2 "0:Not GST  1:GST" VALUE 0x0000C9DF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCDR1 "0:Not GST  1:GST" VALUE 0x0000C9DF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCDR2 "0:Not GST  1:GST" VALUE 0x0000C9DF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTOFE1 "0:Not GST  1:GST" VALUE 0x0000C9E1 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTOFE2 "0:Not GST  1:GST" VALUE 0x0000C9E1 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTDRE1 "0:Not GST  1:GST" VALUE 0x0000C9E1 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTDRE2 "0:Not GST  1:GST" VALUE 0x0000C9E1 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDC21NG "0:Not GST  1:GST" VALUE 0x0000C9E2 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDC22NG "0:Not GST  1:GST" VALUE 0x0000C9E2 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGDC23NG "0:Not GST  1:GST" VALUE 0x0000C9E2 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLNG1 "0:Not GST  1:GST" VALUE 0x0000C9E3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLNG2 "0:Not GST  1:GST" VALUE 0x0000C9E3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLLS "0:Not GST  1:GST" VALUE 0x0000C9E3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLRS "0:Not GST  1:GST" VALUE 0x0000C9E3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLHZ "0:Not GST  1:GST" VALUE 0x0000C9E3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLAV "0:Not GST  1:GST" VALUE 0x0000C9E3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFHF1 "0:Not GST  1:GST" VALUE 0x0000C9E3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRNG1 "0:Not GST  1:GST" VALUE 0x0000C9E4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRNG2 "0:Not GST  1:GST" VALUE 0x0000C9E4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRLS "0:Not GST  1:GST" VALUE 0x0000C9E4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRRS "0:Not GST  1:GST" VALUE 0x0000C9E4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRHZ "0:Not GST  1:GST" VALUE 0x0000C9E4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRAV "0:Not GST  1:GST" VALUE 0x0000C9E4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFHF2 "0:Not GST  1:GST" VALUE 0x0000C9E4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGISCNGL "0:Not GST  1:GST" VALUE 0x0000C9E9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGISCNGH "0:Not GST  1:GST" VALUE 0x0000C9E9 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1O "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2O "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1L "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2L "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1R "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2R "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R1H "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGO2R2H "0:Not GST  1:GST" VALUE 0x0000C9EA REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRO2HH1 "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRO2HH2 "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRO2HL1 "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGRO2HL2 "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGKN1NGL "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGKN1NGH "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGKN2NGL "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGKN2NGH "0:Not GST  1:GST" VALUE 0x0000C9EB REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFMNGR "0:Not GST  1:GST" VALUE 0x0000C9EC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFMNGL "0:Not GST  1:GST" VALUE 0x0000C9EC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFMNGH "0:Not GST  1:GST" VALUE 0x0000C9EC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGIGNGR "0:Not GST  1:GST" VALUE 0x0000C9EC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTWNGL "0:Not GST  1:GST" VALUE 0x0000C9ED REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTWNGH "0:Not GST  1:GST" VALUE 0x0000C9ED REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTANGL "0:Not GST  1:GST" VALUE 0x0000C9ED REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTANGH "0:Not GST  1:GST" VALUE 0x0000C9ED REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTANGR "0:Not GST  1:GST" VALUE 0x0000C9ED REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVCNGO "0:Not GST  1:GST" VALUE 0x0000C9EE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGEVCNGS "0:Not GST  1:GST" VALUE 0x0000C9EE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTHMNGR "0:Not GST  1:GST" VALUE 0x0000C9EE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNR "0:Not GST  1:GST" VALUE 0x0000C9EF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNL "0:Not GST  1:GST" VALUE 0x0000C9EF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNR2 "0:Not GST  1:GST" VALUE 0x0000C9EF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMRNL2 "0:Not GST  1:GST" VALUE 0x0000C9EF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCI1R "0:Not GST  1:GST" VALUE 0x0000C9EF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVTCI2R "0:Not GST  1:GST" VALUE 0x0000C9EF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGPRSNGL "0:Not GST  1:GST" VALUE 0x0000C9F0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGPRSNGH "0:Not GST  1:GST" VALUE 0x0000C9F0 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAVCCSH "0:Not GST  1:GST" VALUE 0x0000C9F2 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTP1NGH "0:Not GST  1:GST" VALUE 0x0000C9F3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTP1NGL "0:Not GST  1:GST" VALUE 0x0000C9F3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTP2NGH "0:Not GST  1:GST" VALUE 0x0000C9F3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTP2NGL "0:Not GST  1:GST" VALUE 0x0000C9F3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTP12NG "0:Not GST  1:GST" VALUE 0x0000C9F3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTPLRLO "0:Not GST  1:GST" VALUE 0x0000C9F3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGTPLRNO "0:Not GST  1:GST" VALUE 0x0000C9F3 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVMOOPN "0:Not GST  1:GST" VALUE 0x0000C9F4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVMOSHT "0:Not GST  1:GST" VALUE 0x0000C9F4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGMOTSHT "0:Not GST  1:GST" VALUE 0x0000C9F4 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLHZR "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLHZL "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRHZR "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRHZL "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFHF1L "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFHF1H "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFHF2L "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFHF2H "0:Not GST  1:GST" VALUE 0x0000C9F5 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRLD1 "0:Not GST  1:GST" VALUE 0x0000C9F6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLRD1 "0:Not GST  1:GST" VALUE 0x0000C9F6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFRLD2 "0:Not GST  1:GST" VALUE 0x0000C9F6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAFLRD2 "0:Not GST  1:GST" VALUE 0x0000C9F6 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPSC "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPSOC1 "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPSSC1 "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPSOC2 "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPSSC2 "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAP12 "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPCHR "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPSC1 "0:Not GST  1:GST" VALUE 0x0000C9FC REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAVCC1 "0:Not GST  1:GST" VALUE 0x0000C9FD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAVCC2 "0:Not GST  1:GST" VALUE 0x0000C9FD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGPRSSC "0:Not GST  1:GST" VALUE 0x0000C9FD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGPRSOC "0:Not GST  1:GST" VALUE 0x0000C9FD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGUPCRCV "0:Not GST  1:GST" VALUE 0x0000C9FD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAPMUX "0:Not GST  1:GST" VALUE 0x0000C9FD REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0001 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGESPLNK "0:Not GST  1:GST" VALUE 0x0000C9FE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAGBLNK "0:Not GST  1:GST" VALUE 0x0000C9FE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAGBCLK "0:Not GST  1:GST" VALUE 0x0000C9FE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGESPCPL "0:Not GST  1:GST" VALUE 0x0000C9FE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGESPCLK "0:Not GST  1:GST" VALUE 0x0000C9FE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAGBDLY "0:Not GST  1:GST" VALUE 0x0000C9FE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGAGBINT "0:Not GST  1:GST" VALUE 0x0000C9FE REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0002 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCSCHR "0:Not GST  1:GST" VALUE 0x0000C9FF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCSTOT "0:Not GST  1:GST" VALUE 0x0000C9FF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGVSCMP "0:Not GST  1:GST" VALUE 0x0000C9FF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCSOOR "0:Not GST  1:GST" VALUE 0x0000C9FF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCSOCS "0:Not GST  1:GST" VALUE 0x0000C9FF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCSNOK "0:Not GST  1:GST" VALUE 0x0000C9FF REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCLUCMP "0:Not GST  1:GST" VALUE 0x0000CA00 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGBRKCMP "0:Not GST  1:GST" VALUE 0x0000CA00 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCRUCMP "0:Not GST  1:GST" VALUE 0x0000CA00 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGCLSW "0:Not GST  1:GST" VALUE 0x0000CA00 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINHNG6 "0:Not GST  1:GST" VALUE 0x0000CA01 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINHNG5 "0:Not GST  1:GST" VALUE 0x0000CA01 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINHNG4 "0:Not GST  1:GST" VALUE 0x0000CA01 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINHNG3 "0:Not GST  1:GST" VALUE 0x0000CA01 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINHNG2 "0:Not GST  1:GST" VALUE 0x0000CA01 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINHNG1 "0:Not GST  1:GST" VALUE 0x0000CA01 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINLNG6 "0:Not GST  1:GST" VALUE 0x0000CA02 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0080 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINLNG5 "0:Not GST  1:GST" VALUE 0x0000CA02 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0040 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINLNG4 "0:Not GST  1:GST" VALUE 0x0000CA02 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0020 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINLNG3 "0:Not GST  1:GST" VALUE 0x0000CA02 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0010 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINLNG2 "0:Not GST  1:GST" VALUE 0x0000CA02 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0008 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/begin CHARACTERISTIC mfGINLNG1 "0:Not GST  1:GST" VALUE 0x0000CA02 REC_UBYTE_C 0 COMP_0283 0 1 BIT_MASK 0x0004 /begin FUNCTION_LIST /end FUNCTION_LIST /end CHARACTERISTIC
/* MEASUREMENT --------------------------------------------------------- */
/begin MEASUREMENT fABFADJ "0:É…ì_ï‚ê≥íléZèoèàóùñ¢óπ  1:É…ì_ï‚ê≥íléZèoèàóùèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3885 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACONOFF "0:ÉGÉAÉRÉìÇnÇeÇeîªíË  1:ÉGÉAÉRÉìÇnÇmîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF10EA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFAV "0:îRóøÉäÉJÉoÅ[éûêfífóÃàÊèåèÇîªíË  1:îRóøÉäÉJÉoÅ[éûêfífóÃàÊèåèÇîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1113 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFAVCAL "0:ëOA/Fæ›ªíÜä‘ìdà åÃè·êfífÇçsÇÌÇ»  1:ëOA/Fæ›ªíÜä‘ìdà åÃè·êfífÇçsÇ§" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1112 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFBINT "0:èâä˙âªçœÇ›Ç≈ÇÕñ≥Ç¢  1:èâä˙âªçœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1114 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFHCONT "0:ïsê¨óß  1:À∞¿-êßå‰ãñâ¬èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF896A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfAFHCONT "0:ïsê¨óß  1:À∞¿-êßå‰ãñâ¬èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF88DE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFHZ "0:îRóøÉäÉJÉoÅ[éûêfífóÃàÊèåèÇîªíË  1:îRóøÉäÉJÉoÅ[éûêfífóÃàÊèåèÇîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1116 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFHZCAL "0:ëOA/Fæ›ªÿØ¡Å®ÿ∞›âûìöêfífÇçsÇÌÇ»  1:ëOA/Fæ›ªÿØ¡Å®ÿ∞›âûìöêfífÇçsÇ§" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1115 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFLREND "0:ëOA/Fæ›ªâûìöóÚâªêfífñ¢èIóπ(ÿØ¡Å®  1:ëOA/Fæ›ªâûìöóÚâªêfífèIóπ(ÿØ¡Å®ÿ∞" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27B7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFLSTRP "0:A/Fæ›ªºÃƒêfífÿ∞›ºÃƒêfífTRIPñ¢îª  1:A/Fæ›ªºÃƒêfífÿ∞›ºÃƒêfífTRIPîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27B8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFOFLG "0:A/Fæ›ªífê¸êfífGSTèoóÕ√ﬁ∞¿çXêVâ¬  1:A/Fæ›ªífê¸êfífGSTèoóÕ√ﬁ∞¿çXêVïs" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27B9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFOHONO "0:å„O2æ›ªÇÃÀ∞¿Ç™ç≈èâÇ©ÇÁÇnÇmÇ≈Ç»Ç¢  1:å„O2æ›ªÇÃÀ∞¿Ç™ç≈èâÇ…ÇnÇmÇ…Ç»Ç¡ÇΩ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27BA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFOK "0:A/Fæ›ªífê¸êfífê≥èÌéûGSTèoóÕ√ﬁ∞¿  1:A/Fæ›ªífê¸êfífê≥èÌéûGSTèoóÕ√ﬁ∞¿" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27BB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFPRSTM "0:éÊìæïsâ¬  1:éÊìæâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27BE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFRLEND "0:ëOA/Fæ›ªâûìöóÚâªêfífñ¢èIóπ(ÿ∞›Å®  1:ëOA/Fæ›ªâûìöóÚâªêfífèIóπ(ÿ∞›Å®ÿØ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27C0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFRO2INT "0:A/Fæ›ªºΩ√—ópÿ±O2ìdà≥äàê´îÒåoå±  1:A/Fæ›ªºΩ√—ópÿ±O2ìdà≥äàê´åoå±çœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF111C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFRSTRP "0:A/Fæ›ªºÃƒêfífÿØ¡ºÃƒêfífTRIPñ¢îª  1:A/Fæ›ªºÃƒêfífÿØ¡ºÃƒêfífTRIPîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27C1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFSACTM "0:A/Fæ›ªäàê´îªíËÇ»Çµ  1:A/Fæ›ªäàê´îªíËÇ†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27C2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFSAVEND "0:ëOA/Fæ›ªíÜä‘ìdà êfífñ¢èIóπ  1:ëOA/Fæ›ªíÜä‘ìdà êfífèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF27CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFSTJ "0:ÉäÅ[ÉìÅ®ÉäÉbÉ`âûìöóÚâªêfífóÃàÊè  1:ÉäÅ[ÉìÅ®ÉäÉbÉ`âûìöóÚâªêfífóÃàÊè" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1120 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALEV16 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF112A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALNEND "0:ëSàÊîΩâfêßå‰ñ¢é¿çs  1:ëSàÊîΩâfêßå‰çœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF281C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALNJDG "0:ãñâ¬èåèïsê¨óß  1:ãñâ¬èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF112B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALPCLP "0:ñ¢éZèo  1:éZèoçœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1136 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALPLIM "0:ALPHAÇ™É…∫›ÇÃALPHAè„â∫å¿ílÇ…Ç»Ç¡  1:ALPHAÇ™É…∫›ÇÃALPHAè„â∫å¿ílÇ…Ç»Ç¡" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1149 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALRNOKL "0:ëSàÊîΩâfêßå‰ÿ∞›èåèïsê¨óß  1:ëSàÊîΩâfêßå‰ÿ∞›èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF114C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALRNOKR "0:ëSàÊîΩâfêßå‰ÿØ¡èåèïsê¨óß  1:ëSàÊîΩâfêßå‰ÿØ¡èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF114D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fARADLY "0:îÒÉfÉBÉåÉCíÜ  1:ÉfÉBÉåÉCíÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF287C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fARAJBF "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF287D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fARAJUG "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF287E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAVGAFH1 "0:ê›íËëO  1:èâä˙ílê›íËå„" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF392C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBPRAM1 "0:Ω√∞ºﬁ1êfíf ﬂ◊“∞¿ ﬁØ∏±ØÃﬂñ¢äÆ  1:Ω√∞ºﬁ1êfíf ﬂ◊“∞¿ ﬁØ∏±ØÃﬂäÆóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF392E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBSLRNOK "0:èåèïsê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF11CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCATAR2 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2948 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCATARA "0:êGî}êfífèåèñ¢åoå±  1:êGî}êfífèåèåoå±" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF294A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCATEND "0:êfífñ¢èIóπ  1:êfífèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF294D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCATENDV "0:êfífñ¢èIóπ  1:êfífèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF294E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCATJUG "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2950 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCATST2 "0:âEãLà»äO  1:ÉXÉeÅ[ÉW2êfífÇ÷à⁄çs" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2956 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCPCJUG "0:CPCïsãñâ¬  1:CPCãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3ABC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCTOPHS "0:DOSÉfÅ[É^èâä˙âªñ¢  1:DOSÉfÅ[É^èâä˙âªçœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1208 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCVTCCHK "0:CVTCÅ@LO  1:CVTCÅ@HI" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4915 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCVTCCHK "0:CVTCÅ@LO  1:CVTCÅ@HI" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4813 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDCALP "0:âEãLà»äO  1:å∏ë¨ÿ∞›∏◊›ÃﬂíÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1242 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDCLSTJ "0:âÒì]√ﬁ®⁄≤ë“Çøà»äO  1:âÒì]√ﬁ®⁄≤ë“Çø" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1243 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDCTCNTOK "0:DCTCNT( ﬁ›∏ëŒâû)∂≥›ƒÇµÇ»Ç¢  1:DCTCNT( ﬁ›∏ëŒâû)∂≥›ƒÇ∑ÇÈ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2A25 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDLTDEGI0 "0:èÌÇ…DLTDEGI(n)<0ñîÇÕDLTDEGI(n)>=  1:èÌÇ…DLTDEGI(n)<0ñîÇÕDLTDEGI(n)>=" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1275 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDLTVRO2 "0:å„O2/SêfífÉpÉâÉÅÅ[É^éÊìæã÷é~  1:å„O2/SêfífÉpÉâÉÅÅ[É^éÊìæãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2A7A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDOSLN1 "0:PHOSââéZèåèïsê¨óß  1:PHOSââéZèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1292 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDOSPHS "0:DOS/PHOSââéZèåèñ¢åoå±  1:DOS/PHOSââéZèåèåoå±" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2A8A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDRTDESE "0:ãñâ¬  1:ã÷é~" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1293 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDRTDESI "0:ãñâ¬  1:ã÷é~" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1294 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fELNTIM "0:mNLRCâÒîΩì]ÇµÇƒÇ¢Ç»Ç¢  1:mNLRCâÒîΩì]ÇµÇƒÇ¢ÇÈ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF12D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fERRJOK "0:ñ¢îªíË  1:ê≥èÌîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2B62 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fERRJOKE "0:ñ¢îªíË  1:ê≥èÌîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2B61 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fERRJOKI "0:ñ¢îªíË  1:ê≥èÌîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2B63 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fERRORE "0:ê≥èÌ  1:àŸèÌ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF12F8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fERRORI "0:ê≥èÌ  1:àŸèÌ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF12FC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fERRSE2M "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF12FD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fERRSI2M "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF12FE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fEVMON4 "0:ã÷é~  1:äJén" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1340 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT bfEVPCLR "0:EVPCNT∏ÿ±óvãÅñ≥  1:EVPCNT∏ÿ±óvãÅóL" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF22C1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFADDBTIM "0:ñ¢æØƒ  1:æØƒçœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1359 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFAFHCN "0:A/FÀ∞¿êfífîªíËƒÿØÃﬂñ¢îªíË  1:A/FÀ∞¿êfífîªíËƒÿØÃﬂä˘îªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2CEF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFAFHMLOK "0:A/FÀ∞¿êfífê≥èÌèIóπñ¢èIóπ  1:A/FÀ∞¿êfífê≥èÌèIóπèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2CF2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFAFLOK "0:A./Fæ›ªºÃƒêfífÿ∞›ºÃƒOKîªíËñ¢éØï   1:A./Fæ›ªºÃƒêfífÿ∞›ºÃƒOKîªíËéØï " UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA3B1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFAFMLOK "0:A/Fæ›ªêfífOKñ¢èIóπ  1:A/Fæ›ªêfífOKèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2CF3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFAFROK "0:A./Fæ›ªºÃƒêfífÿØ¡ºÃƒOKîªíËñ¢éØï   1:A./Fæ›ªºÃƒêfífÿØ¡ºÃƒOKîªíËéØï " UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA3B9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFBPSNGI "0:VTCäÓèÄäpìxà íuê≥èÌ  1:VTCäÓèÄäpìxà íuàŸèÌ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1361 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT bfFBSLTD "0:Õﬁ∞ΩäwèKñ¢é˚ë©  1:Õﬁ∞ΩäwèKé˚ë©" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF40AC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFBSLTDBU "0:Õﬁ∞ΩäwèKé˚ë©åoå±ñ≥  1:Õﬁ∞ΩäwèKé˚ë©åoå±óL" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA3BC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFBSLTDM "0:Õﬁ∞ΩäwèKñ¢é˚ë©ÇµÇƒÇ»Ç¢  1:Õﬁ∞ΩäwèKé˚ë©ÇµÇΩ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2CFA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT bfFBSRYO "0:óÃàÊì‡  1:óÃàÊäO" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF22C3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFCCUPD "0:å„O2/S F/Cèåèñ¢îªíË  1:å„O2/S F/CèåèîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D1F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFCNSDLYI "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1369 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDOSO1 "0:âEãLà»äO  1:ëOO2/sóÚâªîªíË(1)ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA3BE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDOSO2 "0:âEãLà»äO  1:ëOO2/sóÚâªîªíË(2)ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA3BF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDOSO3 "0:âEãLà»äO  1:ëOO2/sóÚâªîªíË(3)ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA3C0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDRTRGE "0:íxäp  1:êiäp" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1373 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDRTRGI "0:íxäp  1:êiäp" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1374 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDSFDO "0:âEãLà»äO  1:ëOO2/sóÚâªîªíËãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1375 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDSFDOM "0:âEãLà»äO  1:ëOO2/sóÚâªîªíËãñâ¬ãLâØÇ†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1376 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDSFOH "0:âEãLà»äO  1:ëOO2/sïúãAîªíË(1)ê¨óßÅiè„ë§Åj" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1377 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDSFOL "0:âEãLà»äO  1:ëOO2/sïúãAîªíË(1)ê¨óßÅiâ∫ë§Åj" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1378 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDTBTIMI "0:åvë™ñ¢  1:åvë™çœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1379 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFDTFTIMI "0:åvë™ñ¢  1:åvë™çœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF137A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFEEVPC "0:âEãLà»äO  1:ãÛ ﬂ∞ºﬁêßå‰ñ¢óvãÅÅ®óvãÅ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF137C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFHTMP "0:KMRâèúå„à»äO  1:KMRâèúå„" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF138A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFHTWRK "0:KMRíÜà»äO  1:KMRíÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF138B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFIMRDYBF "0:êfífñ¢èIóπ  1:êfífèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D69 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFIRSTSL "0:ñ¢ê›íË  1:ê›íËçœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1FD2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFKEISL "0:O2æ›ªé¸ä˙åvë™∑¨›æŸíÜ  1:O2æ›ªé¸ä˙åvë™íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37E6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFKEISO "0:O2æ›ªé¸ä˙åvë™íÜ  1:O2æ›ªé¸ä˙éÊìæ¿≤–›∏ﬁ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37E7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFLCLP "0:å∏ë¨ÿ∞›∏◊›Ãﬂêßå‰Ç≈ÇÕÇ»Ç¢  1:å∏ë¨ÿ∞›∏◊›Ãﬂêßå‰íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1390 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFLLMJG "0:VO24M < O2LLMñ¢åoå±  1:VO24M < O2LLMåoå±" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37E8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFLMDCHG "0:îΩì]à»äO  1:îΩì]" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1393 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFLRNTD "0:œØÃﬂäwèKñ¢é˚ë©  1:œØÃﬂäwèKé˚ë©" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D7A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFLTS4 "0:äwèKñ¢  1:äwèKçœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D7B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFMRJG1 "0:îRóøºΩ√—êfífèåèïsê¨óß  1:îRóøºΩ√—êfífèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3D78 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFMRJG2 "0:îRóøºΩ√—êfífèåèïsê¨óß  1:îRóøºΩ√—êfífèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3D79 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFNFO2S "0:âEãLà»äO  1:ëOO2/sóÚâªîªíËíÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA425 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2CYU "0:êfífíÜÇ≈ÇÕÇ»Ç¢  1:êfífíÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D82 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HCN "0:O2À∞¿êfífîªíËƒÿØÃﬂñ¢îªíË  1:O2À∞¿êfífîªíËƒÿØÃﬂîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D83 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT afFO2HDON "0:O2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBOFF  1:O2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2328 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HDON "0:O2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBOFF  1:O2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF23D6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HM "0:ëOO2À∞¿ON  1:ëOO2À∞¿OFF" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4944 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfFO2HM "0:ëOO2À∞¿ON  1:ëOO2À∞¿OFF" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4842 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HMFT "0:ñ¢åoâﬂ  1:åoâﬂ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D84 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HNG "0:OK  1:NG" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3D82 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HNG1 "0:O2À∞¿êfífNG1âÒñ⁄ñ¢îªíË  1:O2À∞¿êfífNG1âÒñ⁄îªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA426 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT afFO2HON "0:OFF  1:ON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2329 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HON "0:OFF  1:ON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF23D7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HTU "0:ã÷é~  1:ãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3D83 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2HZNG "0:ìØàÍTRIPì‡Ç≈NGî≠ê∂Ç»Çµ  1:ìØàÍTRIPì‡Ç≈NGî≠ê∂Ç†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37E9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2JHM "0:VO24M >= O2JH -> VO24M < O2JLäO  1:VO24M >= O2JH -> VO24M < O2JLì‡" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37EA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2JLM "0:VO24M < O2JL -> VO24M >= O2JHäO  1:VO24M < O2JL -> VO24M >= O2JHì‡" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37EB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2MLOK "0:O2æ›ªêfífOKñ¢îªíË  1:O2æ›ªêfífOKîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D85 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2OV "0:O2æ›ªàŸèÌìdà≥2êfífåªƒÿØÃﬂíÜNGñ¢  1:O2æ›ªàŸèÌìdà≥2êfífåªƒÿØÃﬂíÜNGîª" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D87 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2SCND "0:èåèîÒê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D88 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2SJ1 "0:O2æ›ªêfífãñâ¬èåèñ¢îªíË  1:O2æ›ªêfífãñâ¬èåèîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D89 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2SJ2 "0:êfífóÃàÊèåè(a)-(t)Ç¢Ç∏ÇÍÇ©ïsê¨  1:êfífóÃàÊèåè(a)-(t)Ç∑Ç◊Çƒê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D8A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2SJ3 "0:O2æ›ªàŸèÌìdà≥êfífóÃàÊèåèïsê¨óß  1:O2æ›ªàŸèÌìdà≥êfífóÃàÊèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D8B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2SJ4 "0:O2æ›ªífê¸êfífãñâ¬èåèïsê¨óß  1:O2æ›ªífê¸êfífãñâ¬èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D8C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2SJ5 "0:O2æ›ªàŸèÌìdà≥êfífóÃàÊèåèïsê¨óß  1:O2æ›ªàŸèÌìdà≥êfífóÃàÊèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D8D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFO2TE "0:êfífë±çs  1:êfífèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37EC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOADDE "0:íPí≤å∏è≠íÜÇ≈Ç»Ç¢  1:íPí≤å∏è≠íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37ED /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOADIN "0:íPí≤ëùâ¡íÜÇ≈Ç»Ç¢  1:íPí≤ëùâ¡íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37EE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOHMLOK "0:O2À∞¿êfífOKñ¢îªíË  1:O2À∞¿êfífOKîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D92 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOLDCN "0:FrO2/SÉ…ì_ÉVÉtÉgêfífƒÿØÃﬂñ¢îªíË  1:FrO2/SÉ…ì_ÉVÉtÉgêfífƒÿØÃﬂîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D93 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOLNCN "0:O2æ›ªàŸèÌìdà≥êfífÿ∞›ºÃƒîªíËƒÿØÃﬂ  1:O2æ›ªàŸèÌìdà≥êfífÿ∞›ºÃƒîªíËƒÿØÃﬂ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D94 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOLNNG1 "0:O2æ›ªàŸèÌìdà≥êfífÿ∞›ºÃƒNG1âÒñ⁄ñ¢  1:O2æ›ªàŸèÌìdà≥êfífÿ∞›ºÃƒNG1âÒñ⁄îª" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA429 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOLNOK "0:O2æ›ªàŸèÌìdà≥êfífÿ∞›ºÃƒOKñ¢îªíË  1:O2æ›ªàŸèÌìdà≥êfífÿ∞›ºÃƒOKîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D95 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOOPCN "0:O2æ›ªífê¸êfífîªíËƒÿØÃﬂñ¢îªíË  1:O2æ›ªífê¸êfífîªíËƒÿØÃﬂîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D98 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFOOPNG1 "0:O2æ›ªífê¸êfífNG1âÒñ⁄ñ¢îªíË  1:O2æ›ªífê¸êfífNG1âÒñ⁄îªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA42B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFORC2NG1 "0:O2æ›ªàŸèÌìdà≥2êfífNG1âÒñ⁄ñ¢îªíË  1:O2æ›ªàŸèÌìdà≥2êfífNG1âÒñ⁄îªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA42D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFORCCN "0:O2æ›ªàŸèÌìdà≥êfífÿØ¡ºÃƒîªíËƒÿØÃﬂ  1:O2æ›ªàŸèÌìdà≥êfífÿØ¡ºÃƒîªíËƒÿØÃﬂ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D99 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFORCNG1 "0:O2æ›ªàŸèÌìdà≥êfífÿØ¡ºÃƒNG1âÒñ⁄ñ¢  1:O2æ›ªàŸèÌìdà≥êfífÿØ¡ºÃƒNG1âÒñ⁄îª" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA42F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFORCOK "0:O2æ›ªàŸèÌìdà≥êfífÿØ¡ºÃƒOKñ¢îªíË  1:O2æ›ªàŸèÌìdà≥êfífÿØ¡ºÃƒOKîªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2D9A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFORPSNG1 "0:O2æ›ªâûìöéûä‘êfíf(é¸îgêî”∆¿ï˚éÆ)  1:O2æ›ªâûìöéûä‘êfíf(é¸îgêî”∆¿ï˚éÆ)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFB54D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFORPSOK "0:O2æ›ªâûìöéûä‘êfíf(é¸îgêî”∆¿ï˚éÆ)  1:O2æ›ªâûìöéûä‘êfíf(é¸îgêî”∆¿ï˚éÆ)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37EF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFPIDPUG "0:±≤ƒﬁŸ ﬂ∞ºﬁÇãñâ¬ÇµÇ»Ç¢  1:±≤ƒﬁŸ ﬂ∞ºﬁÇãñâ¬Ç∑ÇÈ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2DA3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFREBTIMI "0:åvë™ñ¢  1:åvë™çœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF139F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFREFTIMI "0:åvë™ñ¢  1:åvë™çœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF13A0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRESBI "0:ãñâ¬èåèïsê¨óß  1:ãñâ¬èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF13A1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRESFI "0:ãñâ¬èåèïsê¨óß  1:ãñâ¬èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF13A2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRESTIMI "0:îÒåvë™  1:åvë™íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF13A3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRLJUG "0:Lean  1:Rich" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37F0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRLMJG "0:VO24M >= O2RLMñ¢åoå±  1:VO24M >= O2RLMåoå±" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37F1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRO2FC "0:âEãLà»äO  1:îRóø∂Øƒÿ∂ ﬁ∞å„" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2DAF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRTLRNI "0:ñ¢åoå±  1:åoå±çœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA432 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFSO2NG "0:O2/S ê≥èÌ  1:O2/S 2Và»è„NGÇ™ÇPìxÇ≈Ç‡î≠ê∂ÇµÇΩ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF8A3C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfFSO2NG "0:O2/S ê≥èÌ  1:O2/S 2Và»è„NGÇ™ÇPìxÇ≈Ç‡î≠ê∂ÇµÇΩ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF8A04 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFSO2S "0:O2/S ê≥èÌ  1:O2/S OPEN/SHORT" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF8A3D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfFSO2S "0:O2/S ê≥èÌ  1:O2/S OPEN/SHORT" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF8A05 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFTO2M "0:TO2MÇ™ââéZÇ≥ÇÍÇƒÇ¢Ç»Ç¢  1:TO2MââéZçœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37F2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFVTCBSK "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF13B3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFVTCPOS "0:âEãLà»äO  1:VTCäÓèÄäpìxå≈íËóvãÅ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2DFF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFWKSTG "0:âEãLà»äO  1:WKSTRGÉNÉäÉAóvãÅÇ†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2E01 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fHOSHONO "0:å„O2æ›ªÇÃÀ∞¿Ç™ç≈èâÇ©ÇÁÇnÇmÇ≈Ç»Ç¢  1:å„O2æ›ªÇÃÀ∞¿Ç™ç≈èâÇ…ÇnÇmÇ…Ç»Ç¡ÇΩ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2E22 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fHTLMDDGE "0:êfífñ¢èIóπ  1:ëSÇƒÇÃêfífèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2E3C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fHTLMDJ "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1412 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fHYSALP "0:ÀΩ -ë§  1:ÀΩ +ë§" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF141B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fHYSALP0 "0:ÀΩ -ë§  1:ÀΩ +ë§" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF141A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fJUGCNT "0:èàóùñ≥Çµ  1:ââéZ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2E76 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fKINSI "0:ãñâ¬  1:ã÷é~" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF26E6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fKUDCNTE "0:éÊìæâ¬  1:éÊìæïsâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1509 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLEANI "0:êßå‰íÜÇ≈Ç»Ç¢  1:êßå‰íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1517 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLEARNJ "0:ÿ∞›à⁄çsã÷é~èåè(∏€∞Ωﬁƒﬁêßå‰Ç≈Ç»  1:ÿ∞›à⁄çsã÷é~èåè(∏€∞Ωﬁƒﬁêßå‰Ç≈Ç»" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2E9C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLJUONE "0:A/Fæ›ªäwèKçXêVïsãñâ¬Åiÿ∞›Åj  1:A/Fæ›ªäwèKçXêV1ìxãñâ¬Åiÿ∞›Åj" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2EAB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLJUONH "0:HOSCMAXäwèKçXêVïsãñâ¬Åiÿ∞›Åj  1:HOSCMAXäwèKçXêV1ìxãñâ¬Åiÿ∞›Åj" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2EAC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLMDAPL "0:é¿çsñ≥Çµ  1:é¿çsóLÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF152D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLNRSETz "0:ÿæØƒíÜÇ≈Ç»Ç¢(ëOâÒíl)  1:ÿæØƒíÜ(ëOâÒíl)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2EB9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRDNGZ "0:NGñ¢îªíË  1:NGåüèo" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2EC4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRDOKZ "0:OKñ¢îªíË  1:OKåüèo" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2EC5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRFO2 "0:âEãLà»äO  1:ÉäÉbÉ`Ç©ÇÁÉäÅ[ÉìÇ…êÿÇËë÷ÇÌÇ¡ÇΩ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2ED0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRNCHG "0:¿ﬁ› ﬂêßå‰Ç»Çµ  1:¿ﬁ› ﬂêßå‰Ç†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF153F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRNCHGA "0:É}ÉbÉvà íuïœçXÇ»Çµ  1:É}ÉbÉvà íuïœçXÇ†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF153E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRNCJOK "0:èåèïsê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1540 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRNCLEAR "0:äwèKãLâØRAM∏ÿ±èåèïsê¨óß  1:äwèKãLâØRAM∏ÿ±èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1541 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRNRCH "0:äwèKópÿ∞›Ã◊∏ﬁ  1:äwèKópÿØ¡Ã◊∏ﬁ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1542 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fLRNSEL "0:BSLRNëIëéû  1:LRNALPëIëéû" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1021 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fMALCHK "0:MALPHA<100%éûC/P Checkñ¢äÆóπ  1:MALPHA<100%éûC/P CheckäÆóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3DEB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fMAPLRNOK "0:èåèïsê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF155D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fMBCJOK "0:èåèïsê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1562 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fMCLPKB "0:îÒ”∆¿∏◊›Ãﬂ->”∆¿∏◊›Ãﬂïsê¨óß  1:îÒ”∆¿∏◊›Ãﬂ->”∆¿∏◊›Ãﬂê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2EFB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fMONTCLP "0:”∆¿∏◊›Ãﬂñ¢åoå±  1:”∆¿∏◊›Ãﬂåoå±" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2FE4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fMRGKJK "0:îRóøäwèKópO2/S OK  1:îRóøäwèKópO2/S NG" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3DF3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fNGOK "0:OK  1:NG" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF300A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fNTPCAN "0:∑¨›æŸèåèïsê¨óß  1:∑¨›æŸèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3027 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fO2DGNGO "0:O2æ›ªífê¸ÅAàŸèÌìdà≥êfífèåèïsê¨  1:O2æ›ªífê¸ÅAàŸèÌìdà≥êfífèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3040 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fO2HCHK "0:ñ¢  1:æØƒçœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3E0D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fO2HFOK "0:FO2À∞¿ífê¸OKîªíËïsê¨óß  1:FO2À∞¿ífê¸OKîªíËê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF15FF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fO2HFOKEX "0:FO2À∞¿ífê¸OKîªíËåoå±ñ≥Çµ  1:FO2À∞¿ífê¸OKîªíËåoå±óLÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3041 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fO2HIRL "0:å„O2À∞¿ONèåèïsê¨óß  1:å„O2À∞¿ONèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1600 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fO2SDGC "0:O2æ›ªàŸèÌìdà≥êfífãñâ¬èåèïsê¨óß  1:O2æ›ªàŸèÌìdà≥êfífãñâ¬èåèïsê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3042 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fOPENJS "0:èôÅXÇ…100%Ç…Ç∑ÇÈ  1:ë¶100%Ç…Ç∑ÇÈ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF162E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPFRDINI "0:âEãLà»äO  1:PFRDéZèo2âÒñ⁄à»ç~" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1657 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT bfPGALPHA "0:ALPHAóvãÅñ≥Çµ  1:ALPHA=100%óvãÅóLÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF22DB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHACE "0:PHOSAZäwèKóÃàÊéûPHOSââéZèåèïsê¨  1:PHOSAZäwèKóÃàÊéûPHOSââéZèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF166C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHAINT "0:PHOSAZÉNÉäÉAèåèïsê¨óß  1:PHOSAZÉNÉäÉAèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF166F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHASTOP "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1670 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHKFOT "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1671 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHNG1 "0:FrO2/SÉ…ì_ºÃƒêfífNG1âÒñ⁄ñ¢îªíË  1:FrO2/SÉ…ì_ºÃƒêfífNG1âÒñ⁄îªíË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFAEAC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHOS1OK "0:PHOS1ââéZã÷é~  1:PHOS1ââéZãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1029 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHOS1ST "0:èââÒPHOSââéZñ¢óπ  1:èââÒPHOSââéZäÆóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1677 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHOS1ST2 "0:PHOS Iï™èâä˙ílââéZñ¢óπ  1:PHOS Iï™èâä˙ílââéZäÆóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1676 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHOSAOK "0:PHOSAââéZèåèïsê¨óß  1:PHOSAââéZèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF102A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHOSZOK "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF167C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPHS1OK "0:çÇîrâ∑É…ÉRÉìèåèà»äOÇÃPHOS1ââéZ  1:çÇîrâ∑É…ÉRÉìèåèà»äOÇÃPHOS1ââéZ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF167D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPRDLY "0:PRå∏éZ√ﬁ®⁄≤íÜÇ≈Ç»Ç¢  1:PRå∏éZ√ﬁ®⁄≤íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF309A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPSLRNCLR "0:∏ÿ±ñ¢  1:∏ÿ±çœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF309F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPUSDGN "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF30B9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPUSDGN2 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF30B8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fQUPSAT "0:í èÌΩ¿∞ƒ  1:∏≤Ø∏±ØÃﬂΩ¿∞ƒ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1F01 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fQUPSCHK "0:∏≤Ø∏±ØÃﬂΩ¿∞ƒêßå‰éûÇÃ√ﬁ®⁄≤îªíËñ¢  1:∏≤Ø∏±ØÃﬂΩ¿∞ƒêßå‰éûÇÃ√ﬁ®⁄≤îªíËèI" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1F02 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRCRSETz "0:ÿæØƒíÜÇ≈Ç»Ç¢(ëOâÒíl)  1:ÿæØƒíÜ(ëOâÒíl)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF30F9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRESCNTOK "0:RESCNT( ﬁ›∏ëŒâû)∂≥›ƒÇµÇ»Ç¢  1:RESCNT( ﬁ›∏ëŒâû)∂≥›ÉgÇ∑ÇÈ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4761 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRFBST "0:èââÒ  1:2âÒñ⁄à»ç~" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF312E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRFOEVPT "0:3rdO2æ›ªêfífÇ…ÇÊÇÈÉLÉÉÉjÉXÉ^ÉpÅ[  1:3rdO2æ›ªêfífÇ…ÇÊÇÈÉLÉÉÉjÉXÉ^ÉpÅ[" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3134 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRJUONE "0:A/Fæ›ªäwèKçXêVïsãñâ¬ÅiÿØ¡Åj  1:A/Fæ›ªäwèKçXêV1ìxãñâ¬ÅiÿØ¡Åj" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF313F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRJUONH "0:HOSCMAXäwèKçXêVïsãñâ¬ÅiÿØ¡Åj  1:HOSCMAXäwèKçXêV1ìxãñâ¬ÅiÿØ¡Åj" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3140 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRLDNGZ "0:NGñ¢îªíË  1:NGåüèo" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3146 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRLDOKZ "0:OKñ¢îªíË  1:OKåüèo" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3147 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRLFO2 "0:âEãLà»äO  1:ÉäÅ[ÉìÇ©ÇÁÉäÉbÉ`Ç…êÿÇËë÷ÇÌÇ¡ÇΩ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3150 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRLNOKT "0:àŸèÌìdà≥êfíf(ç≈è¨íl)OKñ¢èIóπ  1:àŸèÌìdà≥êfíf(ç≈è¨íl)OKèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3155 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2DOSOK "0:èåèïsê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1760 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2DTCL "0:å„O2/S  ﬂ◊“∞¿∏ÿ±îÒóvãÅ  1:å„O2/S  ﬂ◊“∞¿∏ÿ±óvãÅ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3166 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2FB "0:âEãLà»äO  1:F/BíÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3169 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2FBALP "0:êGî}êfífñ¢èIóπ  1:êGî}êfífèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3167 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2FBALZ "0:êGî}êfífñ¢èIóπÅiëOâÒíl)  1:êGî}êfífèIóπÅiëOâÒíl)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3168 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2FBR "0:âEãLà»äO  1:RrO2/SêfífRrO2/S F/Bêßå‰óvãÅ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF316C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2FBRT "0:âEãLà»äO  1:3rdO2/Sêfíf3rdO2/S F/Bêßå‰óvãÅ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF316F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT afRO2HDON "0:ÉäÉAO2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBOFF  1:ÉäÉAO2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2352 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2HDON "0:ÉäÉAO2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBOFF  1:ÉäÉAO2ÉqÅ[É^ÉfÉÖÅ[ÉeÉBON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2400 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2HM "0:å„O2À∞¿ON  1:å„O2À∞¿OFF" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF89C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfRO2HM "0:å„O2À∞¿ON  1:å„O2À∞¿OFF" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF893A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2HOK "0:ífê¸îªíËNG  1:ífê¸îªíËOK" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1764 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2HON1 "0:OFF  1:ON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3EA2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2MLOK "0:å„O2/SêfífOKñ¢èIóπ  1:å„O2/SêfífOKèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3170 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2PHSD "0:RO2/Sêfíf√ﬁ®⁄∞ïtÇ´PHOSèåèïsê¨óß  1:RO2/Sêfíf√ﬁ®⁄∞ïtÇ´PHOSèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3171 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2PJUG "0:RO2/SêfífÉXÉeÅ[ÉWÇQóÃàÊèåèïsê¨  1:RO2/SêfífÉXÉeÅ[ÉWÇQóÃàÊèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3172 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2RCH "0:MVRO2(n)<RSL(n)  1:MVRO2(n)ÅÜRSL(n)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1035 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2RCHO "0:MVRO2(n)<RSL(n)(ëOâÒëOO2îΩì]éû)  1:MVRO2(n)ÅÜRSL(n)(ëOâÒëOO2îΩì]éû)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1767 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2RL "0:ÉäÅ[Éì  1:ÉäÉbÉ`" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF26E8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2STG2 "0:RO2/SêfífÉXÉeÅ[ÉWÇQà⁄çsèåèïsê¨  1:RO2/SêfífÉXÉeÅ[ÉWÇQà⁄çsèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1768 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2STG2E "0:RO2/SêfífÉXÉeÅ[ÉWÇQñ¢îªíË  1:RO2/SêfífÉXÉeÅ[ÉWÇQèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3173 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2STG2J "0:âEãLà»äO  1:RO2/SêfífÉXÉeÅ[ÉWÇQNGèàóùóvãÅ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1769 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fROAVCN "0:àŸèÌìdà≥2êfífTRIPñ¢èIóπ  1:àŸèÌìdà≥2êfífTRIPèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3175 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fROHCAN "0:å„O2/HêfífàŸèÌîªíËñ¢èIóπ  1:å„O2/HêfífàŸèÌîªíËèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3176 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fROHMLOK "0:å„O2/Hêfífê≥èÌèIóπñ¢èIóπ  1:å„O2/Hêfífê≥èÌèIóπèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3177 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fROMNCNT "0:àŸèÌìdà≥(ç≈è¨íl)êfífTRIPñ¢èIóπ  1:àŸèÌìdà≥(ç≈è¨íl)êfífTRIPèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF317D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fROMXCNT "0:àŸèÌìdà≥(ç≈ëÂíl)êfífTRIPñ¢èIóπ  1:àŸèÌìdà≥(ç≈ëÂíl)êfífTRIPèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF317F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRON1ST "0:ñ¢åoâﬂ  1:åoâﬂ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3180 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRORSCNT "0:âûìöéûä‘êfífTRIPñ¢èIóπ  1:âûìöéûä‘êfífTRIPèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3182 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRRCOKT "0:àŸèÌìdà≥êfíf(ç≈ëÂíl)OKñ¢èIóπ  1:àŸèÌìdà≥êfíf(ç≈ëÂíl)OKèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF318C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRRPSOKT "0:âûìöéûä‘êfífOKñ¢èIóπ  1:âûìöéûä‘êfífOKèIóπ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3195 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRSEDRF "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1771 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRSNOX "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1773 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRSNXNOW "0:ÿØ¡Ω ﬂ≤∏êßå‰íÜÇ≈Ç»Ç¢  1:ÿØ¡Ω ﬂ≤∏êßå‰íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1036 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRSPIKEI "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1037 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRSPIKEP "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1774 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRST2ARA "0:ÉXÉeÅ[ÉW2óÃàÊèåèïsê¨óß  1:ÉXÉeÅ[ÉW2óÃàÊèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF319A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRST2GO "0:âEãLà»äO  1:RrO2/SêfífRrO2/S F/Bêßå‰óvãÅãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF319C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSLRNOK "0:äwèKèåèïsê¨óß  1:äwèKèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF17A4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSLSET "0:Ω◊≤Ω⁄ÕﬁŸñ¢ê›íË  1:Ω◊≤Ω⁄ÕﬁŸê›íË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2237 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSOKUT "0:é¸ä˙åvë™∑¨›æŸÇ»Çµ  1:é¸ä˙åvë™∑¨›æŸÇ†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF37FA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSOLDGN "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF31EC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fST2ARA "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF31F8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fST2ARAV "0:âºëzΩ√∞ºﬁ2óÃàÊèåèïsê¨óß  1:âºëzΩ√∞ºﬁ2óÃàÊèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF31F9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fST2GO "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF31FA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fST2GOV "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF31FB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fST2GOW "0:à⁄çsã÷é~  1:à⁄çsãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF31FC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSTPCNTIE "0:∂≥›ƒâ¬  1:∂≥›ƒïsâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF17BC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fTHVO2T "0: ﬂ◊“∞¿”∆¿RAMçXêVãñâ¬  1: ﬂ◊“∞¿”∆¿RAMçXêVã÷é~" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3328 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fTPASS "0:TPASSñ¢éQè∆  1:TPASSéQè∆çœ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1978 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fTROFMT "0:âEãLà»äO  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF33C3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fTSLRNOK "0:èåèïsê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF19D0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fUBNCNTOK "0:UBNCNT( ﬁ›∏ëŒâû)∂≥›ƒÇµÇ»Ç¢  1:UBNCNT( ﬁ›∏ëŒâû)∂≥›ÉgÇ∑ÇÈ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3441 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVCLS "0:äàê´âªåoå±Ç»Çµ  1:äàê´âªåoå±Ç†ÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF344F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVRO2I "0:âEãLà»äO  1:VRO2óöóæØƒ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3FE9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVRO2NG "0:VRO2(n)OK  1:VRO2(n)ÅÜ2[V]Ç≈5[sec]åoâﬂ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3459 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVRSHO1 "0:èââÒ  1:2âÒñ⁄à»ç~" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3FF6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDG3IS "0:êfífïsãñâ¬  1:êfífãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGE1 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGE2 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGE3 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGE4 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGI1 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGI2 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGI3 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34AA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGI4 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34AB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGI5 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34AC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGN "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34B0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGN2 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34AD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCFSE3 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34B1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCFSE4 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34B2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCFSI3 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34B4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCFSI4 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34B5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCFSI5 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34B6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCIECLR "0:óvãÅñ≥Çµ  1:óvãÅóLÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1B24 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCIICLR "0:óvãÅñ≥Çµ  1:óvãÅóLÇË" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1B30 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCNACT "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1B52 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCNACTE "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1B51 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT afVTCSOLE "0:èoóÕOFF  1:èoóÕON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF23A4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCSOLE "0:èoóÕOFF  1:èoóÕON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2452 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT afVTCSOLI "0:èoóÕOFF  1:èoóÕON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF23A5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCSOLI "0:èoóÕOFF  1:èoóÕON" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2453 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTDGN3ES "0:êfífïsãñâ¬  1:êfífãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34BB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTDGN4ES "0:êfífïsãñâ¬  1:êfífãñâ¬" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34BC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTFBONE "0:OPENêßå‰  1:F/Bêßå‰" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1054 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTFBONI "0:OPENêßå‰  1:F/Bêßå‰" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1055 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTLNEE "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1056 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTLNEI "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1057 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTLNERE "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1BF2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTLNERI "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1BF3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTRLNEE "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1C08 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTRLNEI "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1C09 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fZOKA "0:å∏è≠  1:ëùâ¡" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3838 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRST2ARAV "0:èåèïsê¨óß  1:èåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF319B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRO2STG2V "0:RO2/SêfífâºëzÉXÉeÅ[ÉWÇQà⁄çsèåè  1:RO2/SêfífâºëzÉXÉeÅ[ÉWÇQà⁄çsèåè" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF3174 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fEVTCCHK "0:ìdé•ÇuÇsÇbÉ`ÉFÉbÉNêMçÜì¸óÕLow  1:ìdé•ÇuÇsÇbÉ`ÉFÉbÉNêMçÜì¸óÕHigh" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF475A /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfEVTCCHK "0:ìdé•ÇuÇsÇbÉ`ÉFÉbÉNêMçÜì¸óÕLow  1:ìdé•ÇuÇsÇbÉ`ÉFÉbÉNêMçÜì¸óÕHigh" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4754 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFAFHMAX "0:A/Fæ›ªÀ∞¿ ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèîÒê¨  1:A/Fæ›ªÀ∞¿ ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2CF0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFAFHMIN "0:A/Fæ›ªÀ∞¿ ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèîÒê¨  1:A/Fæ›ªÀ∞¿ ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2CF1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFBPSNGE "0:VTCäÓèÄäpìxà íuê≥èÌ  1:VTCäÓèÄäpìxà íuàŸèÌ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF1360 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFROHCMN "0:å„O2/S ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèîÒê¨óß  1:å„O2/S ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2DB2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFROHCMX "0:å„O2/S ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèîÒê¨óß  1:å„O2/S ﬂ◊“∞¿ ﬁØ∏±ØÃﬂèåèê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2DB3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFRTLRNE "0:ñ¢åoå±  1:åoå±çœÇ›" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFFA431 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFVTBSKE "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF13B2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFVTPOSE "0:âEãLà»äO  1:VTCäÓèÄäpìxå≈íËóvãÅ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF2E00 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGE5 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34A7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCDGN5E "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF26EC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVTCFSE5 "0:ïsê¨óß  1:ê¨óß" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF34B3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFHMODE "0:îÒêßå‰  1:À∞¿-êßå‰íÜ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF38CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fZDETDLY "0:í èÌèàóùÅiíxâÑÇ»ÇµÅj  1:íxâÑÇ∑ÇÈ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4020 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfBNCAD "BNC SW analog input flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49C0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfD2SUMCL "DDL2 SUM value calculation requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49C2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfEVRABS1 "New frame ESP occurs" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49C2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fD2SUMCL "DDL2 SUM value calculation requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49C3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfACCCUFAL "ACC C/U fail flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfACGMV1 "Fan 1 activation request from ac" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfACGMV2 "Fan 2 activation request from ac" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfACMNISRN "The idle speed value requested by the AC is currently unavailable" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfACTDDL1 "DDL1 Active test in-progress flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfACTDDL2 "DDL2 Active test in-progress flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfAGBACLRQ "Idle speed setpoint acceleration by AT is requested" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49C6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfAGBGRDFT "Automatic Gearbox ratio engaged default" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49C7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfAGBINVLD "AGB Invalid torque requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49C7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfAGBSIPNG "AGB shift-in-progress adjustment check NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49C7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfALTPWMXN "Alternator mechanical power from CAN is not available" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49C7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfAPSKD "Accel pedal depressed beyond mechanical hard point (if no mechanical KD flag remains inactive)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49C7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfASCCLDG "Clear diagnostics information request" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49C7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfASRINREG "ASR is in regulation" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49C7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfASRPRONG "Protocol error in ASR regulation" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfASRRQCDN "ASR conditions" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfATMSG1A "ATMSG1 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfATMSG2A "ATMSG2 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfBOOST "-" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfBPKSW "parking braking detected" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfBRKSWN "The brake status information is unavailable" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCALAGE "Stall detected" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49C8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCANINIT "CAN initial completion flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49C9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCCADDENA "The CC diagnostic add-on is enabled" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49C9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCHKVDCNG "VDCMSG1 check SUMNG judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49C9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCLRDIAG "CLRDiag service applicative flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49C9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCLURNSW "State of the begin stroke clutch pedal  Physical input" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49C9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCLUSW "State of the clutch pedal (1=clutch pedal pressed)." UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49CA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCLUSWI "Clutch Switch status" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49CA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCLUSWN "The clutch pedal status information is unavailable" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49CA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCMDGMVB1 "Fan 1 activation request from AGB" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49CA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCMDGMVB2 "Fan 2 activation request from AGB" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49CA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCRENGSTP "Engine stall judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49CA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCVTMSG1A "CVTMSG1 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49CA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCVTMSG2A "CVTMSG2 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfCVTMSG3A "CVTMSG3 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDEGRST "The first flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAP12 "Detected failure of accelerator pedal" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAPCHR "Detected failure of accelerator pedal consistency" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAPSOC1 "Detected failure of accelerator pedal track 1 open circuit" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAPSOC2 "Detected failure of accelerator pedal track 2 open circuit" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAPSSC1 "Detected failure of accelerator pedal track 1 short circuit" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49CB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAPSSC2 "Detected failure of accelerator pedal track 2 short circuit" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAVCC1 "Detected failure of power supply 1 (accelerator pedal track 1)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFAVCC2 "Detected failure of power supply 2 (accelerator pedal track 2)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDFESPCPL "ESP complement error detected between ASR and MSR data" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfDIAGONGE "Logical OR between ECM and BCM reception diagnostic indicator" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfECMACCON "An ACC requirement is working, flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfEGBNEUT "Electronic GearBox is in a configuration equivalent to Neutral for a manual gearbox" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49CC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfESPLK "when the first ESP frame is received." UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfESPMALFN "CAN reception ESP fail flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfESPRQCDN "ASR MSR authorization" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETAMXBRK "The brake status information is absent" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETAMXCLU "The clutch pedal status information is absent" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETAMXNUT "The ECU which transmits the neutral position is confirmed absent" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETAMXRVR "The ECU which transmits the reverse position is confirmed absent" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETAMXVSP "The vehicle speed information is absent" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49CD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETSCLKNG "ETS clock NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49CE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETSIVDCA "ETS Invalid torque requirement realtime NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49CE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfETSMSG0A "ETSMSG0 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49CE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfEVRUPC1 "New frame USM occurs" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49CE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfFIFCUT "Engine cut flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49CE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfFPT1VSP "Vehicle speed failure" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49CF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfFSRT "SRT mode" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49CF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfGASCDNG "The flag which unusually judges acceleration" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49CF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfGBDRAG "Boolean that indicates that Gearbox is in Drag Reduction phase" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49CF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfGBGEARLH "The automatic gearbox transmits a limphome or invalid or unexpected gear value" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49CF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfGBGEARNC "The automatic gearbox is not coupled to the engine" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49CF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfGBGEARNT "The automatic gearbox is on neutral position" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49CF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfGBGEARRV "The automatic gearbox is on reverse position" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49D0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfGEARREV "In manual gearbox the reverse position is engaged" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49D0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIDUPPTC "PTC engine idle speed increase, input from the CAN    (CLIM_Base frame)." UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49D0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIMMCOMNG "ECM-IMMU system trouble diagnosis (breakage, ground short) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49D0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIMMIMLCK "ECM-IMMU system trouble diagnosis (ECM communication circuit trouble) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49D0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIMMKEYER "IMMU-KEY system trouble diagnosis (key difference) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49D0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIMMKEYNG "IMMU-KEY system trouble diagnosis (It can't be received.) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIMMLCMNG "Lock mode trouble diagnosis judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIMMVEND "verlog end" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfIMMVIDNG "ECM-IMMU system trouble diagnosis (initialization) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfINCHACT "Inching control permission flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfLVON "Input of the speed limiter main switch" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfMRGBMX "MIL AGB illumination gobal request status" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49D1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfMSRRQCDN "MSR conditions" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49D2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfNEUTPSN "Gearbox is on the neutral position (information from CAN)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49D2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfOBDSAV02 "OBD After-Sales tests - Catalyzer test flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49D2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfPWLRTNRQ "request to keep the power before going in protected state" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49D2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfRECVF "TCS/VDC recover requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49D2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfRESTEGED "Restart judgment (After crash)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfRSTEPRM "ResetECU service applicative flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfRVON "Input of the cruise control main switch" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSDON "Sawtooth signal in progress" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSIPFULL "AGB FULL control request flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSIPMAX "AGB MAX request flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSIPMIN "AGB MIN request flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSIPREV "Speed control requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49D3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSIPROG "AGB request intensive flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49D4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSRBFPR "ST/SW On experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49D4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfSSOKENST "Self-shut-off permission flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49D4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfTCSFCV "mfFVTCS= 1 o'clock power balance, usually, treatment cancellation flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49D4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfTEGRINT "The first flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49D4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfVASCDNG "The flag which unusually judges a vehicle speed" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49D5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfVDCACT "VDC movement signal" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49D5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfVDCREGMX "AYC in regulation acquired on CAN" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49D5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfVITESDSM "The displayed vehicle speed is in miles/h" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49D5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfVITESDSN "Displayed vehicle speed received on the CAN network not available" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49D5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfVITESMXN "Vehicle speed received on the CAN network not available" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49D5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfWNDSHISR "Electric windshield idle speed setpoint acceleration request" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49D5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACCCUFAL "ACC C/U fail flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49D6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACTDDL1 "DDL1 Active test in-progress flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49D6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACTDDL2 "DDL2 Active test in-progress flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49D6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBINVLD "AGB Invalid torque requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49D7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBSIPNG "AGB shift-in-progress adjustment check NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49D7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fATMSG1A "ATMSG1 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49D8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fATMSG2A "ATMSG2 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49D8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBOOST "-" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49D8 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCHKVDCNG "VDCMSG1 check SUMNG judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49D9 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCRENGSTP "Engine stall judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49DA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCVTMSG1A "CVTMSG1 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49DA /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCVTMSG2A "CVTMSG2 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49DB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fCVTMSG3A "CVTMSG3 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49DB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fDEGRST "The first flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49DB /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fECMACCON "An ACC requirement is working, flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49DC /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fESPMALFN "CAN reception ESP fail flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49DD /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fETSMSG0A "ETSMSG0 receiving experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49DE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFIFCUT "Engine cut flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49DE /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFSRT "SRT mode" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49DF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fGASCDNG "The flag which unusually judges acceleration" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49DF /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fIMMCOMNG "ECM-IMMU system trouble diagnosis (breakage, ground short) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49E0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fIMMIMLCK "ECM-IMMU system trouble diagnosis (ECM communication circuit trouble) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49E0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fIMMKEYER "IMMU-KEY system trouble diagnosis (key difference) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49E0 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fIMMKEYNG "IMMU-KEY system trouble diagnosis (It can't be received.) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49E1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fIMMLCMNG "Lock mode trouble diagnosis judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF49E1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fIMMVEND "verlog end" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49E1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fIMMVIDNG "ECM-IMMU system trouble diagnosis (initialization) judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF49E1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fINCHACT "Inching control permission flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49E1 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fPWLRTNRQ "request to keep the power before going in protected state" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49E2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRECVF "TCS/VDC recover requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49E2 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fRESTEGED "Restart judgment (After crash)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49E3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSIPMAX "AGB MAX request flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49E3 DISPLAY_IDENTIFIER Vbx_agb_tq_req_l_lim /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSIPMIN "AGB MIN request flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49E3 DISPLAY_IDENTIFIER Vbx_agb_tq_req_h_lim /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSIPREV "Speed control requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF49E3 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSRBFPR "ST/SW On experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF49E4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fSSOKENST "Self-shut-off permission flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF49E4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fTCSFCV "mfFVTCS= 1 o'clock power balance, usually, treatment cancellation flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF49E4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fTEGRINT "The first flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF49E4 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVASCDNG "The flag which unusually judges a vehicle speed" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49E5 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT wfVSPASCD3 "A vehicle speed pulse periodic judgement flag for ASCD" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49E6 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fVSPASCD3 "A vehicle speed pulse periodic judgement flag for ASCD" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF49E7 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT bfFSKNK "Knock-fail safe" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF4276 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT bfNMIREF "MC command completion flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF4276 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fATGP "AT gear position" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF4277 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFEVINI "After the judgement, control requirement" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4277 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFEVPFLT "åJÇËï‘Çµ" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF4277 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFSLCK "Mode distinction" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF4278 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fFSTOSET "Stratified prohibition flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF4278 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fTWADJ "Adjustment control permission coolant temperature condition judgement" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4278 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACCMOD "Acceleration mode flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF427B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACCYC "Filtered air compressor activation request" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF427B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACENGINH "Engine AC Compressor inhibition" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF427B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACHITMP "Delayed AC Compressor inhibition due to engine control conditions" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF427B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACOUTMX "AC compressor clutching order (for CAN Network Transmission)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF427B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACSECINH "Combination of all the vehicle inhibitions" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF427B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACSTEX "At the time of the start, air-conditioning relay output experience flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF427B /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACSTOK "Flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF427C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fACSTON "At the time of the start, air-conditioning relay output flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF427C /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fADJDDL "Ignition timing, engine speed adjustment common condition judgement" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF427D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fADJSTP "Control value permission condition judgement executive flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF427D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fADV55 "EEPROM ignition timing adjustment value writing treatment judgement" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF427D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fADV55OLD "EEPROM ignition timing adjustment value writing requirement judgement (previous value)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF427D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fADVADJWT "ADVEPN value EEPROM writing requirement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF427D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFMICND "AF/M middle electric potential fixed diagnosis condition" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF427D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFOPCND "AF/M breakage diagnosis condition" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF427D /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAFSHCND "AF/M short diagnosis condition" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF427E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBCANNG "AGB CAN communication system NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF427E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBCLKCA "AGB clock check realtime NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF427E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBCLKNG "AGB clock check NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF427E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBCMDFT "AGB torque control prohibition flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF427E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBDLYNG "AGB shift-in-progress time-out check NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF427E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBFNCNG "AGB requested torque function system NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF427E /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBLNKCA "AGB link check realtime NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF427F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBLNKCM "AGB link check NG one's personal history flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF427F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBLNKNG "AGB link check NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF427F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBRTDNG "AGB retard requirement time check NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF427F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBTQDFT "AGB default torque limitation execution flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF427F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAGBTUPNG "AGB requested torque rise integral value check NG flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF427F /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fALTCJUG "Alternator generating electricity voltage variable system trouble diagnosis permission condition" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF4281 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAPLHDFTZ "Pedal limp home downgraded mode" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF4281 DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_dft_prev /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAPOFR1ST "A setup of the APOFSR beginning" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF4282 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAPP20MS "APP 20mS JOB executive permission flag (in an APP 2 times, 1 time practice)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF4282 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAPP40MS "APP 40mS JOB executive permission flag (in an APP 4 times, 1 time practice)" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF4282 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fASCDFAL2 "ASCD operation fail flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF4283 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fASCOED "ECU side transmitting prohibition flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF4283 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fASCSWCHK "Operation SW welding diagnosis MAINSW switching judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF4283 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fATRNGZ "The judgement flag which an ATRNG previous value has been set on" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF4284 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fATVSPNG "A/T side vehicle speed sensor NG judgement distinction" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF4284 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fAUTOPMD "Auto-power mode" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0008 ECU_ADDRESS 0xFFFF4284 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBATDEG "Battery deterioration flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0004 ECU_ADDRESS 0xFFFF4284 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBATSC "Battery electric current sensor middle sticking voltage flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4284 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBATSCINI "Battery electric current sensor middle sticking voltage first computed flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF4284 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBCDCVTM "DIREDC# timer, setup/check judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF4285 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBITCNT "m<N treatment switchover output check" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0040 ECU_ADDRESS 0xFFFF4285 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBNOBNCNG "Brake SW un-adjustment judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0020 ECU_ADDRESS 0xFFFF4285 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBPMNCN "Vapor occurrence speed monitor control" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0010 ECU_ADDRESS 0xFFFF4285 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBURAMCLR "The backup RAM clear actual behavior voice" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0002 ECU_ADDRESS 0xFFFF4285 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBUREND "Backup RAM system diagnosis control complete flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0001 ECU_ADDRESS 0xFFFF4285 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin MEASUREMENT fBURMON "Backup RAM system diagnosis permission condition judgement flag" UBYTE COMP_0283 1 100 0 1 BIT_MASK 0x0080 ECU_ADDRESS 0xFFFF4286 /begin FUNCTION_LIST /end FUNCTION_LIST /end MEASUREMENT
/begin COMPU_METHOD COMP_0068 "1-" RAT_FUNC "%8.2" "-" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD COMP_0283 "1flag" RAT_FUNC "%8.2" "flag" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/begin COMPU_METHOD COMP_0091 "Ã◊∏ﬁÃ◊∏ﬁ" RAT_FUNC "%8.2" "Ã◊∏ﬁ" COEFFS 0 1 0 0 0 1 /end COMPU_METHOD
/* RECORD_LAYOUT ------------------------------------------------------ */
/begin RECORD_LAYOUT REC_UBYTE_C FNC_VALUES 1 UBYTE COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT REC_UWORD_C FNC_VALUES 1 UWORD COLUMN_DIR DIRECT /end RECORD_LAYOUT
/begin RECORD_LAYOUT REC_ULONG_C FNC_VALUES 1 ULONG COLUMN_DIR DIRECT /end RECORD_LAYOUT
/end MODULE
/end PROJECT
