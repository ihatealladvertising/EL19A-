		tlquvwc_clelwCd_hCDzbFa_kCRa00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_doc1_wht_tbn 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_down_air_fil_prs_max
		"Maximum value for downstream air filter pressure"
		VALUE
		0x800578e4
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_down_air_fil_prs_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_down_air_fil_prs_min
		"Minimum value for downstream air filter pressure"
		VALUE
		0x800578e2
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_down_air_fil_prs_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_down_bkp_vs_neut
		"Down breakpoint on vehicle speed in order to detect a vehicle stop"
		VALUE
		0x8005884a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_down_bkp_vs_neut 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_down_egr_cool_temp_ftc
		"Filtering time calibration for the temperature downstream the EGR cooler"
		VALUE
		0x80043aee
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_down_egr_cool_temp_ftc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_down_shf_no_seq_dly
		"Cxx_down_shf_no_seq_dly"
		VALUE
		0x800592fe
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_down_shf_pow_rat
		"Cxx_down_shf_pow_rat"
		VALUE
		0x80059216
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_14
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_ant_dly
		"Cxx_driv_ant_dly"
		VALUE
		0x800592fd
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_100_pow
		"Calibration of simple model of aerodynamic drag power: drag power at 100km/h"
		VALUE
		0x80059191
		RSA_RecordLayout_VALUE_UBYTE
		500000
		drbdAab_snynrtd_cpBhbcd_W__500a
		0.
		500000.
    DISPLAY_IDENTIFIER Cxx_driv_sp_100_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_grd_mv_down_fil_fac
		"Filter time constant for calculation of driver activity mean value,when decreasing"
		VALUE
		0x80059190
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_driv_sp_grd_mv_down_fil_fac 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_grd_mv_frz_fil_fac
		"Filter time constant (high value) for freezing calculation of driver activity mean value"
		VALUE
		0x8005918f
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_driv_sp_grd_mv_frz_fil_fac 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_grd_mv_up_fil_fac
		"Filter time constant for calculation of driver activity mean value,when increasing"
		VALUE
		0x8005918e
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_driv_sp_grd_mv_up_fil_fac 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_grd_mv_upd_h_thd
		"High pedal ratio threshold for updating pedal activity calculation"
		VALUE
		0x8005918c
		RSA_RecordLayout_VALUE_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_driv_sp_grd_mv_upd_h_thd 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_grd_mv_upd_l_thd
		"Low pedal ratio threshold for updating pedal activity calculation"
		VALUE
		0x8005918a
		RSA_RecordLayout_VALUE_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_driv_sp_grd_mv_upd_l_thd 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_grd_mv_upd_vs_thd
		"Vehicle speed low threshold for updating driver activity calculation"
		VALUE
		0x80059188
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_driv_sp_grd_mv_upd_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_mv_frz_fil_fac
		"Filter time constant (high value) for freezing calculation of driver setpoint mean value"
		VALUE
		0x80059186
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_driv_sp_mv_frz_fil_fac 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_mv_upd_pdl_thd
		"Low pedal ratio threshold for updating driver setpoint mean value calculation (when option selected)"
		VALUE
		0x80059184
		RSA_RecordLayout_VALUE_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_driv_sp_mv_upd_pdl_thd 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_mv_upd_vs_thd
		"Vehicle speed low threshold for updating driver setpoint mean value calculation"
		VALUE
		0x80059182
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_driv_sp_mv_upd_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_sp_pow_ref
		"Reference max engine power value for normalising driver setpoint"
		VALUE
		0x80059181
		RSA_RecordLayout_VALUE_UBYTE
		500000
		drbdAab_snynrtd_cpBhbcd_W__500a
		0.
		500000.
    DISPLAY_IDENTIFIER Cxx_driv_sp_pow_ref 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_driv_spt_fac_fail_slop
		"Slope for failsafe transition of driving style indicator"
		VALUE
		0x80059180
		RSA_RecordLayout_VALUE_UBYTE
		5
		gjkApod_wtFxkBb_DmtjdCa_roCRaa0
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_driv_spt_fac_fail_slop 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_drvn_eng_n_thd_h
		"High threshold of engine speed used to initialize the timer"
		VALUE
		0x80041500
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_drvn_eng_n_thd_h 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_drvn_eng_n_thd_l
		"Low threshold of engine speed used to initialize the timer"
		VALUE
		0x800414fe
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_drvn_eng_n_thd_l 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dspl_vs_secu_fac
		"Factor to detect bad received displayed vehicle speed"
		VALUE
		0x800401bc
		RSA_RecordLayout_VALUE_UBYTE
		0.255
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		0.255
    DISPLAY_IDENTIFIER Cxx_dspl_vs_secu_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dspl_vs_secu_ofs
		"Offset to detect bad received displayed vehicle speed"
		VALUE
		0x800401ba
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_dspl_vs_secu_ofs 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dspl_vs_secu_thd
		"Threshold to detect bad received displayed vehicle speed"
		VALUE
		0x800401b8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_dspl_vs_secu_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dt1_maf_reg_fac_neg
		"Gain factor of the dt1 in the negative section"
		VALUE
		0x80063c12
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_dt1_maf_reg_fac_neg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dt1_maf_reg_fac_pos
		"Gain factor of the dt1 in the positive section"
		VALUE
		0x80063c10
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_dt1_maf_reg_fac_pos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dt1_maf_reg_fac_win
		"Gain factor of the dt1 in the window"
		VALUE
		0x80063c0e
		RSA_RecordLayout_VALUE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_dt1_maf_reg_fac_win 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dt1_maf_reg_t_fac
		"Time factor in the dt1 characteristic"
		VALUE
		0x80063c0c
		RSA_RecordLayout_VALUE_UBYTE
		0.255
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		0.255
    DISPLAY_IDENTIFIER Cxx_dt1_maf_reg_t_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dt1_maf_reg_win_neg
		"Definition of the negative part of the window"
		VALUE
		0x80063c0b
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_dt1_maf_reg_win_neg 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dt1_maf_reg_win_pos
		"Definition of the positive part of the window"
		VALUE
		0x80063c0a
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_dt1_maf_reg_win_pos 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dtc_lb_cata
		"Diagnostic trouble code faulttype identifier of destructive catalyst for priority rules"
		VALUE
		0x80056cad
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cata 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dtc_lb_fsys
		"Diagnostic trouble code faulttype identifier of fuel system for priority rules"
		VALUE
		0x80056cac
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_fsys 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dtc_msb_fsys
		"Diagnostic trouble code device or function identifier of fuel system for priority rules"
		VALUE
		0x80056caa
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_msb_fsys 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_dtc_obd_mis_cata_lpg
		"Misfire diagnostic trouble code for LPG application (OBD)"
		VALUE
		0x80056ca8
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_mis_cata_lpg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_dyn_thd
		"a_dg_dft_mng_failmgt/Dynamic storage capacity or dynamic failure structures index maximum value"
		VALUE
		0x80055c26
		RSA_RecordLayout_VALUE_UBYTE
		9
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		9.
    DISPLAY_IDENTIFIER Cxx_dyn_thd 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_cut_1
		"Initialization of the I part of the PI regulator in case of shut-off cond. 1"
		VALUE
		0x80063c08
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_cut_1 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_cut_2
		"Initialization of the I part of the PI regulator in case of shut-off cond. 2"
		VALUE
		0x80063c06
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_cut_2 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_cut_3
		"Initialization of the I part of the PI regulator in case of shut-off cond. 3"
		VALUE
		0x80063c04
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_cut_3 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_cut_ovr
		"Initialization of the I part of the PI regulator in case of overrun shut-off condition"
		VALUE
		0x80063c02
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_cut_ovr 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_cut_sge
		"Initialization of the I part of the PI regulator in case of sge shut-off condition"
		VALUE
		0x80063c00
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_cut_sge 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_emtv_opn_fail
		"Initialization of the I part of the PI regulator in case of emtv failure mode"
		VALUE
		0x80063bfe
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_emtv_opn_fail 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_itcl_efl
		"Initialization value for MAF I part in case of edge falling detection on Vsx_thr_air_reg"
		VALUE
		0x80063bfc
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_itcl_efl 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_itcl_erg
		"Initialization value for MAF I part in case of edge rising detection on Vsx_thr_air_reg"
		VALUE
		0x80063bfa
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_itcl_erg 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_itol_efl
		"Initialization value for MAF I part in case of edge falling detection on Vsx_thr_sat_ena"
		VALUE
		0x80063bf8
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_itol_efl 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_i_rep_itol_erg
		"Initialization value for MAF I part in case of edge rising detection on Vsx_thr_sat_ena"
		VALUE
		0x80063bf6
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_ear_i_rep_itol_erg 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_reg_h_thd
		"Maximal value for ear error"
		VALUE
		0x80043b5e
		RSA_RecordLayout_VALUE_SWORD
		6000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cxx_ear_reg_h_thd 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ear_reg_l_thd
		"Minimal value for ear error"
		VALUE
		0x80043b5c
		RSA_RecordLayout_VALUE_SWORD
		6000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cxx_ear_reg_l_thd 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_nr1
		"PartNumber.LowerPart (byte 0)"
		VALUE
		0x80056f7a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_nr1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_nr2
		"PartNumber.LowerPart (byte 1)"
		VALUE
		0x80056f79
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_nr2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_nr3
		"PartNumber.LowerPart (byte 2)"
		VALUE
		0x80056f78
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_nr3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_nr4
		"PartNumber.LowerPart (byte 3)"
		VALUE
		0x80056f77
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_nr4 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_nr5
		"PartNumber.LowerPart (byte 4)"
		VALUE
		0x80056f76
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_nr5 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_stt_ctr_dec
		"Decrement step of the non-volatile counters"
		VALUE
		0x80055bcf
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_stt_ctr_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_stt_ctr_max
		"Maximum value of the non-volatile counters"
		VALUE
		0x80055bce
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_stt_ctr_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ecu_stt_ctr_thd
		"Decrement threshold of the non volatile counters"
		VALUE
		0x80055bcd
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ecu_stt_ctr_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_ar_temp_t_fil
		"Time constant for exhasut fuel injector internal surface temperature filtration"
		VALUE
		0x8005825a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_efi_ar_temp_t_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_ext_ar
		"Exhaust fuel injector external surface"
		VALUE
		0x80058258
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		pycplga_CrspAEb_wagastd_mCRa00a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_efi_ext_ar 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_int_ar
		"Exhaust fuel injector internal surface"
		VALUE
		0x80058256
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		pycplga_CrspAEb_wagastd_mCRa00a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_efi_int_ar 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_itl_ar_temp_ini
		"Exhaust fuel injector internal surface temperature initial value"
		VALUE
		0x80058254
		RSA_RecordLayout_VALUE_UWORD
		1240
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_efi_itl_ar_temp_ini 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_egaf_ftc
		"Filtering time constant of volumic exhaust gas flow for purge condition computation"
		VALUE
		0x80058f3c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_efi_purg_egaf_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_egaf_thd
		"exhaust gas air flow threshold for purge condition computation"
		VALUE
		0x80058f3a
		RSA_RecordLayout_VALUE_UWORD
		2000
		movAqed_DtteCgd_cloonha_Bh__10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_efi_purg_egaf_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_fuel_min_wht
		"Minimum fuel weight to complete purge"
		VALUE
		0x80058f38
		RSA_RecordLayout_VALUE_UWORD
		10
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		0.
		10.
    DISPLAY_IDENTIFIER Cxx_efi_purg_fuel_min_wht 
    FORMAT "%3.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_fwe_thd
		"Fuel wear estimation threshold for purge request"
		VALUE
		0x80058f36
		RSA_RecordLayout_VALUE_UWORD
		20000
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_efi_purg_fwe_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_max_t
		"Maximum purge duration"
		VALUE
		0x80058f34
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_efi_purg_max_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_rgn_t
		"Minimum time after regeneration to start 5th injector purge"
		VALUE
		0x80058f32
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_efi_purg_rgn_t 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_utp_ftc
		"Filtering time constant of CSF upstream temperature for purge condition computation"
		VALUE
		0x80058f30
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_efi_purg_utp_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_purg_utp_thd
		"CSF upstream temperature threshold for purge condition computation"
		VALUE
		0x80058f2e
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_efi_purg_utp_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_rad_temp
		"Material thermal radiance"
		VALUE
		0x80058252
		RSA_RecordLayout_VALUE_UWORD
		6.5535e-007
		yiElrDb_aknicqc_ADFwaxb_WkC_00o
		0.
		6.5535E-07
    DISPLAY_IDENTIFIER Cxx_efi_rad_temp 
    FORMAT "%13.11" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efi_wht
		"Material mass"
		VALUE
		0x80058250
		RSA_RecordLayout_VALUE_UWORD
		65.535
		tlquvwc_clelwCd_hCDzbFa_kCRa00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_efi_wht 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efv_ff_mg_strk_min_acum
		"Minimum calibration to accumulate the effective fuel mass flow desired into exhaust line in mg/strk"
		VALUE
		0x80059006
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_efv_ff_mg_strk_min_acum 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efy_dly
		"Opening delay for an optimal voltage battery"
		VALUE
		0x80058db8
		RSA_RecordLayout_VALUE_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_efy_dly 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efy_spg_cool_max
		"Maximum value supercharger cooler efficiency"
		VALUE
		0x800578e0
		RSA_RecordLayout_VALUE_UWORD
		5
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_efy_spg_cool_max 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_efy_spg_cool_min
		"Minimum value supercharger cooler efficiency"
		VALUE
		0x800578de
		RSA_RecordLayout_VALUE_UWORD
		5
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_efy_spg_cool_min 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_cmd_1
		"Command value in the first state of egr cooler bypass"
		VALUE
		0x80060082
		RSA_RecordLayout_VALUE_SWORD
		400
		bcEalnd_AvmCroa_pdqnwqa_fR06012
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_cmd_1 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_cmd_2
		"Command value in the second state of egr cooler bypass"
		VALUE
		0x80060080
		RSA_RecordLayout_VALUE_SWORD
		400
		bcEalnd_AvmCroa_pdqnwqa_fR06012
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_cmd_2 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_dist_cmd
		"Distance between two bypass activation to avoid  jamming"
		VALUE
		0x80060094
		RSA_RecordLayout_VALUE_ULONG
		16777215
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		16777215.
    DISPLAY_IDENTIFIER Cxx_egr_byp_dist_cmd 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_gear
		"Gear engaged"
		VALUE
		0x80043aec
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_egr_byp_gear 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_n
		"High Engine speed limit for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043aea
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_thd_amp
		"High atmospheric pressure threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ae8
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_thd_amp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_thd_emtv_psn
		"High EGR valve position threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ae6
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_thd_emtv_psn 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_thd_n
		"High engine speed threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ae4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_thd_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_thd_tco
		"High engine coolant temperature threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ae2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_thd_tco 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_thd_tia_max
		"Maximum intake air temperature high threshold"
		VALUE
		0x80043ae0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_thd_tia_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_thd_tia_min
		"Minimum intake air temperature high threshold"
		VALUE
		0x80043ade
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_thd_tia_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_thd_tqi
		"High operating torque threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043adc
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_thd_tqi 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_h_tqi
		"High torque limit for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ada
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_egr_byp_h_tqi 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_hys_tco_val_1
		"Low threshold value of the hysteresis on the coolant temperature"
		VALUE
		0x80060092
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_hys_tco_val_1 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_hys_tco_val_2
		"High threshold value of the hysteresis on the coolant temperature"
		VALUE
		0x80060090
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_hys_tco_val_2 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_hys_tia_val_1
		"Low threshold value of the hysteresis on the corrected air temperature"
		VALUE
		0x8006008e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_hys_tia_val_1 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_hys_tia_val_2
		"High threshold value of the hysteresis on the corrected air temperature"
		VALUE
		0x8006008c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_hys_tia_val_2 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_n
		"Low engine speed limit for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ad8
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_thd_amp
		"Low atmospheric pressure threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ad6
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_thd_amp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_thd_emtv_psn
		"Low EGR valve position threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ad4
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_thd_emtv_psn 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_thd_n
		"Low engine speed threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ad2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_thd_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_thd_tco
		"Low engine coolant temperature threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ad0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_thd_tco 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_thd_tia_max
		"Maximum intake air temperature low threshold"
		VALUE
		0x80043ace
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_thd_tia_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_thd_tia_min
		"Minimum intake air temperature low threshold"
		VALUE
		0x80043acc
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_thd_tia_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_thd_tqi
		"Low operating torque threshold for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043aca
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_thd_tqi 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_l_tqi
		"Low torque limit for EGR bypass blocked diagnosis authorization"
		VALUE
		0x80043ac8
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_egr_byp_l_tqi 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_n_ftc
		"Filtering time calibration for the engine speed"
		VALUE
		0x80043ac6
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_egr_byp_n_ftc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_stab_dly
		"Calibration for EGR bypass blocked diagnosis stabilization delay"
		VALUE
		0x80043ac4
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_egr_byp_stab_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_tco_hys_wid
		"Width of the hysteresis"
		VALUE
		0x8006008a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_byp_tco_hys_wid 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_byp_tqi_ftc
		"Filtering time calibration for the operating torque"
		VALUE
		0x80043ac2
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_egr_byp_tqi_ftc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_amp_h_thd_pp
		"High threshold pp value for air pressure hysteresis cut-off"
		VALUE
		0x80061504
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_cut_amp_h_thd_pp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_amp_h_thd_pr
		"High threshold pr value for air pressure hysteresis cut-off"
		VALUE
		0x80061502
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_cut_amp_h_thd_pr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_amp_h_thd_rij
		"High threshold rij value for air pressure hysteresis cut-off"
		VALUE
		0x80061500
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_cut_amp_h_thd_rij 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_amp_l_thd_pp
		"Low threshold pp value for air pressure hysteresis cut-off"
		VALUE
		0x800614fe
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_cut_amp_l_thd_pp 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_amp_l_thd_pr
		"Low threshold pr value for air pressure hysteresis cut-off"
		VALUE
		0x800614fc
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_cut_amp_l_thd_pr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_amp_l_thd_rij
		"Low threshold rij value for air pressure hysteresis cut-off"
		VALUE
		0x800614fa
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_egr_cut_amp_l_thd_rij 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_ovs_h_thd_pp
		"High threshold pp value for engine overspeed hysteresis cut-off"
		VALUE
		0x800614f8
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_ovs_h_thd_pp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_ovs_h_thd_pr
		"High threshold pr value for engine overspeed hysteresis cut-off"
		VALUE
		0x800614f6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_ovs_h_thd_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_ovs_h_thd_rij
		"High threshold rij value for engine overspeed hysteresis cut-off"
		VALUE
		0x800614f4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_ovs_h_thd_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_ovs_l_thd_pp
		"Low threshold pp value for engine overspeed hysteresis cut-off"
		VALUE
		0x800614f2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_ovs_l_thd_pp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_ovs_l_thd_pr
		"Low threshold pr value for engine overspeed hysteresis cut-off"
		VALUE
		0x800614f0
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_ovs_l_thd_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_ovs_l_thd_rij
		"Low threshold rij value for engine overspeed hysteresis cut-off"
		VALUE
		0x800614ee
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_ovs_l_thd_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_thd_is_pp
		"Engine speed threshold for EGR regulation cut-off in idle speed mode in pp mode"
		VALUE
		0x800614ec
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_thd_is_pp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_thd_is_pr
		"Engine speed threshold for EGR regulation cut-off in idle speed mode in pr mode"
		VALUE
		0x800614ea
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_thd_is_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_thd_is_rij
		"Engine speed threshold for EGR regulation cut-off in idle speed mode in rij mode"
		VALUE
		0x800614e8
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_thd_is_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_uds_h_thd_pp
		"High threshold pp value for engine underspeed hysteresis cut-off"
		VALUE
		0x800614e6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_uds_h_thd_pp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_uds_h_thd_pr
		"High threshold pr value for engine underspeed hysteresis cut-off"
		VALUE
		0x800614e4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_uds_h_thd_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_uds_h_thd_rij
		"High threshold rij value for engine underspeed hysteresis cut-off"
		VALUE
		0x800614e2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_uds_h_thd_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_uds_l_thd_pp
		"Low threshold pp value for engine underspeed hysteresis cut-off"
		VALUE
		0x800614e0
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_uds_l_thd_pp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_uds_l_thd_pr
		"Low threshold pr value for engine underspeed hysteresis cut-off"
		VALUE
		0x800614de
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_uds_l_thd_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_n_uds_l_thd_rij
		"Low threshold rij value for engine underspeed hysteresis cut-off"
		VALUE
		0x800614dc
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_n_uds_l_thd_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_t_thd_is_cutt_cln
		"Time threshold for EGR regulation cut-off in idle speed mode when cleaning strategy is activated"
		VALUE
		0x80062884
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_egr_cut_t_thd_is_cutt_cln 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_t_thd_is_pp
		"Time threshold for EGR regulation cut-off in idle speed mode in pp mode"
		VALUE
		0x800614da
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_egr_cut_t_thd_is_pp 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_t_thd_is_pr
		"Time threshold for EGR regulation cut-off in idle speed mode in pr mode"
		VALUE
		0x800614d9
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_egr_cut_t_thd_is_pr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_t_thd_is_rij
		"Time threshold for EGR regulation cut-off in idle speed mode in rij mode"
		VALUE
		0x800614d8
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_egr_cut_t_thd_is_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_h_thd_pp
		"High threshold pp value for coolant temperature hysteresis cut-off"
		VALUE
		0x800614d6
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_h_thd_pp 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_h_thd_pr
		"High threshold pr value for coolant temperature hysteresis cut-off"
		VALUE
		0x800614d4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_h_thd_pr 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_h_thd_rij
		"High threshold rij value for coolant temperature hysteresis cut-off"
		VALUE
		0x800614d2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_h_thd_rij 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_l_thd_pp
		"Low threshold pp value for coolant temperature hysteresis cut-off"
		VALUE
		0x800614d0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_l_thd_pp 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_l_thd_pr
		"Low threshold pr value for coolant temperature hysteresis cut-off"
		VALUE
		0x800614ce
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_l_thd_pr 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_l_thd_rij
		"Low threshold rij value for coolant temperature hysteresis cut-off"
		VALUE
		0x800614cc
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_l_thd_rij 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_thd_is_pp
		"Tco threshold for EGR cut-off in idle speed mode in pp mode"
		VALUE
		0x800614ca
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_thd_is_pp 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_thd_is_pr
		"Tco threshold for EGR cut-off in idle speed mode in pr mode"
		VALUE
		0x800614c8
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_thd_is_pr 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tco_thd_is_rij
		"Tco threshold for EGR cut-off in idle speed mode in rij mode"
		VALUE
		0x800614c6
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tco_thd_is_rij 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_h_thd
		"Tia higher threshold value for EGR cut-off (cond. 2)"
		VALUE
		0x80062882
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_h_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_h_thd_pp
		"High threshold pp value for intake air temperature hysteresis cut-off"
		VALUE
		0x800614c4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_h_thd_pp 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_h_thd_pr
		"High threshold pr value for intake air temperature hysteresis cut-off"
		VALUE
		0x800614c2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_h_thd_pr 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_h_thd_rij
		"High threshold rij value for intake air temperature hysteresis cut-off"
		VALUE
		0x800614c0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_h_thd_rij 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_l_thd
		"Tia lower threshold value for EGR cut-off (cond. 2)"
		VALUE
		0x80062880
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_l_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_l_thd_pp
		"Low threshold pp value for intake air temperature hysteresis cut-off"
		VALUE
		0x800614be
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_l_thd_pp 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_l_thd_pr
		"Low threshold pr value for intake air temperature hysteresis cut-off"
		VALUE
		0x800614bc
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_l_thd_pr 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tia_l_thd_rij
		"Low threshold rij value for intake air temperature hysteresis cut-off"
		VALUE
		0x800614ba
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tia_l_thd_rij 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tqi_hys_wid_pr
		"Hysteresis width value for fast accel determination in pr mode"
		VALUE
		0x800614b8
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_egr_cut_tqi_hys_wid_pr 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tqi_hys_wid_rij
		"Hysteresis width value for fast accel determination in rij and pp modes"
		VALUE
		0x800614b6
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_egr_cut_tqi_hys_wid_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tqi_t_pp
		"Calibration in pp mode for the time delay at the end of the fast acceleration shut-off"
		VALUE
		0x800614b4
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_egr_cut_tqi_t_pp 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tqi_t_pr
		"Calibration in pr mode for the time delay at the end of the fast acceleration shut-off"
		VALUE
		0x800614b2
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_egr_cut_tqi_t_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tqi_t_rij
		"Calibration in ri mode for the time delay at the end of the fast acceleration shut-off"
		VALUE
		0x800614b0
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_egr_cut_tqi_t_rij 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tqi_tco_gear_thd
		"Gear engaged threshold for tco correction switch in fast accel determination"
		VALUE
		0x800614ae
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_egr_cut_tqi_tco_gear_thd 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_tqi_tco_n_thd
		"Engine speed threshold for tco correction switch in fast accel determination"
		VALUE
		0x800614ac
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_egr_cut_tqi_tco_n_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_vs_thd_is_pp
		"Vehicle speed threshold for EGR cut-off in idle speed mode in pp mode"
		VALUE
		0x800614aa
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_egr_cut_vs_thd_is_pp 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_vs_thd_is_pr
		"Vehicle speed threshold for EGR cut-off in idle speed mode in pr mode"
		VALUE
		0x800614a9
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_egr_cut_vs_thd_is_pr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_cut_vs_thd_is_rij
		"Vehicle speed threshold for EGR cut-off in idle speed mode in rij mode"
		VALUE
		0x800614a8
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_egr_cut_vs_thd_is_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_maf_reg_max_lim
		"Maximal output value of the PI air regulator"
		VALUE
		0x80063bf4
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_maf_reg_max_lim 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_maf_reg_max_lim_air_reg
		"Maximal output value of the PI air regulator in thr_air_reg mode"
		VALUE
		0x80063bf2
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_maf_reg_max_lim_air_reg 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_maf_reg_min_lim_air_reg
		"Minimal output value of the PI air regulator in thr_air_reg mode"
		VALUE
		0x80063bf0
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_maf_reg_min_lim_air_reg 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_pwm_rep_decl_pp
		"Replacement position value in case of overrun shut-off condition in Pp mode"
		VALUE
		0x800618c4
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_pwm_rep_decl_pp 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_pwm_rep_decl_pr
		"Replacement position value in case of overrun shut-off condition in Pr mode"
		VALUE
		0x80061bb4
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_pwm_rep_decl_pr 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_egr_pwm_rep_decl_rij
		"Replacement position value in case of overrun shut-off condition in Rij mode"
		VALUE
		0x80061ea4
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_egr_pwm_rep_decl_rij 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_el_bk_wind_is_n
		"Electric backlite idle speed setpoint calibration"
		VALUE
		0x8005ae44
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_el_bk_wind_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_el_bk_wind_meca_pow
		"Electric backlite mechanical power"
		VALUE
		0x8006b348
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_el_bk_wind_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_el_csm_alt_cut_dly
		"Inhibition of the delay of the calculation of the idle speed setpoint offset under alternator requests"
		VALUE
		0x8005ae42
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_el_csm_alt_cut_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_el_csm_clc_dly
		"Inhibition of the delay of the calculation of the idle speed setpoint offset after engine start"
		VALUE
		0x8005ae41
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_el_csm_clc_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_el_csm_clc_neg_fac
		"Gain used for the calculation of the electric balance protection counter"
		VALUE
		0x8005ae40
		RSA_RecordLayout_VALUE_UBYTE
		1
		pvnjhxa_sDyoeeb_yAhnhea_1__050a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_el_csm_clc_neg_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_el_csm_clc_neut_vb
		"electric balance protection voltage reference"
		VALUE
		0x8005ae3e
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_el_csm_clc_neut_vb 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_el_csm_clc_pos_fac
		"Gain used for the calculation of the electric balance protection counter"
		VALUE
		0x8005ae3c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pvnjhxa_sDyoeeb_yAhnhea_1__050a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_el_csm_clc_pos_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_el_wind_meca_pow
		"Electrical windshield mechanical power"
		VALUE
		0x8006b346
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_el_wind_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_el_wind_tco
		"Engine coolant temperature threshold which not allowed electric windshield idle speed setpoint"
		VALUE
		0x8005ae3a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_el_wind_tco 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_act_tco_thd
		"Coolant temperature threshold to activate the EMTV control during after-run."
		VALUE
		0x80058b9c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_act_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_amp_thd_h_mon
		"Value above which the regulation diagnosis is activated."
		VALUE
		0x80058b08
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_emtv_amp_thd_h_mon 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_amp_thd_l_mon
		"Value under which the regulation diagnosis is disactivated."
		VALUE
		0x80058b06
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_emtv_amp_thd_l_mon 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_ctr_1
		"Time counter to ensure that the valve is closed before thrust cleaning (high neg. Volt.)"
		VALUE
		0x80058b9a
		RSA_RecordLayout_VALUE_UWORD
		1024
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1024.
    DISPLAY_IDENTIFIER Cxx_emtv_clos_ctr_1 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_ctr_2
		"Time counter to set the time period of the high negative voltage command."
		VALUE
		0x80058b98
		RSA_RecordLayout_VALUE_UWORD
		1024
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1024.
    DISPLAY_IDENTIFIER Cxx_emtv_clos_ctr_2 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_dly
		"Time to set Vbx_emtv_clos at 1 when inputs conditions are OK"
		VALUE
		0x80058b04
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_emtv_clos_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_nok_thd
		"Position treshold to consider the EMTV not fully closed"
		VALUE
		0x80058b02
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_clos_nok_thd 
    FORMAT "%8.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_rat_h_thd_1
		"Ratio threshold to consider the component as open. Used for Service 06 purpose."
		VALUE
		0x80058b00
		RSA_RecordLayout_VALUE_UBYTE
		2
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_emtv_clos_rat_h_thd_1 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_rat_h_thd_2
		"Ratio threshold to consider the component as open. Used for Service 06 purpose."
		VALUE
		0x80058aff
		RSA_RecordLayout_VALUE_UBYTE
		2
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_emtv_clos_rat_h_thd_2 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_rat_thd
		"Ratio threshold to consider the component as closed."
		VALUE
		0x80058afe
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_emtv_clos_rat_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_clos_thd
		"Position treshold to consider the EMTV fully closed."
		VALUE
		0x80058afc
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_clos_thd 
    FORMAT "%8.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_cmd_val_1
		"Parameter corresponding to the S1 coefficient of the RST Controller."
		VALUE
		0x80058c0c
		RSA_RecordLayout_VALUE_UWORD
		1
		zaiesxc_pDtfwqc_lixtcqc_nA_0a00
		-1.
		0.
    DISPLAY_IDENTIFIER Cxx_emtv_cmd_val_1 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_cmd_val_2
		"Parameter corresponding to the S2 coefficient of the RST Controller."
		VALUE
		0x80058c0a
		RSA_RecordLayout_VALUE_UWORD
		1
		zaiesxc_pDtfwqc_lixtcqc_nA_0a00
		-1.
		0.
    DISPLAY_IDENTIFIER Cxx_emtv_cmd_val_2 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_cmd_val_3
		"Parameter corresponding to the S3 coefficient of the RST Controller."
		VALUE
		0x80058c08
		RSA_RecordLayout_VALUE_UWORD
		1
		zaiesxc_pDtfwqc_lixtcqc_nA_0a00
		-1.
		0.
    DISPLAY_IDENTIFIER Cxx_emtv_cmd_val_3 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_cps_v
		"Compensation Voltage."
		VALUE
		0x80058c06
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_cps_v 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_crt_val_neg_dly_1
		"Time delay before enabling the current limitation strategy for negative current."
		VALUE
		0x80058afa
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_emtv_crt_val_neg_dly_1 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_crt_val_neg_dly_2
		"Time delay before stopping the current limitation strategy for negative current."
		VALUE
		0x80058af9
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_emtv_crt_val_neg_dly_2 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_crt_val_pos_dly_1
		"Time delay before enabling the current limitation strategy for positive current."
		VALUE
		0x80058af8
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_emtv_crt_val_pos_dly_1 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_crt_val_pos_dly_2
		"Time delay before stopping the current limitation strategy for positive current."
		VALUE
		0x80058af7
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_emtv_crt_val_pos_dly_2 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_ctl_lim
		"Limitation used in the RST controller to take into account the max. battery voltage."
		VALUE
		0x80058c04
		RSA_RecordLayout_VALUE_UWORD
		24.9996185302734
		BDbaydc_ejoxiEd_lqghvcb_n_ao00a
		0.
		24.9996185302734
    DISPLAY_IDENTIFIER Cxx_emtv_ctl_lim 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_dft_psn_1
		"Default position in case of a detected failure on the sensor."
		VALUE
		0x80056f9e
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_dft_psn_1 
    FORMAT "%8.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_el_fail_mod
		"Failure mode associated with an electric failure on the component (Hbridge, bv ...)"
		VALUE
		0x80058af6
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_el_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_fail_ctr_max
		"Maximum number of EMTV failure mode activation"
		VALUE
		0x80043b6e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_emtv_fail_ctr_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_frn_cps_v
		"Absolute value of the Friction Compensation Voltage."
		VALUE
		0x80058c02
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_frn_cps_v 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_lacq_fail_mod
		"Failure mode associated with a Lacquered EMTV."
		VALUE
		0x80058af5
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_lacq_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_ofs_ctr_1_max
		"Maximal number of iterations to calculate the medium value of the position during Offset Learning."
		VALUE
		0x80058b96
		RSA_RecordLayout_VALUE_UWORD
		1000
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1000.
    DISPLAY_IDENTIFIER Cxx_emtv_ofs_ctr_1_max 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_ofs_fail_mod
		"Failure mode associated with an offset learning failure."
		VALUE
		0x80058af4
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_ofs_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_ofs_lim_clos_down
		"Minimum value of the first learnt offset."
		VALUE
		0x80058af2
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_ofs_lim_clos_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_ofs_lim_clos_up
		"Maximum value of the first learnt offset."
		VALUE
		0x80058af0
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_ofs_lim_clos_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_ofs_tco_thd
		"Coolant temperature threshold to allow the offset learning."
		VALUE
		0x80058b94
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_ofs_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_opn_fail_val
		"Opening value setpoint for EMTV failure mode (blocked valve or cuttings)"
		VALUE
		0x800621ae
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_opn_fail_val 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_clos
		"Emtv position setpoint in case of EGR regulation shut-off"
		VALUE
		0x800621a6
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_clos 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_clos_rel_thd
		"Relative position value under which the thrust cleaning (high neg. Voltage) is allowed."
		VALUE
		0x80058b92
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_clos_rel_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ctl_0
		"Parameter corresponding to the R0 coefficient of the RST Controller."
		VALUE
		0x80058c00
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ctl_0 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ctl_1
		"Parameter corresponding to the R1 coefficient of the RST Controller."
		VALUE
		0x80058bfe
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ctl_1 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ctl_2
		"Parameter corresponding to the R2 coefficient of the RST Controller."
		VALUE
		0x80058bfc
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ctl_2 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ctl_3
		"Parameter corresponding to the R3 coefficient of the RST Controller."
		VALUE
		0x80058bfa
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ctl_3 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_cutt_thd
		"Maximum diff. allowed btw the last threshold and the read value before detecting a cutting."
		VALUE
		0x80058aee
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_cutt_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_frn_cps_thd
		"Absolute value of the area near the position setpoint where the friction compensation voltage is 0."
		VALUE
		0x80058bf8
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_frn_cps_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_lim_down
		"Defines the range near the closed thrust to activate the approach strategy."
		VALUE
		0x80058b90
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_lim_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_lim_up
		"Defines the range near the open thrust to activate the approach strategy."
		VALUE
		0x80058b8e
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_lim_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ofs_clos_frst_eprm
		"First offset value stored in EEPROM, before the First Offset Learning."
		VALUE
		0x80058b8c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ofs_clos_frst_eprm 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ofs_clos_last_eprm
		"Last offset value stored in EEPROM, before the First Offset Learning."
		VALUE
		0x80058b8a
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ofs_clos_last_eprm 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ofs_frst_thd
		"Maximum difference btw the first offset and the read value of the thrust before detecting a failure"
		VALUE
		0x80058aec
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ofs_frst_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ofs_lim_down
		"Defines the range near the closed thrust to activate the approach strategy during offset learning."
		VALUE
		0x80058b88
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ofs_lim_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_ofs_open
		"Software value of the open thrust."
		VALUE
		0x80058b86
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_ofs_open 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_slop_lim_down
		"Slope corresponding to the maximum negative approach speed of the closed thrust."
		VALUE
		0x80058bf6
		RSA_RecordLayout_VALUE_UWORD
		100
		prgtCkd_krawoFb_tmjbqrb_f__no0a
		-100.
		0.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_slop_lim_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_slop_lim_down_1
		"Slope corresponding to the maximum component speed while closing"
		VALUE
		0x80058bf4
		RSA_RecordLayout_VALUE_UWORD
		100
		prgtCkd_krawoFb_tmjbqrb_f__no0a
		-100.
		0.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_slop_lim_down_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_slop_lim_up
		"Slope corresponding to the maximum approach speed of the open thrust."
		VALUE
		0x80058bf2
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_slop_lim_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_slop_lim_up_1
		"Slope corresponding to the maximum speed component while opening."
		VALUE
		0x80058bf0
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_slop_lim_up_1 
    FORMAT "%8.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_sp_clos_thd_in
		"Setpoint position threshold to enter the closing procedure."
		VALUE
		0x80058b84
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_sp_clos_thd_in 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_sp_clos_thd_out
		"Setpoint position threshold to quit the closing procedure."
		VALUE
		0x80058b82
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_sp_clos_thd_out 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_sp_ctl_0
		"Parameter corresponding to the T0 coefficient of the RST Controller."
		VALUE
		0x80058bee
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_emtv_psn_sp_ctl_0 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_sp_ctl_1
		"Parameter corresponding to the T1 coefficient of the RST Controller."
		VALUE
		0x80058bec
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_emtv_psn_sp_ctl_1 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_sp_ctl_2
		"Parameter corresponding to the T2 coefficient of the RST Controller."
		VALUE
		0x80058bea
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_emtv_psn_sp_ctl_2 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_sp_stab_thd
		"Range of setpoint variation under which the setpoint can be considered as stable."
		VALUE
		0x80058be8
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_sp_stab_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_stab_thd_1
		"Threshold value to consider the stability of position in the dead zone filter."
		VALUE
		0x80058be6
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_stab_thd_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_stab_thd_2
		"Threshold value to consider the stability of the position during the Offset Learning."
		VALUE
		0x80056f9c
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_stab_thd_2 
    FORMAT "%8.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_thd_1
		"Second position threshold to keep the dead zone filter active."
		VALUE
		0x80058be4
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_thd_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_v_lim_down
		"Minimum value of the signal voltage before detecting a SRC failure."
		VALUE
		0x80056f9a
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_v_lim_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_psn_v_lim_up
		"Maximum value of the signal voltage before detecting a SRC failure."
		VALUE
		0x80056f98
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_emtv_psn_v_lim_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_blk_dly_1
		"Minimal time threshold to begin the OBD check"
		VALUE
		0x80058aea
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_emtv_reg_blk_dly_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_blk_dly_2
		"time to detect an OBD failure"
		VALUE
		0x80058ae8
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_emtv_reg_blk_dly_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_blk_open_fail_mod
		"Failure mode associated with the blocked emtv during full closing."
		VALUE
		0x80058ae6
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_reg_blk_open_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_blk_open_thd
		"Threshold used during Regulation Diagnosis, under which the valve is closed."
		VALUE
		0x80058ae4
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_emtv_reg_blk_open_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_clos_fail_mod
		"Failure mode associated with a blocked closed component during regulation."
		VALUE
		0x80058ae2
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_reg_clos_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_h_thd
		"Maximal value for the error loop in the emtv regulation"
		VALUE
		0x80058ae0
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_reg_h_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_l_thd
		"Minimal value for the error loop in the emtv regulation"
		VALUE
		0x80058ade
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_reg_l_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_reg_open_fail_mod
		"Failure mode associated with a blocked open component during regulation."
		VALUE
		0x80058add
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_reg_open_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sat_hys_neg
		"Value of the negative threshold for the emtv saturation"
		VALUE
		0x80063bc0
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_sat_hys_neg 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sat_hys_pos
		"Value of the positive threshold for the emtv saturation"
		VALUE
		0x80063bbe
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_sat_hys_pos 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sat_thd_supl
		"Supplier saturation threshold of emtv"
		VALUE
		0x80063bbc
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_sat_thd_supl 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sens_fail_mod
		"Failure mode associated with a sensor failure"
		VALUE
		0x80058adc
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_sens_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sens_pws
		"Default value of the sensor's power supply voltage."
		VALUE
		0x80056f96
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_emtv_sens_pws 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sp_lim
		"Minimal value of the emtv setpoint before EGR shut-off"
		VALUE
		0x800621a4
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_sp_lim 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sp_max_last
		"Last maximal limitation for the Emtv setrpoint"
		VALUE
		0x800621ac
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_sp_max_last 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sp_max_neg_slop
		"Value of the negative slope for the maximal emtv setpoint"
		VALUE
		0x800618c0
		RSA_RecordLayout_VALUE_ULONG
		65534.5
		pbxrrcb_uxwdEfd_uEzojfd_Bs__n0a
		-65535.
		-0.5
    DISPLAY_IDENTIFIER Cxx_emtv_sp_max_neg_slop 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sp_max_pos_slop
		"Value of the positive slope for the maximal emtv setpoint"
		VALUE
		0x800618bc
		RSA_RecordLayout_VALUE_ULONG
		65534.5
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.5
		65535.
    DISPLAY_IDENTIFIER Cxx_emtv_sp_max_pos_slop 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sp_min
		"Minimal value of the emtv setpoint"
		VALUE
		0x800621aa
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_sp_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_sp_min_last
		"Last minimal limitation for the Emtv setpoint"
		VALUE
		0x800621a8
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_sp_min_last 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_stab_dly_1
		"Time period of the first position stability control before activating the Dead Zone Filter."
		VALUE
		0x80058be2
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_emtv_stab_dly_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_stab_dly_2
		"Time value to declare the sensor power supply voltage not OK."
		VALUE
		0x80056f94
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_emtv_stab_dly_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_tco_thd_h_mon
		"Water temperature above which the engine is not considered as cold."
		VALUE
		0x80058ada
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_tco_thd_h_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_tco_thd_l_mon
		"Water temperature under which the engine is considered as cold."
		VALUE
		0x80058ad8
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_emtv_tco_thd_l_mon 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_lim_down_1
		"Minimum voltage value of the command during regulation mode (if no current limitation)."
		VALUE
		0x80058b80
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_v_lim_down_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_lim_down_2
		"Min. voltage value of the command during regulation mode, in the case of current limitation."
		VALUE
		0x80058b7e
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_v_lim_down_2 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_lim_up_1
		"Maximum voltage value of the command during regulation mode (if no current limitation)."
		VALUE
		0x80058b7c
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_emtv_v_lim_up_1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_lim_up_2
		"Max. voltage value of the command during regulation mode, in the case of current limitation."
		VALUE
		0x80058b7a
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_emtv_v_lim_up_2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_neg_thd
		"Negative command voltage threshold used for the current limitation strategy."
		VALUE
		0x80058ad6
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_v_neg_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_ofs_lim_down
		"Maximum negative voltage command during the closing of the component."
		VALUE
		0x80058b78
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_v_ofs_lim_down 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_pos_thd
		"Positive command voltage threshold used for the current limitation strategy."
		VALUE
		0x80058ad4
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_emtv_v_pos_thd 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_sp_clos_1
		"High negative voltage in open loop control to ensure the cleaning of the thrust."
		VALUE
		0x80058b76
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_v_sp_clos_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_v_sp_clos_2
		"Negative voltage in open loop control to keep the valve closed."
		VALUE
		0x80058b74
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_emtv_v_sp_clos_2 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_vb_fail_mod
		"Indicates which kind of safety mode has to be applied in case of a pb on the battery voltage."
		VALUE
		0x80058ad2
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_emtv_vb_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_vb_lim_down_1
		"First threshold of the hysteresis on the battery voltage to indicate a pws problem."
		VALUE
		0x80058ad0
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_emtv_vb_lim_down_1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_vb_lim_down_2
		"Second threshold of the hysteresis on the battery voltage to indicate a power problem."
		VALUE
		0x80058ace
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_emtv_vb_lim_down_2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_vb_lim_up_1
		"First threshold of the hysteresis on the battery voltage to indicate a too high voltage."
		VALUE
		0x80058acc
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_emtv_vb_lim_up_1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_vb_lim_up_2
		"Second threshold of the hysteresis on the battery voltage to indicate a too high voltage."
		VALUE
		0x80058aca
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_emtv_vb_lim_up_2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_emtv_vb_nok_dly
		"Time value to declare the battery voltage not OK."
		VALUE
		0x80058ac8
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_emtv_vb_nok_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ena_sta_agb_vld_dly
		"After this duration, the previous value of Vsx_ena_sta_agb will be copy in Vsx_ena_sta_agb_ecm"
		VALUE
		0x8005cef2
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ena_sta_agb_vld_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_end_sip_ena_dly
		"Cxx_end_sip_ena_dly"
		VALUE
		0x800597c7
		RSA_RecordLayout_VALUE_UBYTE
		10.2
		VA_F_0v04_p0_7
		0
		10.2
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_eng_alt_rat
		"Pulley ratio"
		VALUE
		0x8005cf42
		RSA_RecordLayout_VALUE_UBYTE
		5
		xgtCpnd_gszbitc_FbDberc_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_eng_alt_rat 
    FORMAT "%10.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_eng_aut_can_diag_dly
		"Delay between the moment when the engine is autonomous and the authorization to set Vbx_can_diag to 1"
		VALUE
		0x80055c1c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_eng_aut_can_diag_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_eng_loss_pow_min
		"Minimum mechanical power due to electrical consumers"
		VALUE
		0x8006b344
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_eng_loss_pow_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_eng_vol_efy_ex_max_lim
		"Maximum value for the exhaust volumetric efficiency"
		VALUE
		0x80056fbe
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_eng_vol_efy_ex_max_lim 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_eng_vol_efy_ex_min_lim
		"Minimum value for the exhaust volumetric efficiency"
		VALUE
		0x80056fbc
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_eng_vol_efy_ex_min_lim 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_eng_vol_efy_in_max_lim
		"Maximum value for the intake volumetric efficiency"
		VALUE
		0x80056fba
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_eng_vol_efy_in_max_lim 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_eng_vol_efy_in_min_lim
		"Minimum value for the intake volumetric efficiency"
		VALUE
		0x80056fb8
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_eng_vol_efy_in_min_lim 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_esd_did_spg_reg_apl_down
		"Turbocharger negative deviation RSA_API_ExtendedSnapshotData number of DID to store"
		VALUE
		0x8005d033
		RSA_RecordLayout_VALUE_UBYTE
		6
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		6.
    DISPLAY_IDENTIFIER Cxx_esd_did_spg_reg_apl_down 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_esd_did_spg_reg_apl_up
		"Turbocharger positive deviation RSA_API_ExtendedSnapshotData number of DID to store"
		VALUE
		0x8005d032
		RSA_RecordLayout_VALUE_UBYTE
		6
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		6.
    DISPLAY_IDENTIFIER Cxx_esd_did_spg_reg_apl_up 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_etun_nr
		"Other system features"
		VALUE
		0x80056f75
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_etun_nr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_fail_val
		"Exhaust manifold pressure default value"
		VALUE
		0x80057d98
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ex_prs_fail_val 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_lim_neg_slop
		"Value of the negative maximum slope for exhaust pressure setpoint in case of combustion mode change"
		VALUE
		0x80043b06
		RSA_RecordLayout_VALUE_UWORD
		3276750
		BzcDpDc_nDAfApa_arzCqqa_BsA005a
		-3276750.
		0.
    DISPLAY_IDENTIFIER Cxx_ex_prs_lim_neg_slop 
    FORMAT "%8.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_lim_pos_slop
		"Value of the positive maximum slope for exhaust pressure setpoint in case of combustion mode change"
		VALUE
		0x80043b04
		RSA_RecordLayout_VALUE_UWORD
		3276750
		fFxvEyc_Farydib_Bvpdzsa_Bp__o20
		0.
		3276750.
    DISPLAY_IDENTIFIER Cxx_ex_prs_lim_pos_slop 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_lim_spg_err_ena_thd
		"boost pressure error threshold used to enable exhaust pressure limitation"
		VALUE
		0x80043b02
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ex_prs_lim_spg_err_ena_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_lim_spg_err_thd
		"Value of boost pressure error threshold  to disable the exhaust pressure limitation"
		VALUE
		0x80043b00
		RSA_RecordLayout_VALUE_SWORD
		20000
		bFvxscc_Ayimzfb_CwzqyDc_Ba__a0a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_ex_prs_lim_spg_err_thd 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_max_lim_ena_dly
		"time delay calibration of turn on delay used on exhaust pressure max limitation activation"
		VALUE
		0x80043afe
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ex_prs_max_lim_ena_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_max_lim_ofs
		"Offset calibration added to exhaust pressure max setpoint"
		VALUE
		0x80043afc
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ex_prs_max_lim_ofs 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_max_lim_spg_err_thd
		"Value of boost pressure error threshold  to disable the max exhaust pressure limitation"
		VALUE
		0x80043afa
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-20000.
		0.
    DISPLAY_IDENTIFIER Cxx_ex_prs_max_lim_spg_err_thd 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_no_lk_n_thd
		"Minimum engine speed to authorise no link diagnostic"
		VALUE
		0x80057dbc
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ex_prs_no_lk_n_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_no_lk_spg_thd
		"Minimum boost pressure to authorise no link diagnostic"
		VALUE
		0x80057dba
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ex_prs_no_lk_spg_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_no_lk_tqi_thd
		"Minimum torque setpoint to authorise no link diagnostic"
		VALUE
		0x80057db8
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ex_prs_no_lk_tqi_thd 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_nok_apc_dif
		"Maximal pressure delta of exhaust manifold pressure plausibility test during APC"
		VALUE
		0x80057db6
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ex_prs_nok_apc_dif 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_nok_isr_dif
		"Maximal pressure delta of exhaust manifold pressure plausibility test during ISR"
		VALUE
		0x80057db4
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ex_prs_nok_isr_dif 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_nok_n_thd
		"Maximum engine speed to authorise nok diagnostic"
		VALUE
		0x80057db2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ex_prs_nok_n_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_nok_tqi_thd
		"Maximum torque setpoint to authorise nok diagnostic"
		VALUE
		0x80057db0
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ex_prs_nok_tqi_thd 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_tia_cold_cut_dly
		"Delay calibration of turn off delay bloc used for tia cold shut-off"
		VALUE
		0x80057dae
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ex_prs_tia_cold_cut_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_tia_cold_cut_h
		"Tia high threshold to activate tia cold shut-off"
		VALUE
		0x80057dac
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ex_prs_tia_cold_cut_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_prs_tia_cold_cut_l
		"Tia low threshold to activate tia cold shut-off"
		VALUE
		0x80057daa
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ex_prs_tia_cold_cut_l 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ex_reg_apl_down_max
		"Threshold of negative deviation of the turbine (exhaust pressure deviation)"
		VALUE
		0x8005d030
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ex_reg_apl_down_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monisft_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_acel_pdl_rat_thd
		"Accelerator pedal foot-off ratio threshold for external controls"
		VALUE
		0x80056e16
		RSA_RecordLayout_VALUE_UWORD
		1.25
		omqfgpc_fbAwBcc_yctdhkb_f_Ra0oa
		0.
		1.25
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_acel_pdl_rat_thd 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_max_n
		"Max engine speed for external controls"
		VALUE
		0x8006b35e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_max_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_rps_max
		"Maximum allowed rail pressure setpoint for external controls operation"
		VALUE
		0x8006b35c
		RSA_RecordLayout_VALUE_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_rps_max 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_sens_map_max
		"Maximum manifold pressure measurement for external controls operation"
		VALUE
		0x8006b35a
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_sens_map_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_sens_spg_map_max_t
		"Filtration time of boost overpressure pressure for external controls operation"
		VALUE
		0x8006b358
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_sens_spg_map_max_t 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_sens_spg_max
		"Maximum boost pressure measurement for external controls operation"
		VALUE
		0x8006b356
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_sens_spg_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_sens_tco_max
		"Maximum engine coolant temperature (sensor) for external controls operation"
		VALUE
		0x8006b354
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_sens_tco_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_tbt_max
		"Max temperature before turbine for external controls operation"
		VALUE
		0x8006b352
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_tbt_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monisft_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ext_ctrl_vs_thd
		"Vehicle speed threshold to authorize external controls operation."
		VALUE
		0x80056e14
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ext_ctrl_vs_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fac_n_d
		"Filter factor on moving mean value of derivative difference between engine and idle speed"
		VALUE
		0x8005a9e0
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_fac_n_d 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fac_n_drv_d
		"Derivate filter factor"
		VALUE
		0x8005aaa8
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_fac_n_drv_d 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fac_n_drv_fil
		"Derivate filter factor for derivate of engine speed for start engine state"
		VALUE
		0x8005aaa6
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_fac_n_drv_fil 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fac_n_drv_ftc_dyn
		"Factor of filtering of derivate of engine speed"
		VALUE
		0x8005ae14
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fac_n_drv_ftc_dyn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fac_prs_loss
		"Value for pressure loss in the supercharger cooler"
		VALUE
		0x800578dc
		RSA_RecordLayout_VALUE_UWORD
		6000
		lDsheqa_jsDlsDa_ABgqofd_mnCRa0a
		0.
		6000.
    DISPLAY_IDENTIFIER Cxx_fac_prs_loss 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fast_ad_cdn_dly
		"Delay of initialization of recognition of engine speed hook"
		VALUE
		0x8005aa66
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fast_ad_cdn_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fast_dec_slop
		"Value for the fast decrease slope"
		VALUE
		0x8004141a
		RSA_RecordLayout_VALUE_UWORD
		65535
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_fast_dec_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fast_driv_spt_fac_dec_slop
		"decreasing slope of 'fast' driving style factor"
		VALUE
		0x8005917e
		RSA_RecordLayout_VALUE_UWORD
		0.2
		EjEjeBc_Fwbsxha_yuBglkb_ro__1o0
		-0.2
		0.
    DISPLAY_IDENTIFIER Cxx_fast_driv_spt_fac_dec_slop 
    FORMAT "%7.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fast_driv_spt_fac_kd
		"'Fast' driver sportivity factor in KD"
		VALUE
		0x8005917d
		RSA_RecordLayout_VALUE_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fast_driv_spt_fac_kd 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fast_inc_slop
		"Value for the fast increase slope"
		VALUE
		0x80041418
		RSA_RecordLayout_VALUE_UWORD
		65535
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_fast_inc_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fast_off_kd_pdl_thd
		"Cxx_fast_off_kd_pdl_thd"
		VALUE
		0x80059334
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ff_sum_sta_cata_min_1
		"Injected fuel quantity threshold for transition to rgn or to catalyst_heating state (in fail. mode)"
		VALUE
		0x80067f64
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_ff_sum_sta_cata_min_1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fil_fac_dft
		"Default factor for torque slope limitation"
		VALUE
		0x8005afe8
		RSA_RecordLayout_VALUE_UWORD
		65535
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_fil_fac_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_fil_is_i_sp
		"Value of progressive return of the integral correction torque in Out ISR state"
		VALUE
		0x8005ab40
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_fil_is_i_sp 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fim_sum_fac
		"Factor which allows to adapt the Vxx_csm_sum format, only for the CAN Consumption"
		VALUE
		0x80059004
		RSA_RecordLayout_VALUE_UWORD
		100
		coccfFc_twmCjBc_pgCaqeb_n__6o0a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fim_sum_fac 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_flat_dhil_thd
		"Cxx_flat_dhil_thd"
		VALUE
		0x80059766
		RSA_RecordLayout_VALUE_SWORD
		65535
		VA_F_1_p0_13
		-32768
		32767
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_flat_uhil_thd
		"Cxx_flat_uhil_thd"
		VALUE
		0x80059764
		RSA_RecordLayout_VALUE_SWORD
		65535
		VA_F_1_p0_13
		-32768
		32767
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_adv_bch_mod_val
		"Bench mode value for main advance"
		VALUE
		0x80050fba
		RSA_RecordLayout_VALUE_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_fms_adv_bch_mod_val 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_bas_adv_gear
		"Gear engaged ( [-1 0 1 2 3 4 5 6] ) to swith on the specfic correction for the advance of main injection."
		VALUE
		0x8004f38e
		RSA_RecordLayout_VALUE_UBYTE
		8
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_bas_adv_gear 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_adv_pft_asd_rgn
		"Atmospheric pressure correction for main advance during asd rgn"
		VALUE
		0x80069dee
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_fms_cor_adv_pft_asd_rgn 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_fp1_pft_asd_rgn
		"Corrected quantity of pre injection 1 during asd rgn"
		VALUE
		0x8004b42a
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_cor_fp1_pft_asd_rgn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_fp2_pft_asd_rgn
		"Corrected quantity of pre-injection2 during pft regeneration"
		VALUE
		0x8004be0a
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_cor_fp2_pft_asd_rgn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_fpo_pft_asd_rgn
		"Corrected quantity of post injection during asd rgn"
		VALUE
		0x8004ca4a
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_cor_fpo_pft_asd_rgn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_tlp_pft_asd_rgn
		"correction for angle of late post injection during asd rgn"
		VALUE
		0x8004eafe
		RSA_RecordLayout_VALUE_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_fms_cor_tlp_pft_asd_rgn 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_tp1_pft_asd_rgn
		"Correction for separation of pre-injection 1 during asd rgn"
		VALUE
		0x8005340e
		RSA_RecordLayout_VALUE_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_fms_cor_tp1_pft_asd_rgn 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_tp2_pft_asd_rgn
		"Corrected separation of pre-injection2 during asd rgn"
		VALUE
		0x80053ee6
		RSA_RecordLayout_VALUE_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_fms_cor_tp2_pft_asd_rgn 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_cor_tpo_pft_asd_rgn
		"Corrected angle of post injection during pft regeneration"
		VALUE
		0x800549be
		RSA_RecordLayout_VALUE_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_fms_cor_tpo_pft_asd_rgn 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_maf_err_ini
		"Initial value of PT1 for filtered mass air flow error"
		VALUE
		0x80043d7a
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_fms_efi_maf_err_ini 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_maf_err_t_fil
		"Time constant of PT1 for filtered mass air flow error"
		VALUE
		0x80043d78
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fms_efi_maf_err_t_fil 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_maf_n_max_fac_pr
		"Minimum engine speed value to activate the factor of maximum exhaust fuel quantity during pft rgn"
		VALUE
		0x80043d76
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_efi_maf_n_max_fac_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_maf_tqi_max_fac_pr
		"Minimum torque value to activate the factor of maximum exhaust fuel quantity during pft rgn"
		VALUE
		0x80043d74
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_efi_maf_tqi_max_fac_pr 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_asd_utp_min_h
		"High threshold of minimum CSF upstream temperature for exhaust fuel injection during ASD pft rgn"
		VALUE
		0x80067ed4
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_asd_utp_min_h 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_asd_utp_min_l
		"Low threshold of minimum CSF upstream temperature for exhaust fuel injection during ASD pft rgn"
		VALUE
		0x80067ed2
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_asd_utp_min_l 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_csm_min_h_pr
		"High threshold of minimum consumption for exhaust fuel injection during pft regeneration"
		VALUE
		0x80067ed0
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_csm_min_h_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_csm_min_l_pr
		"Low threshold of minimum consumption for exhaust fuel injection during pft regeneration"
		VALUE
		0x80067ece
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_csm_min_l_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_n_min_pr
		"Engine speed threshold for switching off exhaust fuel injection during pft regeneration"
		VALUE
		0x80067ecc
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_n_min_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_n_tout
		"Time out switch off exhaust fuel injection when engine speed is low during pft regeneration"
		VALUE
		0x80067eca
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_n_tout 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_nul_inj_tout
		"Time out switch off exhaust fuel injection when there is no injection in cylinders during pft regeneration"
		VALUE
		0x80067ec8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_nul_inj_tout 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_utp_min_h_pr
		"High threshold for minimum CSF upstream temperature for exhaust fuel injection during CSF rgn"
		VALUE
		0x80067ec6
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_utp_min_h_pr 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_efi_off_utp_min_l_pr
		"Low threshold of minimum CSF upstream temperature for exhaust fuel injection during CSF rgn"
		VALUE
		0x80067ec4
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_efi_off_utp_min_l_pr 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_ext_tq_max_t
		"Maximum time of external torque request for forbiden transition of combustion mode"
		VALUE
		0x8004ea6c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fms_ext_tq_max_t 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_afterxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_bch_mod_val
		"Bench mode value for after injection quantity"
		VALUE
		0x80068180
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_faf_bch_mod_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_gear_h_bas_rij
		"Hight hysteresys basic value of gearbox parameter for after injection activation during rij"
		VALUE
		0x800681a6
		RSA_RecordLayout_VALUE_UBYTE
		9
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		-2.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_faf_gear_h_bas_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_gear_h_cold_rij
		"Hight hysteresys cold value of gearbox parameter for after injection activation during rij"
		VALUE
		0x800681a5
		RSA_RecordLayout_VALUE_UBYTE
		9
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		-2.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_faf_gear_h_cold_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_gear_h_mv_rij
		"Hight hysteresys medium value of gearbox parameter for after injection activation during rij"
		VALUE
		0x800681a4
		RSA_RecordLayout_VALUE_UBYTE
		9
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		-2.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_faf_gear_h_mv_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_gear_hys_rij
		"Hysteresys value of gearbox parameter for after injection activation during rij"
		VALUE
		0x800681a3
		RSA_RecordLayout_VALUE_UBYTE
		9
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		-2.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_faf_gear_hys_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_gear_l_bas_rij
		"Low hysteresys basic value of gearbox parameter for after injection activation during rij"
		VALUE
		0x800681a2
		RSA_RecordLayout_VALUE_UBYTE
		9
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		-2.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_faf_gear_l_bas_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_gear_l_cold_rij
		"Low hysteresys cold value of gearbox parameter for after injection activation during rij"
		VALUE
		0x800681a1
		RSA_RecordLayout_VALUE_UBYTE
		9
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		-2.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_faf_gear_l_cold_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_gear_l_mv_rij
		"Low hysteresys medium value of gearbox parameter for after injection activation during rij"
		VALUE
		0x800681a0
		RSA_RecordLayout_VALUE_UBYTE
		9
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		-2.
		7.
    DISPLAY_IDENTIFIER Cxx_fms_faf_gear_l_mv_rij 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_min_hys
		"half hysteresis value for minimum quantity of after injection"
		VALUE
		0x8006817a
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_faf_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_n_h_bas_rij
		"Hight hysteresys basic value of engine speed parameter for after injection activation during rij"
		VALUE
		0x8006819e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_faf_n_h_bas_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_n_h_cold_rij
		"Hight hysteresys cold value of engine speed parameter for after injection activation during rij"
		VALUE
		0x8006819c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_faf_n_h_cold_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_n_h_mv_rij
		"Hight hysteresys medium value of engine speed parameter for after injection activation during rij"
		VALUE
		0x8006819a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_faf_n_h_mv_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_n_hys_rij
		"Hysteresys value of engine speed parameter for after injection activation during rij"
		VALUE
		0x80068198
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_faf_n_hys_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_n_l_bas_rij
		"Low hysteresys basic value of engine speed parameter for after injection activation during rij"
		VALUE
		0x80068196
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_faf_n_l_bas_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_n_l_cold_rij
		"Low hysteresys cold value of engine speed parameter for after injection activation during rij"
		VALUE
		0x80068194
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_faf_n_l_cold_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_n_l_mv_rij
		"Low hysteresys medium value of engine speed parameter for after injection activation during rij"
		VALUE
		0x80068192
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_faf_n_l_mv_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_tqi_h_bas_rij
		"Hight hysteresys basic value of torque setpoint parameter for after injection activation during rij"
		VALUE
		0x80068190
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_faf_tqi_h_bas_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_tqi_h_cold_rij
		"Hight hysteresys cold value of torque setpoint parameter for after injection activation during rij"
		VALUE
		0x8006818e
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_faf_tqi_h_cold_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_tqi_h_mv_rij
		"Hight hysteresys medium value of torque setpoint parameter for after injection activation during rij"
		VALUE
		0x8006818c
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_faf_tqi_h_mv_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_tqi_hys_rij
		"Hysteresys value of torque setpoint parameter for after injection activation during rij"
		VALUE
		0x8006818a
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_faf_tqi_hys_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_tqi_l_bas_rij
		"Low hysteresys basic value of torque setpoint parameter for after injection activation during rij"
		VALUE
		0x80068188
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_faf_tqi_l_bas_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_tqi_l_cold_rij
		"Low hysteresys cold value of torque setpoint parameter for after injection activation during rij"
		VALUE
		0x80068186
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_faf_tqi_l_cold_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_faf_tqi_l_mv_rij
		"Low hysteresys medium value of torque setpoint parameter for after injection activation during rij"
		VALUE
		0x80068184
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_faf_tqi_l_mv_rij 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp1_min_hys
		"half hysteresis value for minimum quantity of late post injection 1"
		VALUE
		0x8004980c
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_flp1_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp1_rat
		"Split factor of late post injection 1 and 2"
		VALUE
		0x8004980a
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_flp1_rat 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp2_min_hys
		"half hysteresis value for minimum quantity of late post injection 2"
		VALUE
		0x80049808
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_flp2_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp2_wish_l
		"Low level of activation of split late post injection"
		VALUE
		0x80049806
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_flp2_wish_l 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_lpostxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp_bch_mod_val
		"Bench mode value for late post injection quantity"
		VALUE
		0x80068c3e
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_flp_bch_mod_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp_maf_err_ini
		"Initial value of PT1 for filtered mass air flow error"
		VALUE
		0x80043d72
		RSA_RecordLayout_VALUE_SWORD
		6000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cxx_fms_flp_maf_err_ini 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp_maf_err_t_fil
		"Time constant of PT1 for filtered mass air flow error"
		VALUE
		0x80043d70
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fms_flp_maf_err_t_fil 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp_maf_n_max_fac_pr
		"Minimum engine speed to activate the factor of maximum late post-injection quantity during pft rgn"
		VALUE
		0x80043d6e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_flp_maf_n_max_fac_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp_maf_tqi_max_fac_pr
		"Minimum torque to activate the factor of maximum late postinjection quantity during pft rgn"
		VALUE
		0x80043d6c
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_fms_flp_maf_tqi_max_fac_pr 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_flp_min_hys
		"half hysteresis value for minimum quantity of late post injection"
		VALUE
		0x80049804
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_flp_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_mainxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fma_bch_mod_val
		"Bench mode value for main injection quantity"
		VALUE
		0x80068c42
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_fma_bch_mod_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fp1_bch_mod_val
		"Bench mode value for pre-injection 1 angle"
		VALUE
		0x80068e0e
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_fp1_bch_mod_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fp1_fim_main_rat
		"Ratio of quantity main for pre injection 1 without pre-inejction 2"
		VALUE
		0x80068e0c
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_fp1_fim_main_rat 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fp1_fim_main_rat_2p
		"Ratio of quantity main for pre injection 1 with pre-inejction 2"
		VALUE
		0x80068e0a
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_fp1_fim_main_rat_2p 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fp1_min_hys
		"half hysteresis value for minimum quantity of pre-injection 1"
		VALUE
		0x8006817c
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_fp1_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fp2_bch_mod_val
		"Bench mode value for pre-injection 2 quantity"
		VALUE
		0x8004c5a8
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_fp2_bch_mod_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fp2_fim_main_rat
		"Ratio of quantity main for pre injection 2"
		VALUE
		0x8004c5a6
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_fp2_fim_main_rat 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fp2_min_hys
		"half hysteresis value for minimum quantity of pre-injection 2"
		VALUE
		0x800498b6
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_fp2_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fpo_bch_mod_val
		"Bench mode value for post injection quantity"
		VALUE
		0x80068e12
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_fpo_bch_mod_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_fpo_min_hys
		"half hysteresis value for minimum quantity of post injection"
		VALUE
		0x8006817e
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_fpo_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_asd_utp_min_h
		"High threshold of minimum CSF upstream temperature for late post injection during ASD pft rgn"
		VALUE
		0x80067ee8
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_asd_utp_min_h 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_asd_utp_min_l
		"Low threshold of minimum CSF upstream temperature for late post injection during ASD pft rgn"
		VALUE
		0x80067ee6
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_asd_utp_min_l 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_csm_min_h_pr
		"High threshold of minimum consumption for late post injection during pft regeneration"
		VALUE
		0x80067ee4
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_csm_min_h_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_csm_min_l_pr
		"Low threshold of minimum consumption for late post injection during pft regeneration"
		VALUE
		0x80067ee2
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_csm_min_l_pr 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_n_min_pr
		"Engine speed threshold to switch off late post injection during pft regeneration"
		VALUE
		0x80067ee0
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_n_min_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_n_tout
		"Time out switch off late post injection when engine is low during pft regeneration"
		VALUE
		0x80067ede
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_n_tout 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_nul_inj_tout
		"Time out switch off late post injection when there is no injection in cylinders during pft regeneration"
		VALUE
		0x80067edc
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_nul_inj_tout 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_utp_min_h_pr
		"High threshold of minimum upstream CSF temperature for late post injection during pft rgn"
		VALUE
		0x80067eda
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_utp_min_h_pr 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_lpos_off_utp_min_l_pr
		"Low threshold of minimum upstream CSF temperature for late post injection during pft rgn"
		VALUE
		0x80067ed8
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fms_lpos_off_utp_min_l_pr 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_main_fim_min_hys
		"half hysteresis value for minimum quantity of main injection"
		VALUE
		0x800498b4
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_fms_main_fim_min_hys 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_amp1
		"Atmospheric pressure thresold one to activate the specific calibration of cutting pre injection"
		VALUE
		0x8004c5d0
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_amp1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_amp2
		"Atmospheric pressure thresold two to activate the specific calibration of cutting pre injection"
		VALUE
		0x8004c5ce
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_amp2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_gear1
		"Gear ratio thresold one to activate the specific calibration of cutting pre injection"
		VALUE
		0x8004c5cd
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_gear1 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_gear2
		"Gear ratio thresold two to activate the specific calibration of cutting pre injection"
		VALUE
		0x8004c5cc
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_gear2 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_n_tqi_hys1
		"Hysteresis value 1 for the output of the map Cmp_fms_pinj_cut_1, 2, 3, 4, 5"
		VALUE
		0x8004c5ca
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_n_tqi_hys1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_n_tqi_hys2
		"Hysteresis value 2 for the output of the map Cmp_fms_pinj_cut_1, 2, 3, 4, 5"
		VALUE
		0x8004c5c8
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_n_tqi_hys2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_tco_hys1
		"Hysteresis value 1 for the input of the map Cmp_fms_bas, amp, gear, comb_mod, _pinj_cut"
		VALUE
		0x8004c5c6
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_tco_hys1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_tco_hys2
		"Hysteresis value 2 for the input of the map Cmp_fms_bas, amp, gear, comb_mod, _pinj_cut"
		VALUE
		0x8004c5c4
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_tco_hys2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_tia_hys1
		"Hysteresis value 1 for the input of the map Cmp_fms_bas, amp, gear, comb_mod, _pinj_cut"
		VALUE
		0x8004c5c2
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_tia_hys1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_pinj_cut_tia_hys2
		"Hysteresis value 2 for the input of the map Cmp_fms_bas, amp, gear, comb_mod, _pinj_cut"
		VALUE
		0x8004c5c0
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_fms_pinj_cut_tia_hys2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_afterxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_taf_bch_mod_val
		"Bench mode value for after separation"
		VALUE
		0x8006925c
		RSA_RecordLayout_VALUE_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_fms_taf_bch_mod_val 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_tlp_bch_mod_val
		"Bench mode value for late post injection angle"
		VALUE
		0x80069dea
		RSA_RecordLayout_VALUE_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_fms_tlp_bch_mod_val 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_tp1_bch_mod_val
		"Bench mode value for pre-injection 1 separation"
		VALUE
		0x80053ee2
		RSA_RecordLayout_VALUE_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_fms_tp1_bch_mod_val 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_tp2_bch_mod_val
		"Bench mode value for pre-injection 2 separation"
		VALUE
		0x800549ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_fms_tp2_bch_mod_val 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fms_tpo_bch_mod_val
		"Bench mode value for post injection angle"
		VALUE
		0x8005524e
		RSA_RecordLayout_VALUE_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_fms_tpo_bch_mod_val 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcfshou_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_free_shf_dft_val
		"value send if free shit can't be calculated (0 or 3)"
		VALUE
		0x8006b201
		RSA_RecordLayout_VALUE_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		3.
    DISPLAY_IDENTIFIER Cxx_free_shf_dft_val 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcfshou_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_free_shf_ini_val
		"Freeshift initial value sent on the CAN."
		VALUE
		0x8006b200
		RSA_RecordLayout_VALUE_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		3.
    DISPLAY_IDENTIFIER Cxx_free_shf_ini_val 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_free_shf_no_pdl
		"Cxx_free_shf_no_pdl"
		VALUE
		0x800593d0
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_free_shf_no_pdl_brk_ass
		"Cxx_free_shf_no_pdl_brk_ass"
		VALUE
		0x800593ce
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_free_shf_no_pdl_fast_off
		"Cxx_free_shf_no_pdl_fast_off"
		VALUE
		0x80059332
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_free_shf_no_pdl_fast_on
		"Cxx_free_shf_no_pdl_fast_on"
		VALUE
		0x80059352
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_frst_edge_dly
		"Calibration used for EGR bypass activation delay"
		VALUE
		0x80043ac0
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_frst_edge_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_frst_sta_dly
		"Specific time out before starter stop demand for the first engine cranking"
		VALUE
		0x8005cef0
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_frst_sta_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fwe_tco_max
		"Maximal engine coolant temperature"
		VALUE
		0x80058f2c
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_fwe_tco_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_fwe_tt_max
		"Measured temperature before turbine maximal"
		VALUE
		0x80058f2a
		RSA_RecordLayout_VALUE_UWORD
		1200
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		0.
		1200.
    DISPLAY_IDENTIFIER Cxx_fwe_tt_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_gear_df_spg
		"Gear engaged in case of invalid gear detected for supercharger strategy"
		VALUE
		0x8005d086
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_gear_df_spg 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_gear_df_tran
		"Gear engaged in case of invald gear detected for transient saturation strategy"
		VALUE
		0x800434c2
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_gear_df_tran 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_gbxlixx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_gear_dft_lim_tq
		"Maximum torque to protect gearbox (default mode)"
		VALUE
		0x8005b216
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_gear_dft_lim_tq 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_gear_max
		"Cxx_gear_max"
		VALUE
		0x80059366
		RSA_RecordLayout_VALUE_UBYTE
		5
		VA_F_1_p1_2
		1
		6
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_gear_max_tqe_h
		"Limit between the high ratio and the low ratio"
		VALUE
		0x80041933
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_gear_max_tqe_h 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_gear_mon
		"Gear engaged"
		VALUE
		0x80043b5a
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_gear_mon 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_h_blk_is_alt_pow
		"High theshold on filtered alternator mechanical power to authorize the detection of an engine speed hook"
		VALUE
		0x8005aa64
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_h_blk_is_alt_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_h_gear_win_thd
		"Window size calibration for detection of new gear engaged (high gears)"
		VALUE
		0x8006b250
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_h_gear_win_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_h_prs_ac_dsb_dly
		"Authorized time of high AC pressure before AC compressor inhibition"
		VALUE
		0x8005cee6
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_h_prs_ac_dsb_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_h_prs_ac_dsb_hys
		"High pressure hysteresis of the AC compressor inhibition threshold"
		VALUE
		0x8005cee4
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_h_prs_ac_dsb_hys 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_h_prs_ac_dsb_thd
		"Maximum AC pressure before compressor inhibition"
		VALUE
		0x8005cee2
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_h_prs_ac_dsb_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_h_thd_tra_acel_ok
		"High threshold of Abs_gt_avg to validate the information of the transverse acceleration"
		VALUE
		0x80058abe
		RSA_RecordLayout_VALUE_UWORD
		13.5
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		0.
		13.5
    DISPLAY_IDENTIFIER Cxx_h_thd_tra_acel_ok 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_hpf_fac_ups_lamb
		"Time constant for filtering upstream proportional lambda value"
		VALUE
		0x80058382
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_hpf_fac_ups_lamb 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_hpf_fac_ups_rich
		""
		VALUE
		0x80058380
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_hpf_fac_ups_rich 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_i_agb_driv_tq_thd
		"Upper threshold of torque integrator detecting irregular shifts"
		VALUE
		0x8005876e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		cBcxaAb_uwygFqb_dmopcrc_N___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_i_agb_driv_tq_thd 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_i_fac_ex_reg_neg_slop
		"Negative slope for i part corrction factor for exhaust pressure limitation"
		VALUE
		0x8005d064
		RSA_RecordLayout_VALUE_UWORD
		327.67
		oztfsAd_CwctBpb_rFDnrpa_1__000a
		-327.67
		0.
    DISPLAY_IDENTIFIER Cxx_i_fac_ex_reg_neg_slop 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_i_fac_ex_reg_pos_slop
		"Positive slope for i part corrction factor for exhaust pressure limitation"
		VALUE
		0x8005d062
		RSA_RecordLayout_VALUE_UWORD
		327.67
		FhAkxid_mcktvDd_ysgmcea_1__000a
		0.
		327.67
    DISPLAY_IDENTIFIER Cxx_i_fac_ex_reg_pos_slop 
    FORMAT "%7.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_i_fac_neg_slop
		"Negative slope for i part corrction factor"
		VALUE
		0x8005d060
		RSA_RecordLayout_VALUE_UWORD
		327.67
		oztfsAd_CwctBpb_rFDnrpa_1__000a
		-327.67
		0.
    DISPLAY_IDENTIFIER Cxx_i_fac_neg_slop 
    FORMAT "%8.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_i_fac_pos_slop
		"Positive slope for i part corrction factor"
		VALUE
		0x8005d05e
		RSA_RecordLayout_VALUE_UWORD
		327.67
		FhAkxid_mcktvDd_ysgmcea_1__000a
		0.
		327.67
    DISPLAY_IDENTIFIER Cxx_i_fac_pos_slop 
    FORMAT "%7.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_ac_sp
		"Type of increase  slope for the air conditionning idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041416
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_ac_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_acs_sp
		"Type of increase slope for the accessories idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041415
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_acs_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_agb_sp
		"Type of increase  slope for the AGB idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041414
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_agb_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_dgi_sp
		"Type of increase slope for the diagnosis and protection idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041413
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_dgi_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_diag_vvtc_sp
		"Type of increase slope for the VVTC routine idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041412
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_diag_vvtc_sp 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_el_bk_sp
		"Type of increase slope for the electrical backlite idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041411
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_el_bk_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_el_wind_sp
		"Type of increase  slope for the electrical windshield idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041410
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_el_wind_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_inj_sp
		"Type of increase slope for the injector idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004140f
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_inj_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_moni_sp
		"Type of increase  slope for the monitool idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004140e
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_moni_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_pft_sp
		"Type of increase  slope for the particle filter idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004140d
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_pft_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_ptc_sp
		"Type of increase  slope for the PTC idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004140c
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_ptc_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_pwst_sp
		"Type of increase  slope for the power steering idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004140b
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_pwst_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_run_vh_sp
		"Type of increase  slope for the running vehicle idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x8004140a
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_run_vh_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_tco_sp
		"Type of increase  slope for the coolant temperature idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041409
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_tco_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inc_slop_thpl_sp
		"Type of increase  slope for the thermoplunger idle speed setpoint (1=Low 2=Med 3=Fast)"
		VALUE
		0x80041408
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_inc_slop_thpl_sp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ini_i_fac
		"Factor on the losses to estimate the couple of initialization of the integral torque"
		VALUE
		0x8005ab3e
		RSA_RecordLayout_VALUE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_ini_i_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_entrfxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ini_stop_dly
		"Inhibition delay of the judgement of the engine stop state"
		VALUE
		0x8005afda
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ini_stop_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_inj_cmd_max_npu
		"Maximal number of injection per stroke that the system is able to achieve for the Nox purge mode"
		VALUE
		0x8004ea6a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_inj_cmd_max_npu 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_inj_cmd_max_ocd
		"Maximal number of injection per stroke that the system is able to achieve for the Nox purge mode"
		VALUE
		0x8004ea69
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_inj_cmd_max_ocd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_inj_cmd_max_pr
		"Maximal number of injection per stroke that the system is able to achieve for the particulate filter regeneration mode"
		VALUE
		0x8004ea68
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_inj_cmd_max_pr 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntspcxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inj_stop_n_ofs
		"injection stop offset"
		VALUE
		0x8005af2c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_inj_stop_n_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_inj_vld_min_is_n
		"Default value if a default is detected on the engine speed sensor"
		VALUE
		0x8005adec
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_inj_vld_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ip_abst_frm_dly
		"Cluster Control Unit absence detection time-out"
		VALUE
		0x80055bcc
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ip_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ip_ecu_conf
		"Cluster Control Unit feature for Mux Network configuration detection (always present or optional)"
		VALUE
		0x80055bcb
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ip_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ip_vld_abst_frm_dec
		"Cluster Control Unit : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bca
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ip_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_ip_vld_abst_frm_inc
		"Cluster Control Unit : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bc9
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ip_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_act_ofs
		"Offset about idle speed setpoint to create activate idle speed state threshold"
		VALUE
		0x8005aaa4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_act_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_data.c' */
/begin CHARACTERISTIC
		Cxx_is_ad_tq_dft
		"First value and default calibration of adaptive correction torque about erasing authorization after a clear diag info request from the"
		VALUE
		0x8005a9dc
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_is_ad_tq_dft 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_ast_ofs_zon
		"Zone of offset about idle speed setpoint to generate a setpoint in after start state"
		VALUE
		0x8005aaa2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_ast_ofs_zon 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_cdn_h_sta_n_dly
		"Delay after start during threshold to exit condition state is increased"
		VALUE
		0x8005aaa0
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_is_cdn_h_sta_n_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_ctl_mux_min_p
		"Minimum proportional torque correction when an intersystem torque request is in progress"
		VALUE
		0x8005acb6
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_is_ctl_mux_min_p 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_d_pft_rgn_fac
		"Derivate correction factor in case of particulate filter regeneration"
		VALUE
		0x8005a9de
		RSA_RecordLayout_VALUE_UWORD
		2
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_is_d_pft_rgn_fac 
    FORMAT "%11.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_deci_in_dly
		"Delay to force activate state when engine speed is reacher"
		VALUE
		0x8005aa9e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_is_deci_in_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_deci_in_n_thd
		"Threshold of engine speed beyond which the strategy of forced entry to ISR is inhibited"
		VALUE
		0x8005aa9c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_deci_in_n_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_fil_drv_n_max_ofs
		"Offset of (offset + zone of offset) about idle speed setpoint to generate a setpoint in after start state"
		VALUE
		0x8005aa9a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_fil_drv_n_max_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_fil_drv_n_min
		"Threshold of hysteresis on engine speed to authorize a filtred derivate of engine speed"
		VALUE
		0x8005aa98
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_fil_drv_n_min 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_i_out_fil_fac
		"Filtering factor of filtered integral correction"
		VALUE
		0x8005ab3c
		RSA_RecordLayout_VALUE_UWORD
		1
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_is_i_out_fil_fac 
    FORMAT "%11.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_i_out_fil_wit_pdl_fac
		"Filtering factor of filtered integral correction without powertrain setpoint request"
		VALUE
		0x8005ab3a
		RSA_RecordLayout_VALUE_UWORD
		1
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_is_i_out_fil_wit_pdl_fac 
    FORMAT "%11.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_i_pft_rgn_fac
		"Integral correction factor in case of particulate filter regeneration"
		VALUE
		0x8005ab38
		RSA_RecordLayout_VALUE_UWORD
		2
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_is_i_pft_rgn_fac 
    FORMAT "%11.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_i_set_ofs
		"Engine speed threshold for fixed integral correction"
		VALUE
		0x8005ab36
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_is_i_set_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_i_tq_trs_ctl_mux_n_in
		"Engine speed threshold to fix integral correction under inter-system request"
		VALUE
		0x8005ab34
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_is_i_tq_trs_ctl_mux_n_in 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_i_tq_trs_ctl_mux_n_out
		"Engine speed threshold to stop fixed integral correction under inter-system request"
		VALUE
		0x8005ab32
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_is_i_tq_trs_ctl_mux_n_out 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_i_zon_out_dly
		"Delay of initialization of recognition of exit of engine speed hook"
		VALUE
		0x8005aa62
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_is_i_zon_out_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_in_cdn_ofs
		"Offset on the threshold determined by the derivate of engine speed"
		VALUE
		0x8005aa96
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_in_cdn_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_in_cdn_ofs2
		"Offset on the threshold determined by the derivate of engine speed when we are not entered in active ISR at the end of a temporization"
		VALUE
		0x8005aa94
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_in_cdn_ofs2 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_in_dly
		"Delay to enter in activate state after condition state (coming out IS)"
		VALUE
		0x8005aa92
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_is_in_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_in_pump_thd
		"Threshold below control can enter in activate state"
		VALUE
		0x8005aa90
		RSA_RecordLayout_VALUE_UWORD
		1
		mjxFltb_kfnvCoc_mCDcAhb_B__020a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_is_in_pump_thd 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_in_wit_pdl_ofs
		"Offset about idle speed setpoint to enter in ISR with a powertrain setpoint request"
		VALUE
		0x8005aa8e
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_is_in_wit_pdl_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_act
		"Engine speed threshold under ISR calculation is authorised"
		VALUE
		0x8005aa8c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_n_act 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_act_hys
		"Engine speed hysteresis to deactivate ISR"
		VALUE
		0x8005aa8a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_n_act_hys 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_max_is_i
		"Engine speed threshold to decrease the positive integral"
		VALUE
		0x8005ab30
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_n_max_is_i 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_max_is_i_grd
		"Torque gradient to decrease the integral"
		VALUE
		0x8005ab2e
		RSA_RecordLayout_VALUE_UWORD
		7.9998779296875
		xdBqnAa_fmFFrja_Dkxfxyb_Np__1a0
		0.
		7.9998779296875
    DISPLAY_IDENTIFIER Cxx_is_n_max_is_i_grd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_min_is_i
		"Engine speed threshold to increase the negative integral"
		VALUE
		0x8005ab2c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_n_min_is_i 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_min_is_i_grd
		"Torque gradient to increase the integral"
		VALUE
		0x8005ab2a
		RSA_RecordLayout_VALUE_UWORD
		7.9998779296875
		xdBqnAa_fmFFrja_Dkxfxyb_Np__1a0
		0.
		7.9998779296875
    DISPLAY_IDENTIFIER Cxx_is_n_min_is_i_grd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_sp_max
		"Maximum idle speed setpoint authorized"
		VALUE
		0x80041406
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_n_sp_max 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_sp_min
		"Minimum idle speed setpoint authorized"
		VALUE
		0x80041404
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_n_sp_min 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_stab_clc_fac
		"Stability engine speed factor in idle speed"
		VALUE
		0x8005aa88
		RSA_RecordLayout_VALUE_UWORD
		0.001998046875
		qDDtqcc_gayxvEc_qlEivjc_s__200a
		0.
		0.001998046875
    DISPLAY_IDENTIFIER Cxx_is_n_stab_clc_fac 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_stab_clc_ini
		"anti-pumping factor initialisation"
		VALUE
		0x8005aa86
		RSA_RecordLayout_VALUE_UWORD
		1
		mjxFltb_kfnvCoc_mCDcAhb_B__020a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_is_n_stab_clc_ini 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_n_stab_drv_thd
		"Stability derivative engine speed threshold in idle speed"
		VALUE
		0x8005aa84
		RSA_RecordLayout_VALUE_UWORD
		8191
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		0.
		8191.
    DISPLAY_IDENTIFIER Cxx_is_n_stab_drv_thd 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_ast_dly
		"Delay to enter in condition idle speed state after a start"
		VALUE
		0x8005aa82
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_is_out_ast_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_drv_thd
		"Threshold about derivate of engine speed to exit of ISR"
		VALUE
		0x8005aa80
		RSA_RecordLayout_VALUE_SWORD
		16383
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		-8192.
		8191.
    DISPLAY_IDENTIFIER Cxx_is_out_drv_thd 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_dyn_ofs
		"Offset on the dynamic setpoint to reset the dynamic setpoint in Cdn and Act states about in case of an overshoot of engine speed"
		VALUE
		0x8005ae12
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_out_dyn_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_n_ofs
		"Offset about setpoint to exit condition state"
		VALUE
		0x8005aa7e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_out_n_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_n_ofs_sta
		"Offset about setpoint to exit activate state"
		VALUE
		0x8005aa7c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_out_n_ofs_sta 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_n_run_vh_thd
		"Threshold about engine speed to exit of ISR (vehicle running)"
		VALUE
		0x8005aa7a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_out_n_run_vh_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_n_stop_vh_thd
		"Threshold about engine speed to exit of ISR (vehicle stopped)"
		VALUE
		0x8005aa78
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_is_out_n_stop_vh_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_pump_thd
		"Threshold above control can exit of activate state"
		VALUE
		0x8005aa76
		RSA_RecordLayout_VALUE_UWORD
		1
		mjxFltb_kfnvCoc_mCDcAhb_B__020a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_is_out_pump_thd 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_out_wit_pdl_ofs
		"Offset about idle speed setpoint to exit of ISR with a powertrain setpoint request"
		VALUE
		0x8005aa74
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_is_out_wit_pdl_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_p_dec_slop
		"Value of the decrease slop for proportional correction"
		VALUE
		0x8005acb4
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		bEowska_EEdlCia_rswmrta_NsA_30a
		-2047.96875
		0.
    DISPLAY_IDENTIFIER Cxx_is_p_dec_slop 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_p_inc_slop
		"Value of the increase slop for proportional correction"
		VALUE
		0x8005acb2
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		Amrmhjb_saoiymc_dComzyc_NsA_30a
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_is_p_inc_slop 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_p_pft_rgn_fac
		"Proportionnal correction factor in case of particulate filter regeneration"
		VALUE
		0x8005acb0
		RSA_RecordLayout_VALUE_UWORD
		2
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_is_p_pft_rgn_fac 
    FORMAT "%11.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_p_sta_max
		"Maximum proportionnal torque correction for the Start state"
		VALUE
		0x8005acae
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_is_p_sta_max 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_is_run_vh_min_crp
		"Threshold of speed vehicle to cancel the increase of idle speed setpoint in case of vehicle creeping"
		VALUE
		0x8005ada2
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_is_run_vh_min_crp 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idctrxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_is_tgt_ftc
		"Raw torque filter factor"
		VALUE
		0x8005ab00
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_is_tgt_ftc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_blk_dly_1
		"Delay, after the closing request, before activating the full closing check strategy."
		VALUE
		0x80058c4c
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_it_blk_dly_1 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_blk_dly_2
		"Duration of the full closing check strategy. After this delay, Vbx_it_blk_chk_ok rises to 1."
		VALUE
		0x80058c4b
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_it_blk_dly_2 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_blk_fail_mod
		"Failure mode associated with the blocked IT during full closing."
		VALUE
		0x80058c4a
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_it_blk_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_blk_thd
		"Threshold used during Regulation Diagnosis, under which the valve is closed."
		VALUE
		0x80058c48
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_blk_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_clos_ctr_1
		"Time counter to ensure that the valve is closed."
		VALUE
		0x80058cb0
		RSA_RecordLayout_VALUE_UWORD
		1024
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1024.
    DISPLAY_IDENTIFIER Cxx_it_clos_ctr_1 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_clos_cut_thd
		"Position value over which the component is considered as closed (during full closing)"
		VALUE
		0x80043b76
		RSA_RecordLayout_VALUE_SWORD
		200
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_it_clos_cut_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_clos_thd
		"Position value under which the component is considered as closed (during full closing)."
		VALUE
		0x80058c46
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_clos_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_cmd_val_1
		"Parameter corresponding to the S1 coefficient of the RST Controller."
		VALUE
		0x80058da8
		RSA_RecordLayout_VALUE_UWORD
		1
		zaiesxc_pDtfwqc_lixtcqc_nA_0a00
		-1.
		0.
    DISPLAY_IDENTIFIER Cxx_it_cmd_val_1 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_cmd_val_2
		"Parameter corresponding to the S2 coefficient of the RST Controller."
		VALUE
		0x80058da6
		RSA_RecordLayout_VALUE_UWORD
		1
		zaiesxc_pDtfwqc_lixtcqc_nA_0a00
		-1.
		0.
    DISPLAY_IDENTIFIER Cxx_it_cmd_val_2 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_cmd_val_3
		"Parameter corresponding to the S3 coefficient of the RST Controller."
		VALUE
		0x80058da4
		RSA_RecordLayout_VALUE_UWORD
		1
		zaiesxc_pDtfwqc_lixtcqc_nA_0a00
		-1.
		0.
    DISPLAY_IDENTIFIER Cxx_it_cmd_val_3 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_cps_v
		"Constant Compensation Voltage (if needed)."
		VALUE
		0x80058da2
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_it_cps_v 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_crt_val_neg_dly_1
		"Time delay before enabling the current limitation strategy for negative current."
		VALUE
		0x80058c45
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_it_crt_val_neg_dly_1 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_crt_val_neg_dly_2
		"Time delay before stopping the current limitation strategy for negative current."
		VALUE
		0x80058c44
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_it_crt_val_neg_dly_2 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_crt_val_pos_dly_1
		"Time delay before enabling the current limitation strategy for positive current."
		VALUE
		0x80058c43
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_it_crt_val_pos_dly_1 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_crt_val_pos_dly_2
		"Time delay before stopping the current limitation strategy for positive current."
		VALUE
		0x80058c42
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_it_crt_val_pos_dly_2 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ctl_lim
		"Limitation used in the RST controller to take into account the max. battery voltage."
		VALUE
		0x80058da0
		RSA_RecordLayout_VALUE_UWORD
		24.9996185302734
		BDbaydc_ejoxiEd_lqghvcb_n_ao00a
		0.
		24.9996185302734
    DISPLAY_IDENTIFIER Cxx_it_ctl_lim 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_dft_psn_1
		"Default value of the abs. position when a failure is detected."
		VALUE
		0x80057cf8
		RSA_RecordLayout_VALUE_UWORD
		100
		wmkbkad_wwidqld_lsCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_dft_psn_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_el_fail_mod
		"Failure mode associated with an electric failure on the component (Hbridge, bv ...)"
		VALUE
		0x80058c41
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_it_el_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_frn_cps_v
		"Absolute value of the Friction Compensation Voltage."
		VALUE
		0x80058d9e
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_it_frn_cps_v 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_ctr_1_max
		"Maximal number of iterations to calculate the medium value of the position during Offset Learning."
		VALUE
		0x80058cae
		RSA_RecordLayout_VALUE_UWORD
		1000
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1000.
    DISPLAY_IDENTIFIER Cxx_it_ofs_ctr_1_max 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_fail_mod
		"Failure mode associated with an offset learning failure."
		VALUE
		0x80058c40
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_it_ofs_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_lim_clos_down
		"Minimum value of the first learnt offset."
		VALUE
		0x80058c3e
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_ofs_lim_clos_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_lim_clos_up
		"Maximum value of the first learnt offset."
		VALUE
		0x80058c3c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_ofs_lim_clos_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_lim_open_down
		"Minimum value of the first learnt offset (open thrust)"
		VALUE
		0x80058c3a
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_ofs_lim_open_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_lim_open_up
		"Maximum value of the first learnt offset (open thrust)"
		VALUE
		0x80058c38
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_ofs_lim_open_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_tco_thd_max
		"Coolant temperature threshold to allow the offset learning. Upper limit."
		VALUE
		0x80058cac
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_it_ofs_tco_thd_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_ofs_tco_thd_min
		"Coolant temperature threshold to allow the offset learning. Lower limit."
		VALUE
		0x80058caa
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_it_ofs_tco_thd_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_open_ctr_1
		"Time counter to ensure that the valve is open."
		VALUE
		0x80058ca8
		RSA_RecordLayout_VALUE_UWORD
		1024
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1024.
    DISPLAY_IDENTIFIER Cxx_it_open_ctr_1 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_open_dly
		"Delay to declare the IT open: Vbx_it_open_0 = 1"
		VALUE
		0x80058c36
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_it_open_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_open_nok_thd
		"Position value under which the component is not considered as fully opened"
		VALUE
		0x80058c34
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_open_nok_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_open_thd
		"Position value above which the component is considered as open (during full opening)."
		VALUE
		0x80058c32
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_open_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_clos_rel_thd
		"Relative position value to consider the component closed"
		VALUE
		0x80058ca6
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_clos_rel_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_cmd_clos
		"Threshold on Vxx_it_psn_sp_cmd to indicate a full closing"
		VALUE
		0x80058c30
		RSA_RecordLayout_VALUE_SWORD
		200
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_cmd_clos 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_cmd_open
		"Threshold on Vxx_it_psn_sp_cmd to indicate a full opening"
		VALUE
		0x80058c2e
		RSA_RecordLayout_VALUE_SWORD
		200
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_cmd_open 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ctl_0
		"Parameter corresponding to the R0 coefficient of the RST Controller."
		VALUE
		0x80058d9c
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_it_psn_ctl_0 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ctl_1
		"Parameter corresponding to the R1 coefficient of the RST Controller."
		VALUE
		0x80058d9a
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_it_psn_ctl_1 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ctl_2
		"Parameter corresponding to the R2 coefficient of the RST Controller."
		VALUE
		0x80058d98
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_it_psn_ctl_2 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ctl_3
		"Parameter corresponding to the R3 coefficient of the RST Controller."
		VALUE
		0x80058d96
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_it_psn_ctl_3 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_cutt_thd
		"Maximum diff. allowed btw the last threshold and the read value before detecting a cutting."
		VALUE
		0x80058c2c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_cutt_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_frn_cps_thd
		"Absolute value of the area near the position setpoint where the friction compensation voltage is 0."
		VALUE
		0x80058d94
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_frn_cps_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_lim_down
		"Defines the range near the closed thrust to activate the approach strategy."
		VALUE
		0x80058ca4
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_lim_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_lim_up
		"Defines the range near the open thrust to activate the approach strategy."
		VALUE
		0x80058ca2
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_lim_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_min
		"Minimal value of the inlet throttle position"
		VALUE
		0x80063b76
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_it_psn_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_off
		"Value of the position of the opened inlet throttle"
		VALUE
		0x80063b74
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_it_psn_off 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_off_slop_neg
		"Negative slope for throttle closure"
		VALUE
		0x80063b70
		RSA_RecordLayout_VALUE_ULONG
		65535
		uAwArwa_iohEDEc_mwmdljb_BDA0a70
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_it_psn_off_slop_neg 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_off_slop_pos
		"Positive slope for throttle opening"
		VALUE
		0x80063b6c
		RSA_RecordLayout_VALUE_ULONG
		65535
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_it_psn_off_slop_pos 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ofs_clos_frst_eprm
		"Default value of the first closed offset position stored in EEPROM"
		VALUE
		0x80058ca0
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_ofs_clos_frst_eprm 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ofs_clos_last_eprm
		"Default value of the last closed offset position stored in EEPROM"
		VALUE
		0x80058c9e
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_ofs_clos_last_eprm 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ofs_frst_thd
		"Maximum difference btw the first offset and the read value of the thrust before detecting a failure"
		VALUE
		0x80058c2a
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_ofs_frst_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ofs_lim_down
		"Defines the range near the closed thrust to activate the approach strategy during offset learning."
		VALUE
		0x80058c9c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_ofs_lim_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ofs_lim_up
		"Defines the range near the open thrust to activate the approach strategy during offset learning."
		VALUE
		0x80058c9a
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_ofs_lim_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ofs_open_frst_eprm
		"Default value of the first open offset position stored in EEPROM"
		VALUE
		0x80058c98
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_ofs_open_frst_eprm 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_ofs_open_last_eprm
		"Default value of the last open offset position stored in EEPROM"
		VALUE
		0x80058c96
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_ofs_open_last_eprm 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_open_rel_thd
		"Relative position to consider the component open."
		VALUE
		0x80058c94
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_open_rel_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_rat_thd
		"Position ratio threshold under which a failure is dectected (full opening or closing failure)."
		VALUE
		0x80058c29
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_it_psn_rat_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_slop_lim_down
		"Slope corresponding to the maximum negative approach speed of the closed thrust."
		VALUE
		0x80058d92
		RSA_RecordLayout_VALUE_UWORD
		100
		prgtCkd_krawoFb_tmjbqrb_f__no0a
		-100.
		0.
    DISPLAY_IDENTIFIER Cxx_it_psn_slop_lim_down 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_slop_lim_down_1
		"Slope corresponding to the maximum speed while closing."
		VALUE
		0x80058d90
		RSA_RecordLayout_VALUE_UWORD
		100
		prgtCkd_krawoFb_tmjbqrb_f__no0a
		-100.
		0.
    DISPLAY_IDENTIFIER Cxx_it_psn_slop_lim_down_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_slop_lim_up
		"Slope corresponding to the maximum approach speed of the open thrust."
		VALUE
		0x80058d8e
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_slop_lim_up 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_slop_lim_up_1
		"Slope corresponding to the maximum speed while opening."
		VALUE
		0x80058d8c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_slop_lim_up_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_clos_thd_in
		"Setpoint position threshold to initiate the closing procedure."
		VALUE
		0x80058c92
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_clos_thd_in 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_clos_thd_out
		"Setpoint position threshold to quit the closing procedure."
		VALUE
		0x80058c90
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_clos_thd_out 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_ctl_0
		"Parameter corresponding to the T0 coefficient of the RST Controller."
		VALUE
		0x80058d8a
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_ctl_0 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_ctl_1
		"Parameter corresponding to the T1 coefficient of the RST Controller."
		VALUE
		0x80058d88
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_ctl_1 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_ctl_2
		"Parameter corresponding to the T2 coefficient of the RST Controller."
		VALUE
		0x80058d86
		RSA_RecordLayout_VALUE_UWORD
		29.9995422363281
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		0.
		29.9995422363281
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_ctl_2 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_open_thd_in
		"Setpoint position threshold to initiate the opening procedure."
		VALUE
		0x80058c8e
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_open_thd_in 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_open_thd_out
		"Setpoint position threshold to quit the opening procedure."
		VALUE
		0x80058c8c
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_open_thd_out 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_sp_stab_thd
		"Range of setpoint variation under which the setpoint can be considered as stable."
		VALUE
		0x80058d84
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_sp_stab_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_stab_thd
		"Threshold value to consider the stability of sensor 2 position during the learning or reading cycle."
		VALUE
		0x80057cf6
		RSA_RecordLayout_VALUE_UWORD
		100
		wmkbkad_wwidqld_lsCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_stab_thd 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_stab_thd_1
		"Threshold value to consider the stability of sensor 1 position during the learning or reading cycle."
		VALUE
		0x80058d82
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_stab_thd_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_thd_1
		"Second position threshold to keep the dead zone filter active."
		VALUE
		0x80058d80
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_psn_thd_1 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_v_lim_down
		"Minimum value of the signal voltage before detecting a SRC failure."
		VALUE
		0x80057cf4
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_it_psn_v_lim_down 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_psn_v_lim_up
		"Maximum value of the signal voltage before detecting a SRC failure."
		VALUE
		0x80057cf2
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_it_psn_v_lim_up 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_pwm_clos
		"Calibrated value of the inlet throttle full closing"
		VALUE
		0x80058c8a
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_pwm_clos 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_pwm_open
		"Calibrated value of the inlet throttle full opening"
		VALUE
		0x80058c88
		RSA_RecordLayout_VALUE_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_it_pwm_open 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_reg_fail_mod
		"Failure mode associated with a blocked component during regulation."
		VALUE
		0x80058c28
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_it_reg_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_reg_h_thd
		"Maximal value for the position error of the IT regulation"
		VALUE
		0x80058c26
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_it_reg_h_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_reg_l_thd
		"Minimal value for the position error of the IT regulation"
		VALUE
		0x80058c24
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_it_reg_l_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_sat_val_neg_slop
		"Negative slope value for the switching throttle saturation value from one combustion mode to another"
		VALUE
		0x800628be
		RSA_RecordLayout_VALUE_UWORD
		32766.5
		ffvohed_uoEmjkd_dCoeDrc_f___20a
		-32767.
		-0.5
    DISPLAY_IDENTIFIER Cxx_it_sat_val_neg_slop 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_sat_val_pos_slop
		"Positive slope value for the switching throttle saturation value from one combustion mode to another"
		VALUE
		0x800628bc
		RSA_RecordLayout_VALUE_UWORD
		32766.5
		Aooymna_oCAdEfc_aACyxka_f_A_2oa
		0.5
		32767.
    DISPLAY_IDENTIFIER Cxx_it_sat_val_pos_slop 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_sens_fail_mod
		"Failure mode associated with a sensor failure"
		VALUE
		0x80058c22
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_it_sens_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_sens_pws
		"Theoretical sensor power supply value"
		VALUE
		0x80057cf0
		RSA_RecordLayout_VALUE_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		0.
		25000.
    DISPLAY_IDENTIFIER Cxx_it_sens_pws 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_sp_neg_slo
		"Negative value of the slope used to switch from open loop control to closed loop control of IT"
		VALUE
		0x80063b68
		RSA_RecordLayout_VALUE_ULONG
		65535
		uAwArwa_iohEDEc_mwmdljb_BDA0a70
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_it_sp_neg_slo 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_sp_pos_slo
		"Positive value of the slope used to switch from open loop control to closed loop control of IT"
		VALUE
		0x80063b64
		RSA_RecordLayout_VALUE_ULONG
		65535
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_it_sp_pos_slo 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_stab_dly
		"Time value to declare the position stable (used during Offset Learning)."
		VALUE
		0x80057cee
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_it_stab_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_stab_dly_1
		"Time period of the first position stability control before activating the Dead Zone Filter."
		VALUE
		0x80058d7e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_it_stab_dly_1 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_t_frst_ofs_act
		"Time duration of the first offset sequence."
		VALUE
		0x80058c86
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_it_t_frst_ofs_act 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_t_pwl_act
		"Time duration of the cleaning sequence."
		VALUE
		0x80058c84
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_it_t_pwl_act 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_turnon_dly_clos
		"Time delay of the full closing operation"
		VALUE
		0x80058c82
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_it_turnon_dly_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_turnon_dly_open
		"Time delay of the full opening operation"
		VALUE
		0x80058c80
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_it_turnon_dly_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_lim_down_1
		"Minimum command voltage during regulation mode, if no current limitation."
		VALUE
		0x80058c7e
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_it_v_lim_down_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_lim_down_2
		"Minimum command voltage during regulation mode, if current limitation."
		VALUE
		0x80058c7c
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_it_v_lim_down_2 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_lim_up_1
		"Maximum command voltage during regulation mode, if no current limitation."
		VALUE
		0x80058c7a
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_v_lim_up_1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_lim_up_2
		"Maximum command voltage during regulation mode, if current limitation."
		VALUE
		0x80058c78
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_v_lim_up_2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_neg_thd
		"Negative command voltage threshold used for the current limitation strategy."
		VALUE
		0x80058c20
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_it_v_neg_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_ofs_lim_down
		"Maximum negative voltage command during the closing of the component."
		VALUE
		0x80058c76
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_it_v_ofs_lim_down 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_ofs_lim_up
		"Maximum positive voltage during the opening of the component."
		VALUE
		0x80058c74
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_v_ofs_lim_up 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_pos_thd
		"Positive command voltage threshold used for the current limitation strategy."
		VALUE
		0x80058c1e
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_v_pos_thd 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_sp_clos_1
		"Negative voltage in open loop control to maintain the component closed."
		VALUE
		0x80058c72
		RSA_RecordLayout_VALUE_SWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		-30.
		30.
    DISPLAY_IDENTIFIER Cxx_it_v_sp_clos_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_v_sp_open_1
		"Positive voltage to maintain the component open."
		VALUE
		0x80058c70
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_v_sp_open_1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_vb_fail_mod
		"Failure mode associated with a battery voltage on the component."
		VALUE
		0x80058c1c
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_it_vb_fail_mod 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_vb_lim_down_1
		"First threshold of the hysteresis on the battery voltage to indicate a pws problem."
		VALUE
		0x80058c1a
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_vb_lim_down_1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_vb_lim_down_2
		"Second threshold of the hysteresis on the battery voltage to indicate a power problem."
		VALUE
		0x80058c18
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_vb_lim_down_2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_vb_lim_up_1
		"First threshold of the hysteresis on the battery voltage to indicate a too high voltage."
		VALUE
		0x80058c16
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_vb_lim_up_1 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_vb_lim_up_2
		"Second threshold of the hysteresis on the battery voltage to indicate a too high voltage."
		VALUE
		0x80058c14
		RSA_RecordLayout_VALUE_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		0.
		60.
    DISPLAY_IDENTIFIER Cxx_it_vb_lim_up_2 
    FORMAT "%5.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_it_vb_nok_dly
		"Time value to declare the battery voltage not OK."
		VALUE
		0x80058c12
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_it_vb_nok_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_k_ftc_dyn_is_sp
		"Filter factor for dynamic setpoint of ISR"
		VALUE
		0x8005ae10
		RSA_RecordLayout_VALUE_UWORD
		655.35
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_k_ftc_dyn_is_sp 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_kd_decl_cut_n_ac_ofs
		"Deceleration injection cut engine offset, if a powertrain torque setpoint is requested and the air conditioning compressor is clutched."
		VALUE
		0x80043308
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_kd_decl_cut_n_ac_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_kd_decl_cut_n_ofs
		"deceleration injection cut engine offset, if a powertrain torque setpoint is requested"
		VALUE
		0x80043306
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_kd_decl_cut_n_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_l_blk_is_alt_pow
		"Low theshold on filtered alternator mechanical power to authorize the detection of an engine speed hook"
		VALUE
		0x8005aa60
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_l_blk_is_alt_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_l_gear_max
		"Gear ratio to searate low gears engaged from high gears engaged"
		VALUE
		0x8006b24e
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_l_gear_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_l_gear_win_thd
		"Window size calibration for detection of new gear engaged (low gears)"
		VALUE
		0x8006b24c
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_l_gear_win_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_l_prs_ac_dsb_hys
		"Low pressure hysteresis of the AC compressor inhibition threshold"
		VALUE
		0x8005cee1
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_l_prs_ac_dsb_hys 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_l_prs_ac_dsb_thd
		"Minimum AC pressure before compressor inhibition"
		VALUE
		0x8005cee0
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_l_prs_ac_dsb_thd 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_l_thd_tra_acel_ok
		"Low threshold of Abs_gt_avg to validate the information of the transverse acceleration"
		VALUE
		0x80058abc
		RSA_RecordLayout_VALUE_UWORD
		13.5
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		0.
		13.5
    DISPLAY_IDENTIFIER Cxx_l_thd_tra_acel_ok 
    FORMAT "%7.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_law_sel_cfm
		"Cxx_law_sel_cfm"
		VALUE
		0x8005976c
		RSA_RecordLayout_VALUE_UBYTE
		5
		VA_F_1_p0_12
		0
		5
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_lacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_lg_acel_fil
		"Time constant of the aceleration calcul filter"
		VALUE
		0x8006b350
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_lg_acel_fil 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_lg_acel_law_fil
		"Cxx_lg_acel_law_fil"
		VALUE
		0x80059365
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_lih_dly
		"Sufficient time to confirm limphome mode in automatic gearbox"
		VALUE
		0x8005915a
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_lih_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_load_inf
		"Min load value during air mass flow sensor drift diagnosis"
		VALUE
		0x800573ee
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_load_inf 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_load_sup
		"Max load value during air mass flow sensor drift diagnosis"
		VALUE
		0x800573ec
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_load_sup 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_dyn_1_mdl_ftc
		"Filtering time constant for air mass flow across the inlet throttle valve"
		VALUE
		0x800573d0
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_maf_dyn_1_mdl_ftc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_dyn_fail_swi_neg_slop
		"Calibration for negative slope of dynamic mass air flow failure mode switch"
		VALUE
		0x800573ea
		RSA_RecordLayout_VALUE_UWORD
		250000
		gkqcqfd_fDxenaa_ypqitmb_BsD_020
		-250000.
		0.
    DISPLAY_IDENTIFIER Cxx_maf_dyn_fail_swi_neg_slop 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_dyn_fail_swi_pos_slop
		"Calibration for positive slope of dynamic mass air flow failure mode switch"
		VALUE
		0x800573e8
		RSA_RecordLayout_VALUE_UWORD
		250000
		rmrnjea_mqkhdia_FFkBoda_Bpp__20
		0.
		250000.
    DISPLAY_IDENTIFIER Cxx_maf_dyn_fail_swi_pos_slop 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_dyn_ftc
		"Calibration for dynamic mass air flow filtered constant"
		VALUE
		0x800573ce
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_maf_dyn_ftc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_ftc_mon
		"Filtering time calibration for the air mass flow"
		VALUE
		0x80043b58
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_maf_ftc_mon 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_h_thd_mon
		"high air mass flow threshold for monitoring"
		VALUE
		0x80043b56
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_h_thd_mon 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_ini
		"Initialization of the I part of the PI regulator"
		VALUE
		0x80063bee
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_ini 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_neg_fac
		"Gain value in the negative part of the window of the maf I regulator"
		VALUE
		0x80063bec
		RSA_RecordLayout_VALUE_UWORD
		5
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_neg_fac 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_neg_fac_air_reg
		"Gain value in the negative part of the window of the maf I regulator in thr_air_reg mode"
		VALUE
		0x80063bea
		RSA_RecordLayout_VALUE_UWORD
		5
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_neg_fac_air_reg 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_pos_fac
		"Gain value in the positive part of the window of the maf I regulator"
		VALUE
		0x80063be8
		RSA_RecordLayout_VALUE_UWORD
		5
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_pos_fac 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_pos_fac_air_reg
		"Gain value in the positive part of the window of the maf i regulator in thr_air_reg mode"
		VALUE
		0x80063be6
		RSA_RecordLayout_VALUE_UWORD
		5
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_pos_fac_air_reg 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_win_fac
		"Gain value in the window of the maf I regulator"
		VALUE
		0x80063be4
		RSA_RecordLayout_VALUE_UWORD
		5
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_win_fac 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_win_fac_air_reg
		"Gain value in the window of the maf i regulator in thr_air_reg mode"
		VALUE
		0x80063be2
		RSA_RecordLayout_VALUE_UWORD
		5
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_win_fac_air_reg 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_win_neg
		"Definition of the negative part of the window for the maf I regulator"
		VALUE
		0x80063be0
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_win_neg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_win_neg_air_reg
		"Definition of the negative part of the window for the maf I regulator in thr_air_reg mode"
		VALUE
		0x80063bde
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_win_neg_air_reg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_win_pos
		"Definition of the positive part of the window for the maf I regulator"
		VALUE
		0x80063bdc
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_win_pos 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_i_reg_win_pos_air_reg
		"Definition of the positive part of the window for the maf P regulator in thr_air_reg mode"
		VALUE
		0x80063bda
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_i_reg_win_pos_air_reg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_l_thd_mon
		"low air mass flow threshold for monitoring"
		VALUE
		0x80043b54
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_l_thd_mon 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_lim_min
		"Minimal value of the limitation of maf sp"
		VALUE
		0x80063fb4
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_lim_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_neg_fac
		"Gain value in the negative part of the window of the maf P regulator"
		VALUE
		0x80063bd8
		RSA_RecordLayout_VALUE_UWORD
		5
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_neg_fac 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_neg_fac_air_reg
		"Gain value in the negative part of the window of the maf P regulator in thr_air_reg mode"
		VALUE
		0x80063bd6
		RSA_RecordLayout_VALUE_UWORD
		5
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_neg_fac_air_reg 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_pos_fac
		"Gain value in the positive part of the window of the maf p regulator"
		VALUE
		0x80063bd4
		RSA_RecordLayout_VALUE_UWORD
		5
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_pos_fac 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_pos_fac_air_reg
		"Gain value in the positive part of the window of the maf p regulator in thr_air_reg mode"
		VALUE
		0x80063bd2
		RSA_RecordLayout_VALUE_UWORD
		5
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_pos_fac_air_reg 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_win_fac
		"Gain value in the window of the maf p regulator"
		VALUE
		0x80063bd0
		RSA_RecordLayout_VALUE_UWORD
		5
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_win_fac 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_win_fac_air_reg
		"Gain value in the window of the maf p regulator in thr_air_reg mode"
		VALUE
		0x80063bce
		RSA_RecordLayout_VALUE_UWORD
		5
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		0.
		5.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_win_fac_air_reg 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_win_neg
		"Definition of the negative part of the window for the maf P regulator"
		VALUE
		0x80063bcc
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_win_neg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_win_neg_air_reg
		"Definition of the negative part of the window for the maf P regulator in thr_air_reg mode"
		VALUE
		0x80063bca
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_win_neg_air_reg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_win_pos
		"Definition of the positive part of the window for the maf I regulator"
		VALUE
		0x80063bc8
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_win_pos 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_p_reg_win_pos_air_reg
		"Definition of the positive part of the window for the maf I regulator in thr_air_reg mode"
		VALUE
		0x80063bc6
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_maf_p_reg_win_pos_air_reg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_reg_fac_cor_min
		"Minimum value for the corrective factor of the maf regulator gains"
		VALUE
		0x80063bc4
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_maf_reg_fac_cor_min 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_bas_slop_neg_pp
		"Negative slope for the slop switch between two different maf setpoints in pp mode"
		VALUE
		0x800641fc
		RSA_RecordLayout_VALUE_UWORD
		175000
		mpFohEb_Frujlnd_kyyCsbc_BssA020
		-175000.
		0.
    DISPLAY_IDENTIFIER Cxx_maf_sp_bas_slop_neg_pp 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_bas_slop_neg_rij
		"Negative slope for the slop switch between two different maf setpoints in rij mode."
		VALUE
		0x80066686
		RSA_RecordLayout_VALUE_UWORD
		175000
		mpFohEb_Frujlnd_kyyCsbc_BssA020
		-175000.
		0.
    DISPLAY_IDENTIFIER Cxx_maf_sp_bas_slop_neg_rij 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_bas_slop_pos_pp
		"Positive slope for the slop switch between two different maf setpoints in pp mode"
		VALUE
		0x800641fa
		RSA_RecordLayout_VALUE_UWORD
		175000
		rmrnjea_mqkhdia_FFkBoda_Bpp__20
		0.
		175000.
    DISPLAY_IDENTIFIER Cxx_maf_sp_bas_slop_pos_pp 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_bas_slop_pos_rij
		"Positive slope for the slop switch between two different maf setpoints in rij mode"
		VALUE
		0x80066684
		RSA_RecordLayout_VALUE_UWORD
		175000
		phvmFbd_piFuvyc_ADhtvrd_BsDA020
		0.
		175000.
    DISPLAY_IDENTIFIER Cxx_maf_sp_bas_slop_pos_rij 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_slop_neg
		"Negative slope for the slop switch between two different combustion modes"
		VALUE
		0x80063fb2
		RSA_RecordLayout_VALUE_UWORD
		250000
		gkqcqfd_fDxenaa_ypqitmb_BsD_020
		-250000.
		0.
    DISPLAY_IDENTIFIER Cxx_maf_sp_slop_neg 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_slop_neg_npu
		"Negative slope for the maf setpoint slop switch for the npu mode"
		VALUE
		0x80063fb0
		RSA_RecordLayout_VALUE_UWORD
		250000
		gkqcqfd_fDxenaa_ypqitmb_BsD_020
		-250000.
		0.
    DISPLAY_IDENTIFIER Cxx_maf_sp_slop_neg_npu 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_slop_pos
		"Positive slope for the slop switch between two different combustion modes"
		VALUE
		0x80063fae
		RSA_RecordLayout_VALUE_UWORD
		250000
		rmrnjea_mqkhdia_FFkBoda_Bpp__20
		0.
		250000.
    DISPLAY_IDENTIFIER Cxx_maf_sp_slop_pos 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_sp_slop_pos_npu
		"Positive slope for the maf setpoint slop switch for the npu mode"
		VALUE
		0x80063fac
		RSA_RecordLayout_VALUE_UWORD
		250000
		rmrnjea_mqkhdia_FFkBoda_Bpp__20
		0.
		250000.
    DISPLAY_IDENTIFIER Cxx_maf_sp_slop_pos_npu 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_maf_utp_dft
		"Maximum CSF upstream temp set point in case of maf dyn default"
		VALUE
		0x800458fc
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_maf_utp_dft 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_map_fil_max_tqi_ftc
		"Filter timer constant of the manifold pressure for the maximum torque calculation"
		VALUE
		0x8005b4e8
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_map_fil_max_tqi_ftc 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_map_ftc
		"Calibration for filtering time constant of manifold pressure"
		VALUE
		0x800576be
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_map_ftc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_amp_max
		"Maximum atmospheric pressure to allow learning"
		VALUE
		0x800577a6
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_mapc_amp_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_amp_min
		"Minimum atmospheric pressure to allow learning"
		VALUE
		0x800577a4
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_mapc_amp_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_dif_max
		"Maximum correction for the manifold pressure"
		VALUE
		0x800577a3
		RSA_RecordLayout_VALUE_SBYTE
		200
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_mapc_dif_max 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_dif_min
		"Minimum correction for the manifold pressure"
		VALUE
		0x800577a2
		RSA_RecordLayout_VALUE_SBYTE
		200
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_mapc_dif_min 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_dly_avg
		"Duration for mean value calculation"
		VALUE
		0x800577a0
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_mapc_dly_avg 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_ftc_amp
		"Filter time constant for the atmospheric pressure"
		VALUE
		0x8005779e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_mapc_ftc_amp 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_ftc_map
		"Filter time_constant for the manifold air pressure"
		VALUE
		0x8005779c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_mapc_ftc_map 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_it_psn_min_apc
		"Minimum value of throttle position to allow diagnosis during APC"
		VALUE
		0x8005779a
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_mapc_it_psn_min_apc 
    FORMAT "%8.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_it_psn_min_isr
		"Minimum value of throttle position to allow diagnosis during ISR"
		VALUE
		0x80057798
		RSA_RecordLayout_VALUE_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_mapc_it_psn_min_isr 
    FORMAT "%8.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_n_max
		"Maximum engine speed to allow nok diagnostic during ISR"
		VALUE
		0x80057796
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_mapc_n_max 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_plau_diag_apc
		"Maximum value for difference between manifold pressure and atmospheric pressure during APC"
		VALUE
		0x80057794
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_mapc_plau_diag_apc 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_plau_diag_isr
		"Maximum value for difference between manifold pressure and atmospheric pressure during ISR"
		VALUE
		0x80057792
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_mapc_plau_diag_isr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_tco_max
		"Low coolant temperature over which the learning process is not allowed"
		VALUE
		0x80057790
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mapc_tco_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_tco_min
		"Low coolant temperature under which the learning process is not allowed"
		VALUE
		0x8005778e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mapc_tco_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_tia_max
		"High ambient temperature over which the learning process is not allowed"
		VALUE
		0x8005778c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mapc_tia_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_tia_min
		"Low ambient temperature under which the learning process is not allowed"
		VALUE
		0x8005778a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mapc_tia_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mapc_tqi_max
		"Maximum torque setpoint to allow nok diagnostic during ISR"
		VALUE
		0x80057788
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_mapc_tqi_max 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_decl
		"Cxx_max_decl"
		VALUE
		0x80059360
		RSA_RecordLayout_VALUE_SLONG
		25.5
		VA_F_0v0004_p0_15
		-12
		13.5
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_dspl_arw_cyc_nr
		"Cxx_max_dspl_arw_cyc_nr"
		VALUE
		0x800592eb
		RSA_RecordLayout_VALUE_UBYTE
		32
		VA_I_16
		0
		32
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_dspl_arw_down_dly
		"Cxx_max_dspl_arw_down_dly"
		VALUE
		0x800592fa
		RSA_RecordLayout_VALUE_UWORD
		1310.7
		VA_F_0v02_p0_4
		0
		1310.7
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_dspl_arw_up_dly
		"Cxx_max_dspl_arw_up_dly"
		VALUE
		0x800592f8
		RSA_RecordLayout_VALUE_UWORD
		1310.7
		VA_F_0v02_p0_4
		0
		1310.7
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_gear_cge_dly
		"Maximum time allowed for a gear shift"
		VALUE
		0x8005876c
		RSA_RecordLayout_VALUE_UBYTE
		255
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_max_gear_cge_dly 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_dec_slop
		"Negatif slope for the engine speed limitation"
		VALUE
		0x8005af50
		RSA_RecordLayout_VALUE_UWORD
		65535
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_max_n_dec_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_fl_tkof
		"Engine speed limitation during the take off (idiot start)"
		VALUE
		0x8005af4e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_max_n_fl_tkof 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_fl_tkof_ext_ctrl_dly
		"Delay to consolidate the external controls"
		VALUE
		0x8005af4c
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_max_n_fl_tkof_ext_ctrl_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_fl_tkof_vs_thd
		"Vehicle speed threshold to activate the take off engine speed limitation (idiot start)"
		VALUE
		0x8005af4a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_max_n_fl_tkof_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_gear_dft
		"Maximum engine speed for gearbox default"
		VALUE
		0x8005af48
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_max_n_gear_dft 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_inc_slop
		"Positive slope for the engine speed limitation"
		VALUE
		0x8005af46
		RSA_RecordLayout_VALUE_UWORD
		65535
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_max_n_inc_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_ovn_ofs
		"Engine speed offset on maximum engine speed"
		VALUE
		0x8005af44
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_max_n_ovn_ofs 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_tco_toil_dft
		"maximum engine speed depending on coolant temperature (default value)"
		VALUE
		0x8005af42
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_max_n_tco_toil_dft 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_n_thd_oil_ovn
		"Maximum engine speed in start operation"
		VALUE
		0x8005af40
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_max_n_thd_oil_ovn 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_pow
		"Max power for accelerator pedal limp home powertrain setpoint"
		VALUE
		0x80059d08
		RSA_RecordLayout_VALUE_UBYTE
		500000
		drbdAab_snynrtd_cpBhbcd_W__500a
		0.
		500000.
    DISPLAY_IDENTIFIER Cxx_max_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_pow_fs
		"Cxx_max_pow_fs"
		VALUE
		0x80059212
		RSA_RecordLayout_VALUE_UWORD
		655350
		VA_F_10_p0_17
		0
		655350
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_statlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_pow_gear
		"maximum power for power limitation."
		VALUE
		0x800431b2
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_max_pow_gear 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_max_prot_spg_tqe_slop
		"value of positive and negative gradient in case of torque limitation for supercharger"
		VALUE
		0x8005b948
		RSA_RecordLayout_VALUE_UWORD
		102398.4375
		uECeoAd_nhBifyd_rgxnmhd_NsA_o0a
		0.
		102398.4375
    DISPLAY_IDENTIFIER Cxx_max_prot_spg_tqe_slop 
    FORMAT "%11.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nramsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_rams_n_1
		"Failsafe maximum engine speed level 1"
		VALUE
		0x8005afc8
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_max_rams_n_1 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nramsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_rams_n_2
		"Failsafe maximum engine speed level 2"
		VALUE
		0x8005afc6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_max_rams_n_2 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_rams_tqe_1_slop
		"Slope to attend the safety torque limitation level 1 (low)"
		VALUE
		0x800431bc
		RSA_RecordLayout_VALUE_UWORD
		102398.4375
		uECeoAd_nhBifyd_rgxnmhd_NsA_o0a
		0.
		102398.4375
    DISPLAY_IDENTIFIER Cxx_max_rams_tqe_1_slop 
    FORMAT "%11.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_rams_tqe_2_slop
		"Slope to attend the safety torque limitation level 2 (mean)"
		VALUE
		0x800431ba
		RSA_RecordLayout_VALUE_UWORD
		102398.4375
		uECeoAd_nhBifyd_rgxnmhd_NsA_o0a
		0.
		102398.4375
    DISPLAY_IDENTIFIER Cxx_max_rams_tqe_2_slop 
    FORMAT "%11.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_rams_tqe_3_slop
		"Slope to attend the safety torque limitation level 3 (strong)"
		VALUE
		0x800431b8
		RSA_RecordLayout_VALUE_UWORD
		102398.4375
		uECeoAd_nhBifyd_rgxnmhd_NsA_o0a
		0.
		102398.4375
    DISPLAY_IDENTIFIER Cxx_max_rams_tqe_3_slop 
    FORMAT "%11.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_rams_tqe_3_srs
		"Safety limited torque level 3 (strong) if vehicle speed not valid"
		VALUE
		0x800431b6
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_max_rams_tqe_3_srs 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_rams_tqe_sta_slop
		"Slope to attend the safety torque limitation level 1.2.3 during engine state isn't autonomous"
		VALUE
		0x800431b4
		RSA_RecordLayout_VALUE_UWORD
		102398.4375
		uECeoAd_nhBifyd_rgxnmhd_NsA_o0a
		0.
		102398.4375
    DISPLAY_IDENTIFIER Cxx_max_rams_tqe_sta_slop 
    FORMAT "%11.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_max_vs_n_rat
		"Maximal Vspeed/Neng speed ratio before declaring that Rat Gear is Not Identified."
		VALUE
		0x8006b24a
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_max_vs_n_rat 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_cmd_ena_thd_tco_h
		"Water temperature offset used to activate mdf1 on high temp mode."
		VALUE
		0x8006b0b0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf1_cmd_ena_thd_tco_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_meca_pow
		"Power consumed by cooling fan moving in first speed"
		VALUE
		0x8006b342
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_mdf1_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_off_tco_thd
		"Water temperature threshold used to desactivate mdf1 (engine stop)."
		VALUE
		0x8006b0ae
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf1_off_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_off_tco_thd_h
		"Water temperature offset used to deactivate mdf1 on high temp. mode (engine stop)."
		VALUE
		0x8006b0ac
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf1_off_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_on_tco_thd
		"Water temperature threshold used to activate mdf1 (engine stop)."
		VALUE
		0x8006b0aa
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf1_on_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_on_tco_thd_h
		"Water temperature offset used to activate mdf1 on high temp mode (engine stop)."
		VALUE
		0x8006b0a8
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf1_on_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_on_tco_thd_hys
		"Water temperature threshold used to maintain the power supply request (engine stop)."
		VALUE
		0x8006b0a6
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf1_on_tco_thd_hys 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf1_on_tco_thd_hys_h
		"Water temperature offset used to maintain the power supply request on high temp mode (engine stop)."
		VALUE
		0x8006b0a4
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf1_on_tco_thd_hys_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf2_meca_pow
		"Power consumed by cooling fan moving in second speed"
		VALUE
		0x8006b340
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_mdf2_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf2_off_tco_thd
		"Water temperature offset on Cxx_mdf_1_cmd_ena_thd_tco used to deactivate mdf2 (engine running)."
		VALUE
		0x8006b0a2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf2_off_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
