    DISPLAY_IDENTIFIER Sbx_mfo_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a3b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a39 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a3f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[6].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[7].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006a9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ad0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ad2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ad4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ad6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ad8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ada 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006adc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ade 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ae0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ae2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ae4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ae6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ae8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ab2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ab6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ab4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ab8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006abc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006abe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ac2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ac0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ac4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ac8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ac6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ace 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006acc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ab0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006aa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[8].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006af8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b4f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b4d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b53 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006afc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[9].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ac_prs_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006b9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_1.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_secu_2.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ba8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006baa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_tot.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v1_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bbf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_acel_pdl_v2_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bcb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_actr_rly_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bdd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_seq_ctr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_data_tout.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_agb_no_frm.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_amp_reg_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_cmp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_bgin_clu_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_brk_pdl_cmp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cata_nok_cge.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bf8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_clu_cnt_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007051 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000704e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007050 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007050 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007050 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007050 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cmp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007050 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_cyc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_no_sig.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007058 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007052 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007057 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007054 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007056 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007056 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007056 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007056 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_crk_shp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007056 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_cmp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_swi_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e29 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_sl_tot.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_vs_cmp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e35 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oc_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e41 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_cru_whl_cmd_oor.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006bfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_doc1_utp_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_itl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_err_no_norm.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007064 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007069 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007066 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007068 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007068 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007068 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007068 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_bus_mcut.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007068 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_cpt_blk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000709e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_inj_no_norm.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_1.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000706e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007070 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007075 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007072 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007074 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007074 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007074 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007074 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ecm_mon_secu_2.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007074 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_inj_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e47 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e53 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_efi_sldv_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007136 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007138 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_blk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_egr_byp_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_flow_meca.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_el.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c31 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_hbdg_ovh.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_ofs_no_norm.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c49 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ac_prs_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007170 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007170 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007170 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007170 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007172 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007172 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007172 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_1.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007172 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007174 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007174 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007174 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_secu_2.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007174 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007176 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007176 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007176 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_tot.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007176 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007178 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007178 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007178 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007178 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v1_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_acel_pdl_v2_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000717e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007180 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007180 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007180 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_actr_rly_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007180 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007182 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007182 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007182 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_actr_rly_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007182 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007184 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007184 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007184 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_actr_rly_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_actr_rly_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007184 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007186 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007186 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007186 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007186 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007188 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007188 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007188 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_seq_ctr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007188 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_data_tout.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_agb_no_frm.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007322 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007322 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007322 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_amp_reg_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007322 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007240 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007240 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007240 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_bgin_clu_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007240 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007242 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007242 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007242 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_bgin_clu_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
