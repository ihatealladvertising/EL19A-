/begin CHARACTERISTIC
		Cxx_mdf2_off_tco_thd_h
		"Water temperature offset used to deactivate mdf2 on high temp mode (engine running)."
		VALUE
		0x8006b0a0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf2_off_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf2_on_tco_thd
		"Water temperature offset on Cxx_mdf_1_cmd_ena_thd_tco used to activate mdf2 (engine running)."
		VALUE
		0x8006b09e
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf2_on_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf2_on_tco_thd_h
		"Water temperature offset used to activate mdf2 on high Temp. mode (engine running)."
		VALUE
		0x8006b09c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf2_on_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf_1_cmd_ena_thd_tco
		"Water temperature threshold used to activate mdf1 (engine running)"
		VALUE
		0x8006b09a
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdf_1_cmd_ena_thd_tco 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf_min_dly
		"Minimum duration of fan1 or fan2 activation"
		VALUE
		0x800590d6
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_mdf_min_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdf_on_dly
		"Turn on delay of fan1 or fan2 activation"
		VALUE
		0x800590d4
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_mdf_on_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mdl_ex_prs_ofs
		"Before turbine pressure model offset"
		VALUE
		0x80057d9c
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_mdl_ex_prs_ofs 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdl_tco_inc
		"Engine coolant temperature model increment"
		VALUE
		0x80058436
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdl_tco_inc 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdl_tco_max
		"Max engine coolant temperature model"
		VALUE
		0x80058434
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdl_tco_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mdl_toil_fail
		"Default value in case of mtl toil failure"
		VALUE
		0x80058504
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mdl_toil_fail 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_med_dec_slop
		"Value for the medium decrease slope"
		VALUE
		0x80041402
		RSA_RecordLayout_VALUE_UWORD
		65535
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_med_dec_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_med_inc_slop
		"Value for the medium increase slope"
		VALUE
		0x80041400
		RSA_RecordLayout_VALUE_UWORD
		65535
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_med_inc_slop 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_dspl_arw_down_dly
		"Cxx_min_dspl_arw_down_dly"
		VALUE
		0x800592f3
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_dspl_arw_up_dly
		"Cxx_min_dspl_arw_up_dly"
		VALUE
		0x800592ea
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_ftc_dyn_is_sp
		"Minimal limitation allowing to saturate the constant of time"
		VALUE
		0x8005ae0e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_min_ftc_dyn_is_sp 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_is_i_ofs
		"Offset about minimum torque value of idle speed regulator integral correction to detect a engine speed hook"
		VALUE
		0x8005aa5e
		RSA_RecordLayout_VALUE_SWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cxx_min_is_i_ofs 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_is_n
		"engine speed threshold"
		VALUE
		0x8005afe6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_l_eng_tqe_tqe_hys
		"Hysteresis to detect the saturation of minimum torque by the low engine torque"
		VALUE
		0x8005afe4
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_min_l_eng_tqe_tqe_hys 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_n_thd_min_tq
		"Minimum engine speed threshold for the smoothing between the low engine minimum effective torque and the hyperbolic minimun torque"
		VALUE
		0x8005afe2
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_min_n_thd_min_tq 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_n_tq_grd
		"Torque gradient to set to the minimum torque on the engine torque losses"
		VALUE
		0x8005afe0
		RSA_RecordLayout_VALUE_UWORD
		7.9998779296875
		xdBqnAa_fmFFrja_Dkxfxyb_Np__1a0
		0.
		7.9998779296875
    DISPLAY_IDENTIFIER Cxx_min_n_tq_grd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_n_tq_grd_sta
		"Torque gradient to set to the minimum torque on the engine torque losses in the starting mode"
		VALUE
		0x8005afde
		RSA_RecordLayout_VALUE_UWORD
		7.9998779296875
		xdBqnAa_fmFFrja_Dkxfxyb_Np__1a0
		0.
		7.9998779296875
    DISPLAY_IDENTIFIER Cxx_min_n_tq_grd_sta 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_tq_ast_dsb_dly
		"Maximum delay to disable the minimun torque after the starting mode."
		VALUE
		0x8005afdc
		RSA_RecordLayout_VALUE_UBYTE
		25.4
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.4
    DISPLAY_IDENTIFIER Cxx_min_tq_ast_dsb_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_tqe_dsb
		"a_in_pci_esp_absctxx / Torque value to be sent to torque arbitration when there isn't any request for a minimum torque"
		VALUE
		0x8005886e
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_min_tqe_dsb 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_min_tqi_sot_esti
		"Maximum value of injected fuel quantity for soot mass estimation"
		VALUE
		0x80046654
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_min_tqi_sot_esti 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_min_vs_n_rat
		"Minimal Vspeed/Neng speed ratio before declaring that Rat Gear is Neutral."
		VALUE
		0x8006b248
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_min_vs_n_rat 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mnl_driv_spt_fac
		"Manually forced value of driver sportivity factor (when option bit activated)"
		VALUE
		0x8005917c
		RSA_RecordLayout_VALUE_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_mnl_driv_spt_fac 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mon_stop_tco_thd
		"Water Temperature threshold used to stop the power supply request."
		VALUE
		0x8006b098
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mon_stop_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mon_stop_tco_thd_h
		"Water Temperature threshold used to stop the power supply request on high temperature mode."
		VALUE
		0x8006b096
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_mon_stop_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_01_max
		"Maximum value authorized for the replacement value of the identifier 01"
		VALUE
		0x80056e12
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_moni_id_01_max 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_01_min
		"Minimum value authorized for the replacement value of the identifier 01"
		VALUE
		0x80056e10
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_moni_id_01_min 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_03_max
		"Maximum value authorized for the replacement value of the identifier 03"
		VALUE
		0x80056e0f
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_03_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_03_min
		"Minimum value authorized for the replacement value of the identifier 03"
		VALUE
		0x80056e0e
		RSA_RecordLayout_VALUE_UBYTE
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_03_min 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_06_max
		"Maximum value authorized for the replacement value of the identifier 06"
		VALUE
		0x80056e0c
		RSA_RecordLayout_VALUE_UWORD
		1
		rkcmmwd_dnCngmd_ycnokbb_B__000a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_06_max 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_06_min
		"Minimum value authorized for the replacement value of the identifier 06"
		VALUE
		0x80056e0a
		RSA_RecordLayout_VALUE_UWORD
		1
		rkcmmwd_dnCngmd_ycnokbb_B__000a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_06_min 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_0a_max
		"Maximum value authorized for the replacement value of the identifier 0a"
		VALUE
		0x80056e09
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_0a_max 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_0a_min
		"Minimum value authorized for the replacement value of the identifier 0a"
		VALUE
		0x80056e08
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_0a_min 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_10_max
		"Maximum value authorized for the replacement value of the identifier 10"
		VALUE
		0x80056e06
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_moni_id_10_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_10_min
		"Minimum value authorized for the replacement value of the identifier 10"
		VALUE
		0x80056e04
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_moni_id_10_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_11_max
		"Maximum value authorized for the replacement value of the identifier 11"
		VALUE
		0x80056e02
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_11_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_11_min
		"Minimum value authorized for the replacement value of the identifier 11"
		VALUE
		0x80056e00
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_11_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_13_max
		"Maximum value authorized for the replacement value of the identifier 13"
		VALUE
		0x80056dfe
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_13_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_13_min
		"Minimum value authorized for the replacement value of the identifier 13"
		VALUE
		0x80056dfc
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_13_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_14_max
		"Maximum value authorized for the replacement value of the identifier 14"
		VALUE
		0x80056dfa
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_14_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_14_min
		"Minimum value authorized for the replacement value of the identifier 14"
		VALUE
		0x80056df8
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_14_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_18_max
		"Maximum value authorized for the replacement value of the identifier 18"
		VALUE
		0x80056df6
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_18_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_18_min
		"Minimum value authorized for the replacement value of the identifier 18"
		VALUE
		0x80056df4
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_18_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1a_max
		"Maximum value authorized for the replacement value of the identifier 1a"
		VALUE
		0x80056df2
		RSA_RecordLayout_VALUE_SWORD
		200
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_1a_max 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1a_min
		"Minimum value authorized for the replacement value of the identifier 1a"
		VALUE
		0x80056df0
		RSA_RecordLayout_VALUE_SWORD
		200
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_1a_min 
    FORMAT "%12.8" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1b_max
		"Maximum value authorized for the replacement value of the identifier 1b"
		VALUE
		0x80056dee
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_1b_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1b_min
		"Minimum value authorized for the replacement value of the identifier 1b"
		VALUE
		0x80056dec
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_1b_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1d_max
		"Maximum value authorized for the replacement value of the identifier 1d"
		VALUE
		0x80056dea
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_moni_id_1d_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1d_min
		"Minimum value authorized for the replacement value of the identifier 1d"
		VALUE
		0x80056de8
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_moni_id_1d_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1e_max
		"Maximum value authorized for the replacement value of the identifier 1e"
		VALUE
		0x80056de6
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_1e_max 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1e_min
		"Minimum value authorized for the replacement value of the identifier 1e"
		VALUE
		0x80056de4
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_1e_min 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1f_max
		"Maximum value authorized for the replacement value of the identifier 1f"
		VALUE
		0x80056de2
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_moni_id_1f_max 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_1f_min
		"Minimum value authorized for the replacement value of the identifier 1f"
		VALUE
		0x80056de0
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_moni_id_1f_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_20_max
		"Maximum value authorized for the replacement value of the identifier 20"
		VALUE
		0x80056ddf
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_moni_id_20_max 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_20_min
		"Minimum value authorized for the replacement value of the identifier 20"
		VALUE
		0x80056dde
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_moni_id_20_min 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_21_max
		"Maximum value authorized for the replacement value of the identifier 21"
		VALUE
		0x80056ddc
		RSA_RecordLayout_VALUE_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cxx_moni_id_21_max 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_21_min
		"Minimum value authorized for the replacement value of the identifier 21"
		VALUE
		0x80056dda
		RSA_RecordLayout_VALUE_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cxx_moni_id_21_min 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_29_max
		"Maximum value authorized for the replacement value of the identifier 29"
		VALUE
		0x80056dd8
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_29_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_29_min
		"Minimum value authorized for the replacement value of the identifier 29"
		VALUE
		0x80056dd6
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_moni_id_29_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_30_max
		"Maximum value authorized for the replacement value of the identifier 30"
		VALUE
		0x80056dd4
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_30_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_30_min
		"Minimum value authorized for the replacement value of the identifier 30"
		VALUE
		0x80056dd2
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_30_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_31_max
		"Maximum value authorized for the replacement value of the identifier 31"
		VALUE
		0x80056dd0
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_31_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_31_min
		"Minimum value authorized for the replacement value of the identifier 31"
		VALUE
		0x80056dce
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_31_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_32_max
		"Maximum value authorized for the replacement value of the identifier 32"
		VALUE
		0x80056dcc
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_32_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_32_min
		"Minimum value authorized for the replacement value of the identifier 32"
		VALUE
		0x80056dca
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_32_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_33_max
		"Maximum value authorized for the replacement value of the identifier 33"
		VALUE
		0x80056dc8
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_33_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_33_min
		"Minimum value authorized for the replacement value of the identifier 33"
		VALUE
		0x80056dc6
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_33_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_34_max
		"Maximum value authorized for the replacement value of the identifier 34"
		VALUE
		0x80056dc4
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_34_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_34_min
		"Minimum value authorized for the replacement value of the identifier 34"
		VALUE
		0x80056dc2
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_34_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_35_max
		"Maximum value authorized for the replacement value of the identifier 35"
		VALUE
		0x80056dc0
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_35_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_35_min
		"Minimum value authorized for the replacement value of the identifier 35"
		VALUE
		0x80056dbe
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_35_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_36_max
		"Maximum value authorized for the replacement value of the identifier 36"
		VALUE
		0x80056dbc
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_36_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_36_min
		"Minimum value authorized for the replacement value of the identifier 36"
		VALUE
		0x80056dba
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_moni_id_36_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_37_max
		"Maximum value authorized for the replacement value of the identifier 37"
		VALUE
		0x80056db8
		RSA_RecordLayout_VALUE_SWORD
		65535
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_moni_id_37_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_37_min
		"Minimum value authorized for the replacement value of the identifier 37"
		VALUE
		0x80056db6
		RSA_RecordLayout_VALUE_SWORD
		65535
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_moni_id_37_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_38_max
		"Maximum value authorized for the replacement value of the identifier 38"
		VALUE
		0x80056db4
		RSA_RecordLayout_VALUE_SWORD
		65535
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_moni_id_38_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_38_min
		"Minimum value authorized for the replacement value of the identifier 38"
		VALUE
		0x80056db2
		RSA_RecordLayout_VALUE_SWORD
		65535
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_moni_id_38_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_39_max
		"Maximum value authorized for the replacement value of the identifier 39"
		VALUE
		0x80056db0
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_moni_id_39_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_39_min
		"Minimum value authorized for the replacement value of the identifier 39"
		VALUE
		0x80056dae
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_moni_id_39_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3a_max
		"Maximum value authorized for the replacement value of the identifier 3a"
		VALUE
		0x80056dac
		RSA_RecordLayout_VALUE_SWORD
		65535
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_moni_id_3a_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3a_min
		"Minimum value authorized for the replacement value of the identifier 3a"
		VALUE
		0x80056daa
		RSA_RecordLayout_VALUE_SWORD
		65535
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_moni_id_3a_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3b_max
		"Maximum value authorized for the replacement value of the identifier 3b"
		VALUE
		0x80056da8
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_moni_id_3b_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3b_min
		"Minimum value authorized for the replacement value of the identifier 3b"
		VALUE
		0x80056da6
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_moni_id_3b_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3c_max
		"Maximum value authorized for the replacement value of the identifier 3c"
		VALUE
		0x80056da4
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_moni_id_3c_max 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3c_min
		"Minimum value authorized for the replacement value of the identifier 3c"
		VALUE
		0x80056da2
		RSA_RecordLayout_VALUE_SWORD
		720
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		-360.
		360.
    DISPLAY_IDENTIFIER Cxx_moni_id_3c_min 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3d_max
		"Maximum value authorized for the replacement value of the identifier 3d"
		VALUE
		0x80056da0
		RSA_RecordLayout_VALUE_UWORD
		655.35
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_moni_id_3d_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_3d_min
		"Minimum value authorized for the replacement value of the identifier 3d"
		VALUE
		0x80056d9e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_moni_id_3d_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_3e_max
		"Maximum value authorized for the replacement value of the identifier 3e"
		VALUE
		0x80056d9d
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_3e_max 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_3e_min
		"Minimum value authorized for the replacement value of the identifier 3e"
		VALUE
		0x80056d9c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_3e_min 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_3f_max
		"Maximum value authorized for the replacement value of the identifier 3f"
		VALUE
		0x80056d9b
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_moni_id_3f_max 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_3f_min
		"Minimum value authorized for the replacement value of the identifier 3f"
		VALUE
		0x80056d9a
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Cxx_moni_id_3f_min 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_40_max
		"Maximum value authorized for the replacement value of the identifier 40"
		VALUE
		0x80056d99
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_moni_id_40_max 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_id_40_min
		"Minimum value authorized for the replacement value of the identifier 40"
		VALUE
		0x80056d98
		RSA_RecordLayout_VALUE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_moni_id_40_min 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_46_max
		"Maximum value authorized for the replacement value of the identifier 46"
		VALUE
		0x80056d97
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_46_max 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_46_min
		"Minimum value authorized for the replacement value of the identifier 46"
		VALUE
		0x80056d96
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_46_min 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_47_max
		"Maximum value authorized for the replacement value of the identifier 47"
		VALUE
		0x80056d95
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_47_max 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Cxx_moni_id_47_min
		"Minimum value authorized for the replacement value of the identifier 47"
		VALUE
		0x80056d94
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_moni_id_47_min 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_is_n_sp_max
		"Maximum idle speed setpoint authorized in case of monitool request"
		VALUE
		0x800413fe
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_moni_is_n_sp_max 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_moni_stop_diag_dly
		"Delay between Monitool deactivation and diagnosis reactivation"
		VALUE
		0x80056e1a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_moni_stop_diag_dly 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ms_fac_dist_1
		"100% of estimated soot mass and fac of distance (hot conditions)"
		VALUE
		0x80046d9d
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ms_fac_dist_1 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ms_fac_dist_2
		"a_at_pft_mng_chgtend/100% of estimated soot mass and fac of distance (cold conditions)"
		VALUE
		0x80046d9c
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ms_fac_dist_2 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ms_fac_dist_4
		"100% of soot mass and fac of distance (medium thermal rgn conditions)"
		VALUE
		0x80046d9b
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ms_fac_dist_4 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ms_ref_aftr_rgn_dist_dly
		"After regeneration distance delay for soot mass reference"
		VALUE
		0x80046cd0
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_ms_ref_aftr_rgn_dist_dly 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_mute_abst_frm_dly
		"Mute (transmission failure) detection time-out"
		VALUE
		0x80055bc8
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_mute_abst_frm_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_mute_ecu_conf
		"Mute (transmission failure detection) feature for Mux configuration detection (always present or opt"
		VALUE
		0x80055bc7
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_mute_ecu_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_mute_vld_abst_frm_dec
		"Mute : decrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bc6
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_mute_vld_abst_frm_dec 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_mute_vld_abst_frm_inc
		"Mute : incrementation value for validated absent CAN failure counter."
		VALUE
		0x80055bc5
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_mute_vld_abst_frm_inc 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mux_agb_tqe_nok_raw
		"Raw CAN invalid value for AGB torque"
		VALUE
		0x8005876a
		RSA_RecordLayout_VALUE_UWORD
		4095
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		4095.
    DISPLAY_IDENTIFIER Cxx_mux_agb_tqe_nok_raw 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mux_alt_pwm_fil_t
		"Multiplexed alternator load filter time constant"
		VALUE
		0x80058a8e
		RSA_RecordLayout_VALUE_UWORD
		65535
		etFmowc_wzFizua_ewnyxka_mC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_mux_alt_pwm_fil_t 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mux_asr_msr_tqe_nok_raw
		"Unscaled (raw) invalid value of ASR and MSR torque requests"
		VALUE
		0x8005886c
		RSA_RecordLayout_VALUE_UWORD
		4095
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		4095.
    DISPLAY_IDENTIFIER Cxx_mux_asr_msr_tqe_nok_raw 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_mux_diag_ena_dly
		"delay counter for data reception during initialization phase"
		VALUE
		0x80055bc4
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_mux_diag_ena_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cxx_mux_frm_set_ref
		"Mux messaging set reference"
		VALUE
		0x80055bc2
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_mux_frm_set_ref 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mux_test_mil_dly
		"Delay before readiness status check"
		VALUE
		0x8005912b
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_mux_test_mil_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mux_test_rdn_mil_dly
		"MIL flashing delay when readiness are not completed"
		VALUE
		0x8005912a
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_mux_test_rdn_mil_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_mv_dly
		"particulate filter upstream temperature mean value delay"
		VALUE
		0x80040114
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_mv_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mv_vb_fac
		"Filter factor applied to raw battery voltage"
		VALUE
		0x80058a9c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_mv_vb_fac 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mv_vs_dec_fil
		"Cxx_mv_vs_dec_fil"
		VALUE
		0x8005976b
		RSA_RecordLayout_VALUE_UBYTE
		255
		VA_F_1_p0_18
		0
		255
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_mv_vs_inc_fil
		"Cxx_mv_vs_inc_fil"
		VALUE
		0x8005976a
		RSA_RecordLayout_VALUE_UBYTE
		255
		VA_F_1_p0_18
		0
		255
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_ac_clu_dsb_thd
		"Engine speed limit to authorize AC compressor clutching"
		VALUE
		0x8005cede
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_ac_clu_dsb_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_ac_dsb_hys
		"Engine speed hysteresis of the AC compressor inhibition threshold"
		VALUE
		0x8005cedc
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_ac_dsb_hys 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_ac_dsb_thd
		"Maximum engine speed before AC compressor inhibition"
		VALUE
		0x8005ceda
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_ac_dsb_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_avg_h_thd_decl_pp
		"Engine speed  threshold for the definition of the overrun in pp mode"
		VALUE
		0x800614a6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_avg_h_thd_decl_pp 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_avg_h_thd_decl_pr
		"Engine speed  threshold for the definition of the overrun in pr mode"
		VALUE
		0x800614a4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_avg_h_thd_decl_pr 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_avg_h_thd_decl_rij
		"Higher engine speed threshold for the definition of deceleration in rij mode"
		VALUE
		0x800614a2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_avg_h_thd_decl_rij 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_avg_it_sat_sp_ena
		"a_as_maf_ctl_itolcri/Threshold value of the engine speed for the thr_sat setpoint computation"
		VALUE
		0x8006352c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_avg_it_sat_sp_ena 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_avg_maf_sp_ena
		"Threshold value of the engine speed for the maf setpoint computation"
		VALUE
		0x80066682
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_avg_maf_sp_ena 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_drv_ast
		"Calibration of comparison of the derivate of engine speed for the access Ast - > Cdn"
		VALUE
		0x8005aa72
		RSA_RecordLayout_VALUE_SWORD
		16383
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		-8192.
		8191.
    DISPLAY_IDENTIFIER Cxx_n_drv_ast 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_derivxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_drv_fil_fac
		"first order filter factor for engine speed derivate"
		VALUE
		0x80058914
		RSA_RecordLayout_VALUE_UWORD
		1
		mmvArna_CeqzsCd_pqnbneb_n__630a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_n_drv_fil_fac 
    FORMAT "%11.9" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_drv_out
		"Calibration of comparison of the derivate of engine speed for the access Out or Tkof - > Cdn"
		VALUE
		0x8005aa70
		RSA_RecordLayout_VALUE_SWORD
		16383
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		-8192.
		8191.
    DISPLAY_IDENTIFIER Cxx_n_drv_out 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_ftc_mon
		"Filtering time calibration for the engine speed"
		VALUE
		0x80043b52
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_n_ftc_mon 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_h_thd_mon
		"high engine speed threshold for monitoring"
		VALUE
		0x80043b50
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_h_thd_mon 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_l_thd_mon
		"low engine speed threshold for monitoring"
		VALUE
		0x80043b4e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_l_thd_mon 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_lim_apmp_down_shf_hys
		"Engine speed hysteresis"
		VALUE
		0x80059210
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		VA_F_0v25_p0_3
		0
		16383.75
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_lim_crk_cfm
		"Activation of engine speed limitation by crankshaft back-up mode (0: no limitation, 1: limitation level 1, 2: limitation level 2)"
		VALUE
		0x8005af2e
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_n_lim_crk_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_max_mon
		"Maximal threshold for the engine speed for monitoring"
		VALUE
		0x80043b4c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_max_mon 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_min_mon
		"Minimal engine speed for monitoring"
		VALUE
		0x80043b4a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_min_mon 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_mv_inf
		"Min value of engine cycle speed during air mass flow sensor drift diagnosis"
		VALUE
		0x800573e6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_mv_inf 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_n_mv_sup
		"Max value of engine cycle speed during air mass flow sensor drift diagnosis"
		VALUE
		0x800573e4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_mv_sup 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_run_thd
		"Cxx_n_run_thd"
		VALUE
		0x80059760
		RSA_RecordLayout_VALUE_UWORD
		65535
		VA_F_1_p0_19
		0
		65535
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_sp_dec
		"Idle speed setpoint decrementation"
		VALUE
		0x800413fc
		RSA_RecordLayout_VALUE_UWORD
		65535
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_n_sp_dec 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_step
		"Maximum tuning idle speed setpoint offset authorized"
		VALUE
		0x8005ae64
		RSA_RecordLayout_VALUE_SWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Cxx_n_step 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_n_vld_min_is_n
		"Default value if a default is detected on the engine speed sensor"
		VALUE
		0x8005adea
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_n_vld_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_neg_reg_clos_req
		"a_as_maf_ctl_eitcaes_xxx_xx_d_a/Negative slope value in case of regular closing request"
		VALUE
		0x800621a0
		RSA_RecordLayout_VALUE_ULONG
		65535
		pbxrrcb_uxwdEfd_uEzojfd_Bs__n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_neg_reg_clos_req 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_neg_slo_clos_req
		"a_as_maf_ctl_eitcaes_xxx_xx_d_a/Negative slope value in case of slow closing request"
		VALUE
		0x8006219c
		RSA_RecordLayout_VALUE_ULONG
		65535
		pbxrrcb_uxwdEfd_uEzojfd_Bs__n0a
		-65535.
		0.
    DISPLAY_IDENTIFIER Cxx_neg_slo_clos_req 
    FORMAT "%8.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_neut_gear_rat_tgt
		"Neutral gear ratio target"
		VALUE
		0x8006b246
		RSA_RecordLayout_VALUE_UWORD
		200
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_neut_gear_rat_tgt 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_no_driv_pwt_sp_hys
		"Hysteresis for no powertrain setpoint requested"
		VALUE
		0x80040248
		RSA_RecordLayout_VALUE_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_no_driv_pwt_sp_hys 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_no_driv_pwt_sp_thd
		"Threshold for no powertrain setpoint resquested"
		VALUE
		0x80040246
		RSA_RecordLayout_VALUE_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_no_driv_pwt_sp_thd 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_no_virt_driv_pwt_sp_hys
		"Hysteresis for no powertrain setpoint requested by virtual driver"
		VALUE
		0x80040244
		RSA_RecordLayout_VALUE_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_no_virt_driv_pwt_sp_hys 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_no_virt_driv_pwt_sp_thd
		"Threshold for no powertrain setpoint resquested by virtual driver"
		VALUE
		0x80040242
		RSA_RecordLayout_VALUE_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_no_virt_driv_pwt_sp_thd 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr1
		"Approval number 1"
		VALUE
		0x80056d7f
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr10
		"Approval number 10"
		VALUE
		0x80056d7e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr10 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr2
		"Approval number 2"
		VALUE
		0x80056d7d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr3
		"Approval number 3"
		VALUE
		0x80056d7c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr4
		"Approval number 4"
		VALUE
		0x80056d7b
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr4 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr5
		"Approval number 5"
		VALUE
		0x80056d7a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr5 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr6
		"Approval number 6"
		VALUE
		0x80056d79
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr6 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr7
		"Approval number 7"
		VALUE
		0x80056d78
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr7 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr8
		"Approval number 8"
		VALUE
		0x80056d77
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr8 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_cert_nr9
		"Approval number 9"
		VALUE
		0x80056d76
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_cert_nr9 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_conf_diag_prmt
		""
		VALUE
		0x80056d75
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_conf_diag_prmt 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_conf_diag_schd
		""
		VALUE
		0x80056d74
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_conf_diag_schd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_conf_lamb
		""
		VALUE
		0x80056d73
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_conf_lamb 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_conf_obd
		"OBD requirements to which the vehicle is designed"
		VALUE
		0x80056d72
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_conf_obd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_dc_egr_byp_blk
		"EGR bypass blocked consecutive confirmed latched failures to store an OBD failure"
		VALUE
		0x80043abe
		RSA_RecordLayout_VALUE_UBYTE
		9
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_egr_byp_blk 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_dc_off
		"Number of consecutive driving cycles without failure to switch off the MI"
		VALUE
		0x80055c25
		RSA_RecordLayout_VALUE_UBYTE
		9
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_off 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_obd_wup_thd
		"Number of consecutive warm-up cycles without failure to restore an OBD memorised failure"
		VALUE
		0x80055c24
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_obd_wup_thd 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ad_dly_bfr_resu
		"Turn off delay allowed to loose offset learning conditions"
		VALUE
		0x80043b86
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ocd_ad_dly_bfr_resu 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_dlp_dly
		"Post injection duration"
		VALUE
		0x80043b7c
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ocd_dlp_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_dly_bfr_ena
		"Duration the engine speed and torque must be in steady state before OBD DOC test is enabled"
		VALUE
		0x80043bb8
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ocd_dly_bfr_ena 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_dly_bfr_resu
		"Turn off delay allowed to loose enable conditions during the steady state detection"
		VALUE
		0x80043b85
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ocd_dly_bfr_resu 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_dtp_max
		"Maximum post catalyst exhaust gas temperature permissable for the start of the OBD DOC monitor test"
		VALUE
		0x80043c06
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_ena_dtp_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_dtp_min
		"Minimum post catalyst exhaust gas temperature permissable for the start of the OBD DOC monitor test"
		VALUE
		0x80043c04
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_ena_dtp_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_n_h_thd_1
		"Upper limit on engine speed for the maximum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043c02
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ena_n_h_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_n_h_thd_2
		"Upper limit on engine speed for the minimum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043c00
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ena_n_h_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_n_l_thd_1
		"Lower limit on engine speed for the maximum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043bfe
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ena_n_l_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_n_l_thd_2
		"Lower limit on engine speed for the minimum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043bfc
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ena_n_l_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_tqi_h_thd_1
		"Upper limit on torque for the maximum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043bfa
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ena_tqi_h_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_tqi_h_thd_2
		"Upper limit on torque for the minimum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043bf8
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ena_tqi_h_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_tqi_l_thd_1
		"Lower limit on torque for the maximum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043bf6
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ena_tqi_l_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_tqi_l_thd_2
		"Lower limit on torque for the minimum threshold of the hysteresis in diagnosis enabled conditions"
		VALUE
		0x80043bf4
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ena_tqi_l_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_utp_max
		"Maximum pre catalyst exhaust gas temperature permissable for the start of the OBD DOC monitor test"
		VALUE
		0x80043bf2
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_ena_utp_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ena_utp_min
		"Minimum pre catalyst exhaust gas temperature permissable for the start of the OBD DOC monitor test"
		VALUE
		0x80043bf0
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_ena_utp_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_gear_min
		"Minimum gear engaged to perform the diagnostic"
		VALUE
		0x80043b84
		RSA_RecordLayout_VALUE_UBYTE
		7
		RB_CONV_AtCatDgn_Gear
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_ocd_gear_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_idle_n_thd
		"Engine speed threshold for long idle detection"
		VALUE
		0x80043bee
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_idle_n_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_idle_t_thd
		"Duration threshold for long idle detection"
		VALUE
		0x80043bec
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_Time_1s
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_ocd_idle_t_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_n_dev_max
		"Engine speed threshold for the detection of steady state conditions"
		VALUE
		0x80043bea
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_n_dev_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_n_h_thd_1
		"Upper limit on engine speed for the maximum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043be8
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_n_h_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_n_h_thd_2
		"Upper limit on engine speed for the minimum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043be6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_n_h_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_n_l_thd_1
		"Lower limit on engine speed for the maximum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043be4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_n_l_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_n_l_thd_2
		"Lower limit on engine speed for the minimum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043be2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_n_l_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_t
		"Time constant for first order filter in use in error stability check block"
		VALUE
		0x80043b80
		RSA_RecordLayout_VALUE_UBYTE
		255
		RB_CONV_AtCatDgn_Time_1s
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_t_h_thd
		"High threshold for estimated temperature stability"
		VALUE
		0x80043bc6
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_t_h_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_t_l_thd
		"Low threshold for estimated temperature stability"
		VALUE
		0x80043bc8
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_t_l_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_tco_max
		"Maximum value of engine coolant temperature to enable offset learning operation"
		VALUE
		0x80043bc2
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_AtCatDgn_DegC
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_tco_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_tco_min
		"Minimum value of engine coolant temperature to enable offset learning operation"
		VALUE
		0x80043bc4
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_AtCatDgn_DegC
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_tco_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_tqi_h_thd_1
		"Upper limit on torque for the maximum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043be0
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_tqi_h_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_tqi_h_thd_2
		"Upper limit on torque for the minimum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043bde
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_tqi_h_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_tqi_l_thd_1
		"Lower limit on torque for the maximum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043bdc
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_tqi_l_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_ofs_ad_tqi_l_thd_2
		"Lower limit on torque for the minimum threshold of the hysteresis in offset learning conditions"
		VALUE
		0x80043bda
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_ofs_ad_tqi_l_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_t_comb_mod_ok
		"Time the automate wait for combustion mode 8 before returning in waiting state"
		VALUE
		0x80043b83
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ocd_t_comb_mod_ok 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_t_h_thd
		"High threshold for estimated temperature error"
		VALUE
		0x80043bbe
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_t_h_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_t_l_thd
		"Low  threshold for estimated temperature error"
		VALUE
		0x80043bc0
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_t_l_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_tco_max
		"Maximum value of engine coolant temperature for the OBD DOC monitor to enable"
		VALUE
		0x80043bd8
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_AtCatDgn_DegC
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ocd_tco_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_tco_min
		"Minimum value of engine coolant temperature for the OBD DOC monitor to enable"
		VALUE
		0x80043bd6
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_AtCatDgn_DegC
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ocd_tco_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_dly
		"Duration of the DOC OBD monitor test"
		VALUE
		0x80043bbc
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ocd_test_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_dly_bfr_resu
		"Turn off delay allowed to loose test conditions during the criterion calculation"
		VALUE
		0x80043b82
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_ocd_test_dly_bfr_resu 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_egaf_max
		"Maximum permitted value for the exhaust gas air flow during the OBD test"
		VALUE
		0x80043bd4
		RSA_RecordLayout_VALUE_UWORD
		0.65535
		RB_CONV_AtCatDgn_Kg_s_00001
		0.
		0.65535
    DISPLAY_IDENTIFIER Cxx_ocd_test_egaf_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_egaf_min
		"Minimum permitted value for the exhaust gas air flow during the OBD test"
		VALUE
		0x80043bd2
		RSA_RecordLayout_VALUE_UWORD
		0.65535
		RB_CONV_AtCatDgn_Kg_s_00001
		0.
		0.65535
    DISPLAY_IDENTIFIER Cxx_ocd_test_egaf_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_max_thd
		"Discrimination maximum threshold value for the diagnosis criterion"
		VALUE
		0x80043b9c
		RSA_RecordLayout_VALUE_SWORD
		65535
		RB_CONV_AtCatDgn_OneToOne_wu
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_ocd_test_max_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_min_thd
		"Discrimination minimum threshold value for the diagnosis criterion"
		VALUE
		0x80043b9e
		RSA_RecordLayout_VALUE_SWORD
		65535
		RB_CONV_AtCatDgn_OneToOne_wu
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_ocd_test_min_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_utp_max
		"Maximum permitted value for the pre catalyst exhaust gas temperature during the OBD test"
		VALUE
		0x80043bd0
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_test_utp_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_test_utp_min
		"Minimum permitted value for the pre catalyst exhaust gas temperature during the OBD test"
		VALUE
		0x80043bce
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_AtCatDgn_DegC
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_ocd_test_utp_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_tia_min
		"Minimum ambient air temperature for the OBD DOC monitor to enable"
		VALUE
		0x80043bcc
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_AtCatDgn_DegC
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_ocd_tia_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_tpst_esti_dly
		"Time constant of the filter used for the delay calculation"
		VALUE
		0x80043b81
		RSA_RecordLayout_VALUE_UBYTE
		255
		RB_CONV_AtCatDgn_Time_1s
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_ocd_tpst_esti_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_tqi_dev_max
		"Torque threshold for the detection of steady state conditions"
		VALUE
		0x80043bca
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_ocd_tqi_dev_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_vh_dist_ena_min_h_thd
		"High threshold for minimum vehicule distance to run between two diagnostics"
		VALUE
		0x80043ba2
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_km_1
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_ocd_vh_dist_ena_min_h_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ocd_vh_dist_ena_min_l_thd
		"Low threshold for minimum vehicule distance to run between two diagnostics"
		VALUE
		0x80043ba0
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_AtCatDgn_km_1
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_ocd_vh_dist_ena_min_l_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_oem_id
		"Car manufacturer identification code"
		VALUE
		0x80056f74
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_oem_id 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ofs_ad_dly
		"Duration of the offset learning"
		VALUE
		0x80043bba
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_ofs_ad_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_ofs_ad_gear_min
		"Minimum gear engaged to enable the offset learning operation"
		VALUE
		0x80043b7f
		RSA_RecordLayout_VALUE_UBYTE
		7
		RB_CONV_AtCatDgn_Gear
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_ofs_ad_gear_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_ash_prct
		"oil metal ash percent"
		VALUE
		0x8005806c
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_oil_ash_prct 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_chg_dil_max_mnl_ini
		"Maximum dilution table calibration for manual initialisation"
		VALUE
		0x80055296
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_chg_dil_max_mnl_ini 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_chg_ini
		"Oil dilution intial value after the oil change"
		VALUE
		0x80055294
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_chg_ini 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_chg_mnl_ini
		"Dilution value calibration for manual initialisation"
		VALUE
		0x80055292
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_chg_mnl_ini 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_csm_oil_dil_clc
		"Mean value of oil consumption for oil dilution update to oil total volume"
		VALUE
		0x80055290
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		RB_CONV_Lper1000Km
		0
		2.55
    DISPLAY_IDENTIFIER Cxx_oil_csm_oil_dil_clc 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_csm_vh_dist
		"Maximum vehicle distance for reseting the oil consumption when particule filter is new"
		VALUE
		0x80058442
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_oil_csm_vh_dist 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_dil_min_max_clc
		"Min oil dilution cost for maximum dilution update"
		VALUE
		0x8005528e
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_dil_min_max_clc 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_dil_rij_fac
		"Factor for oil dilution speed unit conversion"
		VALUE
		0x8005528c
		RSA_RecordLayout_VALUE_UWORD
		6553500
		RB_CONV_100_SecPerHr
		0
		6553500
    DISPLAY_IDENTIFIER Cxx_oil_dil_rij_fac 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_dist_min_oil_dil_ovs
		"Min oil distance since last oil change before the next oil change light on"
		VALUE
		0x8005528a
		RSA_RecordLayout_VALUE_UWORD
		60000
		RB_CONV_Distance_1km
		0
		60000
    DISPLAY_IDENTIFIER Cxx_oil_dist_min_oil_dil_ovs 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_rat_max_1
		"Oil dilution maximum threshold to start regeneration"
		VALUE
		0x80055288
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_rat_max_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_rat_max_2
		"Oil dilution maximum threshold to continue regeneration"
		VALUE
		0x80055286
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_rat_max_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_rij_chg_ini
		"Normal mode dilution value calibration for manual initialisation"
		VALUE
		0x80055284
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_rij_chg_ini 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_rij_mnl_chg_ini
		"Normal mode dilution value calibration for initialisation"
		VALUE
		0x80055282
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_oil_rij_mnl_chg_ini 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_oil_vol
		"Oil volume in the engine"
		VALUE
		0x80055280
		RSA_RecordLayout_VALUE_UWORD
		15
		RB_CONV_Liter
		0
		15
    DISPLAY_IDENTIFIER Cxx_oil_vol 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ovn_n_clu_det_dly
		"Maximum time delay to detects the engine speed overshoot on an accelerator pedal release (driver tip-out)"
		VALUE
		0x8005885a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ovn_n_clu_det_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ovn_n_clu_det_thd
		"Engine speed threshold autorization strategy calculation"
		VALUE
		0x80058858
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ovn_n_clu_det_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ovn_n_dif_clu_det_thd
		"Engine speed overshoot threshold"
		VALUE
		0x80058856
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ovn_n_dif_clu_det_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ovn_tq_prop_t_fil
		"Filter timer constant for engine speed in the loop proportional"
		VALUE
		0x8005aefa
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_ovn_tq_prop_t_fil 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_avl
		"Calibration to send on can when the function is  off"
		VALUE
		0x800590fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_avl 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_ctr4
		"Counter 4 threshold calibration"
		VALUE
		0x8006b228
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_owe_ctr4 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_ctr5
		"Counter 5 threshold calibration"
		VALUE
		0x8006b226
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_owe_ctr5 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_drn_dist_max_prg
		"Calibration to forbid an OCS event after an ECU reprogrammation"
		VALUE
		0x80059116
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_drn_dist_max_prg 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_drn_req_dly
		"Calibration of the duration to maintain the drain request signal."
		VALUE
		0x80059118
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0
		6553.5
    DISPLAY_IDENTIFIER Cxx_owe_drn_req_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_eng_aut_dly
		"Delay time before the first value of the engine oil temperature"
		VALUE
		0x8006b0ec
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0
		6553.5
    DISPLAY_IDENTIFIER Cxx_owe_eng_aut_dly 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_frst_km_dil_thd
		"Kilometers threshold to learn the first point"
		VALUE
		0x80059128
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_frst_km_dil_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km1
		"Kilometer threshold to learn the first point"
		VALUE
		0x80059108
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km2
		"Kilometer threshold to learn the second point (first time)"
		VALUE
		0x80059106
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km3
		"Potential kilometers before switching to  one by one  kilometer decrement"
		VALUE
		0x80059104
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km3 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km4
		"Potential kilometer to convergne to the  one by one  decrement in the end of potential"
		VALUE
		0x80059102
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km4 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km4_dil
		"Potential kilometer to convergne to the  one by one  decrement in the end of potential"
		VALUE
		0x80059126
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km4_dil 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km5
		"Potential kilometer when the remainnig km is converged to the  one by one"
		VALUE
		0x80059100
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km5 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km5_dil
		"Potential kilometer when the remainnig km is converged to the  one by one"
		VALUE
		0x80059124
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km5_dil 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km7
		"Saturation of the potential kilometer"
		VALUE
		0x800590f8
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km7 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_dil_intv
		"Between the two points learning interval"
		VALUE
		0x80059122
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km_dil_intv 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_oxi_dil_intrp
		"Between oxidation and dilution kilometers smoothing interval"
		VALUE
		0x80059120
		RSA_RecordLayout_VALUE_UWORD
		65534
		RB_CONV_Distance_1km
		1
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km_oxi_dil_intrp 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_pot_1
		"Potential kilometer on initialisation for zone 1"
		VALUE
		0x8006b0d6
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km_pot_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_pot_2
		"Potential kilometer on initialisation for zone 2"
		VALUE
		0x8006b0d4
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km_pot_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_pot_3
		"Potential kilometer on initialisation for zone 3"
		VALUE
		0x8006b0d2
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km_pot_3 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_pot_4
		"Potential kilometer on initialisation for zone 4"
		VALUE
		0x8006b0d0
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_km_pot_4 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_slop_max
		"Maximal slope of the potential km sended to the customer"
		VALUE
		0x800590fe
		RSA_RecordLayout_VALUE_UWORD
		196.605
		RB_CONV_003_Fac
		0
		196.605
    DISPLAY_IDENTIFIER Cxx_owe_km_slop_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_slop_max_dil
		"Maximal slope of the dilution potential km sended to the customer"
		VALUE
		0x8005911e
		RSA_RecordLayout_VALUE_UWORD
		196.605
		RB_CONV_003_Fac
		0
		196.605
    DISPLAY_IDENTIFIER Cxx_owe_km_slop_max_dil 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_slop_min
		"Minimal slope of the potential km sended to the customer"
		VALUE
		0x800590fc
		RSA_RecordLayout_VALUE_UWORD
		196.605
		RB_CONV_003_Fac
		0
		196.605
    DISPLAY_IDENTIFIER Cxx_owe_km_slop_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_km_slop_min_dil
		"Minimal slope of the dilution potential km sended to the customer"
		VALUE
		0x8005911c
		RSA_RecordLayout_VALUE_UWORD
		196.605
		RB_CONV_003_Fac
		0
		196.605
    DISPLAY_IDENTIFIER Cxx_owe_km_slop_min_dil 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_max_drn_km_1
		"Calibration to activate the drain request if the travelled distance is to big on zone 1"
		VALUE
		0x8006b0ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_max_drn_km_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_max_drn_km_2
		"Calibration to activate the drain request if the travelled distance is to big on zone 2"
		VALUE
		0x8006b0cc
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_max_drn_km_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_max_drn_km_3
		"Calibration to activate the drain request if the travelled distance is to big on zone 3"
		VALUE
		0x8006b0ca
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_max_drn_km_3 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_max_drn_km_4
		"Calibration to activate the drain request if the travelled distance is to big on zone 4"
		VALUE
		0x8006b0c8
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_max_drn_km_4 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_min_drn_km_1
		"Calibration to forbid the drain request if the travelled distance is to small on zone 1"
		VALUE
		0x8006b0c6
		RSA_RecordLayout_VALUE_UWORD
		20000
		RB_CONV_Distance_1km
		0
		20000
    DISPLAY_IDENTIFIER Cxx_owe_min_drn_km_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_min_drn_km_2
		"Calibration to forbid the drain request if the travelled distance is to small on zone 2"
		VALUE
		0x8006b0c4
		RSA_RecordLayout_VALUE_UWORD
		20000
		RB_CONV_Distance_1km
		0
		20000
    DISPLAY_IDENTIFIER Cxx_owe_min_drn_km_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_min_drn_km_3
		"Calibration to forbid the drain request if the travelled distance is to small on zone 3"
		VALUE
		0x8006b0c2
		RSA_RecordLayout_VALUE_UWORD
		20000
		RB_CONV_Distance_1km
		0
		20000
    DISPLAY_IDENTIFIER Cxx_owe_min_drn_km_3 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_min_drn_km_4
		"Calibration to forbid the drain request if the travelled distance is to small on zone 4"
		VALUE
		0x8006b0c0
		RSA_RecordLayout_VALUE_UWORD
		20000
		RB_CONV_Distance_1km
		0
		20000
    DISPLAY_IDENTIFIER Cxx_owe_min_drn_km_4 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_n
		"Engine speed threshold to go out of the manual reset strategy condition"
		VALUE
		0x8006b224
		RSA_RecordLayout_VALUE_UWORD
		6000
		ryhzxDd_bDsnzFa_Ehryxwb_r_A_1oa
		0.
		6000.
    DISPLAY_IDENTIFIER Cxx_owe_n 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_n_mnl_asd_1
		"Maximal number of engine revolutions on zone 1"
		VALUE
		0x8006b0e4
		RSA_RecordLayout_VALUE_ULONG
		300000000
		RB_CONV_1Trs
		0
		300000000
    DISPLAY_IDENTIFIER Cxx_owe_n_mnl_asd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_n_mnl_asd_2
		"Maximal number of engine revolutions on zone 2"
		VALUE
		0x8006b0e0
		RSA_RecordLayout_VALUE_ULONG
		300000000
		RB_CONV_1Trs
		0
		300000000
    DISPLAY_IDENTIFIER Cxx_owe_n_mnl_asd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_n_mnl_asd_3
		"Maximal number of engine revolutions on zone 3"
		VALUE
		0x8006b0dc
		RSA_RecordLayout_VALUE_ULONG
		300000000
		RB_CONV_1Trs
		0
		300000000
    DISPLAY_IDENTIFIER Cxx_owe_n_mnl_asd_3 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_n_mnl_asd_4
		"Maximal number of engine revolutions on zone 4"
		VALUE
		0x8006b0d8
		RSA_RecordLayout_VALUE_ULONG
		300000000
		RB_CONV_1Trs
		0
		300000000
    DISPLAY_IDENTIFIER Cxx_owe_n_mnl_asd_4 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_oil_dil_max_km
		"Maximal traveled kilometers to allow  oil dilution alert"
		VALUE
		0x800590f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_oil_dil_max_km 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_oil_dil_min_km
		"Minimal traveled kilometers to allow  oil dilution alert"
		VALUE
		0x800590f4
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Distance_1km
		0
		65535
    DISPLAY_IDENTIFIER Cxx_owe_oil_dil_min_km 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_oil_dil_thd
		"Maximal oil dilution rate"
		VALUE
		0x800590f2
		RSA_RecordLayout_VALUE_UWORD
		100
		RB_CONV_100_65535_Prc
		0
		100
    DISPLAY_IDENTIFIER Cxx_owe_oil_dil_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_oil_km_dil_thd
		"Maximal oil dilution rate for potential kilometer calculation"
		VALUE
		0x8005911a
		RSA_RecordLayout_VALUE_UWORD
		99.9985
		RB_CONV_100_65535_Prc
		0.0015
		100
    DISPLAY_IDENTIFIER Cxx_owe_oil_km_dil_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_pdl_thd
		"Accelerator pedal threshold for the manual reset strategy"
		VALUE
		0x8006b222
		RSA_RecordLayout_VALUE_UWORD
		1.25
		omqfgpc_fbAwBcc_yctdhkb_f_Ra0oa
		0.
		1.25
    DISPLAY_IDENTIFIER Cxx_owe_pdl_thd 
    FORMAT "%7.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_tco_sub
		"Coolant substitution value in case of failure"
		VALUE
		0x8006b0ea
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_DegC
		-40
		200
    DISPLAY_IDENTIFIER Cxx_owe_tco_sub 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_owe_toil_sub
		"Substitute value of oil temperature if the sensor is failed"
		VALUE
		0x8006b0e8
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_DegC
		-40
		200
    DISPLAY_IDENTIFIER Cxx_owe_toil_sub 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pbt_amp_dif_thd
		"Pressure difference |amp-pbt| threshold"
		VALUE
		0x80057da8
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pbt_amp_dif_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pcmd_neg_slope
		"Negative slope for precontrol transitions according to Vsx_comb_mod"
		VALUE
		0x800621b2
		RSA_RecordLayout_VALUE_UWORD
		6553.4
		zwgdwmb_haBEzgc_ysgmtAd_f__010a
		-6553.5
		-0.1
    DISPLAY_IDENTIFIER Cxx_pcmd_neg_slope 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcco_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pcmd_pos_slope
		"Positive slope for precontrol transitions according to Vsx_comb_mod"
		VALUE
		0x800621b0
		RSA_RecordLayout_VALUE_UWORD
		6553.4
		zitsqmc_gxniCsc_dCEebrc_f___00a
		0.1
		6553.5
    DISPLAY_IDENTIFIER Cxx_pcmd_pos_slope 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fspfzxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_cru_min_lim
		"Cxx_pdl_cru_min_lim"
		VALUE
		0x8005977a
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_fast_on_kd_thd
		"Cxx_pdl_fast_on_kd_thd"
		VALUE
		0x80059350
		RSA_RecordLayout_VALUE_UWORD
		100
		VA_F_0v125_p0_6
		0
		100
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_fmt_fac_slop_swi_down
		"Slope constant used during the change of progressivity maps, when decreasing"
		VALUE
		0x80059c29
		RSA_RecordLayout_VALUE_UBYTE
		1
		lnarxkb_nEFqnga_vinBdFa_roCR2a0
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pdl_fmt_fac_slop_swi_down 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_fmt_fac_slop_swi_up
		"Slope constant used during the change of progressivity maps, when increasing"
		VALUE
		0x80059c28
		RSA_RecordLayout_VALUE_UBYTE
		1
		lnarxkb_nEFqnga_vinBdFa_roCR2a0
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pdl_fmt_fac_slop_swi_up 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_grd_fast_on_thd
		"Cxx_pdl_grd_fast_on_thd"
		VALUE
		0x80059354
		RSA_RecordLayout_VALUE_SWORD
		4000
		VA_F_0v125_p0_20
		-2000
		2000
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_grd_fil
		"Cxx_pdl_grd_fil"
		VALUE
		0x8005934f
		RSA_RecordLayout_VALUE_UBYTE
		5.1
		VA_F_0v02_p0_4
		0
		5.1
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_grd_in_neg_thd
		"Cxx_pdl_grd_in_neg_thd"
		VALUE
		0x80059330
		RSA_RecordLayout_VALUE_SWORD
		4000
		VA_F_0v125_p0_20
		-2000
		2000
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pdl_grd_out_neg_thd
		"Cxx_pdl_grd_out_neg_thd"
		VALUE
		0x8005932e
		RSA_RecordLayout_VALUE_SWORD
		4000
		VA_F_0v125_p0_20
		-2000
		2000
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_ac_amp_h_thd
		"Atmospheric pressure threshold to inhibit performance restitution strategy for air conditioning"
		VALUE
		0x8005cda6
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_perf_ac_amp_h_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_ac_amp_l_thd
		"Atmospheric pressure threshold to activate performance restitution strategy for air conditioning"
		VALUE
		0x8005cda4
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_perf_ac_amp_l_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_dly
		"Maximum duration of accessories deactivation in performance restitution strategy"
		VALUE
		0x8005cda2
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_h_gear
		"Maximum gear to request accessories deactivation in performance restitution strategy"
		VALUE
		0x8005cda1
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_h_gear 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_l_gear
		"Minimum gear to request accessories deactivation in performance restitution strategy"
		VALUE
		0x8005cda0
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_l_gear 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_n
		"Maximum engine speed to request accessories deactivation in preformance restitution strategy"
		VALUE
		0x8005cd9e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_pdl_grd
		"Minimum accelerator pedal gradient to request accessories deactivation in performance restitution strategy"
		VALUE
		0x8005cd9c
		RSA_RecordLayout_VALUE_SWORD
		127.998046875
		pikndba_Biezwsc_vivAhda_roCR5a0
		-64.
		63.998046875
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_pdl_grd 
    FORMAT "%7.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_pdl_grd_t
		"Time constant of accelerator pedal gradient filter"
		VALUE
		0x8005cd9a
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_pdl_grd_t 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_pdl_rat
		"Minimum accelerator pedal position to request accessories deactivation in performance restitution strategy"
		VALUE
		0x8005cd98
		RSA_RecordLayout_VALUE_UWORD
		1.25
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.25
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_pdl_rat 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_dsb_tqe_dif
		"Maximum available torques difference to request accessories deactivation in performance restitution strategy"
		VALUE
		0x8005cd96
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_perf_acs_dsb_tqe_dif 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_ena_n
		"Minimum engine speed to request accessories reactivation in performance restitution strategy"
		VALUE
		0x8005cd94
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_perf_acs_ena_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_perf_acs_ena_pdl_rat
		"Maximum accelerator pedal position to request accessories reactivation in performance restitution strategy"
		VALUE
		0x8005cd92
		RSA_RecordLayout_VALUE_UWORD
		1.25
		Fyedevd_rnBqacd_ulakuub_roA_00a
		0.
		1.25
    DISPLAY_IDENTIFIER Cxx_perf_acs_ena_pdl_rat 
    FORMAT "%8.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_amp_dft_val
		"Atmospheric pressure default value"
		VALUE
		0x80057df4
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_amp_dft_val 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_amp_rgn_ena_1_dft
		"Atmospheric pressure default value"
		VALUE
		0x8006803c
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_amp_rgn_ena_1_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_amp_rgn_ena_h
		"High lim of atmospheric pressure hysteresis to allow regeneration"
		VALUE
		0x8006803a
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_amp_rgn_ena_h 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_amp_rgn_ena_l
		"Low lim of atmospheric pressure hysteresis to allow regeneration"
		VALUE
		0x80068038
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_amp_rgn_ena_l 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_cool_t
		"Maximum time to stay in cooling state"
		VALUE
		0x80045d5a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_cool_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_csm_fil_t
		"Time constante for PT1 filter"
		VALUE
		0x80067eec
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_csm_fil_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_dist_step
		"Mileage step to store a new mass soot value"
		VALUE
		0x80067ef0
		RSA_RecordLayout_VALUE_ULONG
		16777215
		RB_CONV_length_km
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Cxx_pft_asd_dist_step 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_dp_min
		"Minimum differential pressure to allow aftersale regeneration"
		VALUE
		0x80045d20
		RSA_RecordLayout_VALUE_SWORD
		20000
		RB_CONV_Pres_hpa
		-10000
		10000
    DISPLAY_IDENTIFIER Cxx_pft_asd_dp_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_hot_max_t
		"Maximum time to stay in heating state"
		VALUE
		0x80045d58
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_hot_max_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_hot_min_t
		"Minimum time to stay in heating state"
		VALUE
		0x80045d56
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_hot_min_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_lpos_fim_ena_t
		"Maximum time to enable lpos injection"
		VALUE
		0x80045d54
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_lpos_fim_ena_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_n_hot
		"Engine speed for CSF warming up"
		VALUE
		0x80045d50
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_rpm
		0.0
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_asd_n_hot 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_n_prct
		"Percentage of the engine speed calibration"
		VALUE
		0x80045d16
		RSA_RecordLayout_VALUE_UBYTE
		100
		RB_CONV_100_255_Prc
		0.0
		100.0
    DISPLAY_IDENTIFIER Cxx_pft_asd_n_prct 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_n_prct_t
		"Maximum time allowed in the deviation of the engine speed calibration"
		VALUE
		0x80045d4e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_n_prct_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_rgn_ena
		"Specific injection mode for an aftersale regeneration"
		VALUE
		0x80045d15
		RSA_RecordLayout_VALUE_UBYTE
		15
		RB_CONV_OneToOne
		0
		15
    DISPLAY_IDENTIFIER Cxx_pft_asd_rgn_ena 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_rgn_heat_ena
		"Injection mode for catalyst heating"
		VALUE
		0x80045d14
		RSA_RecordLayout_VALUE_UBYTE
		15
		RB_CONV_OneToOne
		0
		15
    DISPLAY_IDENTIFIER Cxx_pft_asd_rgn_heat_ena 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_rgn_maf_sp
		"Calibration for the after sale regeneration"
		VALUE
		0x80063faa
		RSA_RecordLayout_VALUE_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cxx_pft_asd_rgn_maf_sp 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_rgn_stop
		"Injection mode to stop the aftersale regeneration (standard injection mode)"
		VALUE
		0x80045d13
		RSA_RecordLayout_VALUE_UBYTE
		15
		RB_CONV_OneToOne
		0
		15
    DISPLAY_IDENTIFIER Cxx_pft_asd_rgn_stop 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_rgn_t
		"Maximum time to stay in the regeneration state"
		VALUE
		0x80045d52
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_rgn_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_tt_thd
		"Temperature before turbine threshold value for after sale regeneration"
		VALUE
		0x80045d4c
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_DegC
		-40.0
		1200.0
    DISPLAY_IDENTIFIER Cxx_pft_asd_tt_thd 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_tt_thd_t
		"Minimum time required for the temperature before turbine to be higher than a threshold"
		VALUE
		0x80045d46
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_tt_thd_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_utp_lim
		"CSF upstream temperature higher limit"
		VALUE
		0x80045d4a
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_DegC
		-40.0
		1200.0
    DISPLAY_IDENTIFIER Cxx_pft_asd_utp_lim 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_utp_lim_t
		"Time delay to stop asd regeneration if the particulate filter upstream temp raises a threshold"
		VALUE
		0x80045d44
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_utp_lim_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_utp_sp
		"CSF upstream temperature set point for after sale regeneration"
		VALUE
		0x80045d48
		RSA_RecordLayout_VALUE_UWORD
		1240
		RB_CONV_DegC
		-40.0
		1200.0
    DISPLAY_IDENTIFIER Cxx_pft_asd_utp_sp 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_asd_utp_thd_t
		"Time threshold for regeneration validation"
		VALUE
		0x80045d42
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_Time_s
		0.0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_asd_utp_thd_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_cata_hot_max_t_1
		"Maximum time in catalyst_heating state"
		VALUE
		0x80067f02
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_cata_hot_max_t_1 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_cata_hot_max_t_2
		"Maximum time in catalyst_heating state in the case of failure mode"
		VALUE
		0x80067f00
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_cata_hot_max_t_2 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_cata_hot_min_t_1
		"Minimum time in catalyst_heating state"
		VALUE
		0x80067efe
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_cata_hot_min_t_1 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_cata_hot_min_t_2
		"Minimum time in catalyst_heating state in the case of failure mode"
		VALUE
		0x80067efc
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_cata_hot_min_t_2 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_clos_rgn_dist_swi
		"Switch to choose simulated mass threshold to activate flag indicating conditions close to CSF regeneration."
		VALUE
		0x80046d15
		RSA_RecordLayout_VALUE_UBYTE
		3
		FgevDdd_qBlgAwd_zDfgqra_n_R0aoa
		1.
		4.
    DISPLAY_IDENTIFIER Cxx_pft_clos_rgn_dist_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_clos_rgn_ms_swi
		"Switch to choose soot mass threshold to activate the flag indicating conditions close to CSF regeneration"
		VALUE
		0x80046d14
		RSA_RecordLayout_VALUE_UBYTE
		3
		FgevDdd_qBlgAwd_zDfgqra_n_R0aoa
		1.
		4.
    DISPLAY_IDENTIFIER Cxx_pft_clos_rgn_ms_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_cmp_agb_req_t
		"Time after the regeneration start to store the estimated soot mass for automatic gearbox request"
		VALUE
		0x80047118
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_cmp_agb_req_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_cold_sta_tco_thd
		"Engine coolant temperature threshold for cold start detection in msot offset learning strategy."
		VALUE
		0x80046652
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_cold_sta_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_cold_sta_tia_thd
		"Intake air temperature threshold for cold start detection in msot offset learning strategy."
		VALUE
		0x80046650
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_cold_sta_tia_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_comb_ok
		"Threshold on estimated combusted soot mass for partial regeneration detection."
		VALUE
		0x80046b60
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_comb_ok 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_comb_ok_prct
		"Factor for threshold on estimated combusted soot mass for partial regeneration detection."
		VALUE
		0x80046b5e
		RSA_RecordLayout_VALUE_UBYTE
		1
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pft_comb_ok_prct 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_csm_drv_max_rgn_t_dft
		"Defaut value of filtered injected fuel quantity to calculate maximum regeneration time in case of sensor failure"
		VALUE
		0x80067fa6
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_csm_drv_max_rgn_t_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_csm_rgn_err_dft
		"Defaut value of filtered injected fuel quantity to compute regeneration failure condition in case of sensor failure"
		VALUE
		0x80067fa4
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_csm_rgn_err_dft 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ctr_err_min_still
		"Minimum regeneration failures number to active transition to restart state."
		VALUE
		0x80067fa2
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_pft_ctr_err_min_still 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ctr_rgn_err_max
		"Max number of regeneration failure -> validated failure"
		VALUE
		0x80046b86
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_pft_ctr_rgn_err_max 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ctr_spd_req_err
		"Number of regeneration failure reached to allow regeneration with speed_request"
		VALUE
		0x80046d9a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_pft_ctr_spd_req_err 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dfl_vh_dist_min_aut
		"Minimum distance since last default set up to forbid particulate filter regeneration"
		VALUE
		0x80047116
		RSA_RecordLayout_VALUE_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		0.
		1048560.
    DISPLAY_IDENTIFIER Cxx_pft_dfl_vh_dist_min_aut 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_max_zon_1
		"Maximum atmospheric pressure threshold to realise diagnosis on Zone 1"
		VALUE
		0x80045fd4
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_max_zon_1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_max_zon_2
		"Maximum atmospheric pressure threshold to realise diagnosis on Zone2"
		VALUE
		0x80045fd2
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_max_zon_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_max_zon_3
		"Maximum atmospheric pressure threshold to realise diagnosis on Zone 3"
		VALUE
		0x80045fd0
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_max_zon_3 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_max_zon_4
		"Maximum atmospheric pressure threshold to realise diagnosis on Zone 4"
		VALUE
		0x80045fce
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_max_zon_4 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_min_zon_1
		"Minimum atmospheric pressure threshold to realise diagnosis on Zone 1"
		VALUE
		0x80045fcc
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_min_zon_1 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_min_zon_2
		"Minimum atmospheric pressure threshold to realise diagnosis on Zone 2"
		VALUE
		0x80045fca
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_min_zon_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_min_zon_3
		"Minimum atmospheric pressure threshold to realise diagnosis on Zone 3"
		VALUE
		0x80045fc8
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_min_zon_3 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_amp_min_zon_4
		"Minimum atmospheric pressure threshold to realise diagnosis on Zone 4"
		VALUE
		0x80045fc6
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_amp_min_zon_4 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_aut_min_t
		"Minimum engine autonomous time for diagnosis release"
		VALUE
		0x80045d84
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_aut_min_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_aut_min_t_lkg
		"Minimum engine autonomous time for diagnosis release in overload particulate filter"
		VALUE
		0x80046430
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_aut_min_t_lkg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_fil_sq_max
		"Maximum value for the square value of the differential pressure"
		VALUE
		0x80045d80
		RSA_RecordLayout_VALUE_ULONG
		16777215
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		0.
		16777215.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_fil_sq_max 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_fil_sq_max_lkg
		"Maximum value for the square value of the differential pressure in overload particulate filter"
		VALUE
		0x8004642c
		RSA_RecordLayout_VALUE_ULONG
		16777215
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		0.
		16777215.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_fil_sq_max_lkg 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_max
		"Maximum threshold of CSF delta pressure filtered to authorize diff pressure diagnosis"
		VALUE
		0x80045d7e
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_max_lkg
		"Maximum threshold of CSF delta pressure filtered to authorize diff pressure diagnosis in overload particulate filter"
		VALUE
		0x8004642a
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_max_lkg 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_max_zon_1
		"Threshold of maximum pressure difference on Zone 1 to detect malfunctioning CSF"
		VALUE
		0x80045fc4
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_max_zon_1 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_max_zon_2
		"Threshold of maximum pressure difference on Zone 2 to detect malfunctioning CSF"
		VALUE
		0x80045fc2
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_max_zon_2 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_max_zon_3
		"Threshold of maximum pressure difference on Zone 3 to detect malfunctioning CSF"
		VALUE
		0x80045fc0
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_max_zon_3 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_max_zon_4
		"Threshold of maximum pressure difference on Zone 4 to detect malfunctioning CSF"
		VALUE
		0x80045fbe
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_max_zon_4 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_min
		"Threshold of minimum pressure difference to detect malfunctioning CSF"
		VALUE
		0x80045fbc
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_t
		"Time constant for differential pressure filtering"
		VALUE
		0x80045d7c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_dp_t_lkg
		"Time constant for differential pressure filtering in overload particulate filter"
		VALUE
		0x80046428
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_dp_t_lkg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_max_zon_1
		"Maximum volumic exhaust gas flow index to realize diagnosis on Zone 1"
		VALUE
		0x80045fbb
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_max_zon_1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_max_zon_2
		"Maximum volumic exhaust gas flow index to realize diagnosis on Zone 2"
		VALUE
		0x80045fba
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_max_zon_2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_max_zon_3
		"Maximum volumic exhaust gas flow index to realize diagnosis on Zone 3"
		VALUE
		0x80045fb9
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_max_zon_3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_max_zon_4
		"Maximum volumic exhaust gas flow index to realize diagnosis on Zone 4"
		VALUE
		0x80045fb8
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_max_zon_4 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_min_zon_1
		"Minimum volumic exhaust gas flow index to realize diagnosis on Zone 1"
		VALUE
		0x80045fb7
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_min_zon_1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_min_zon_2
		"Minimum volumic exhaust gas flow index to realize diagnosis on Zone 2"
		VALUE
		0x80045fb6
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_min_zon_2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_min_zon_3
		"Minimum volumic exhaust gas flow index to realize diagnosis on Zone 3"
		VALUE
		0x80045fb5
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_min_zon_3 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_ind_min_zon_4
		"Minimum volumic exhaust gas flow index to realize diagnosis on Zone 4"
		VALUE
		0x80045fb4
		RSA_RecordLayout_VALUE_UBYTE
		40
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		40.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_ind_min_zon_4 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_min
		"Minimum air mass flow for diagnosis release"
		VALUE
		0x80045d7a
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_min1
		"Exhaust gas flow threshold for diagnosis of broken particulate filter"
		VALUE
		0x80045d78
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_min1 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_min2
		"Exhaust gas flow threshold for diagnosis of overloaded particulate filter"
		VALUE
		0x80046426
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_min2 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_min_lkg
		"Minimum air mass flow for diagnosis release in overload particulate filter"
		VALUE
		0x80046424
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_min_lkg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_t
		"Filter constant for exhaust air mass flow diagnosis filtering"
		VALUE
		0x80045d76
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_egaf_t_lkg
		"Filter constant for exhaust air mass flow diagnosis filtering in overload particulate filter"
		VALUE
		0x80046422
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_egaf_t_lkg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_max_zon_1
		"Maximum Egr valve position setpoint threshold to realise diagnosis on Zone 1"
		VALUE
		0x80045fb2
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_max_zon_1 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_max_zon_2
		"Maximum Egr valve position setpoint threshold to realise diagnosis on Zone 2"
		VALUE
		0x80045fb0
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_max_zon_2 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_max_zon_3
		"Maximum Egr valve position setpoint threshold to realise diagnosis on Zone 3"
		VALUE
		0x80045fae
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_max_zon_3 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_max_zon_4
		"Maximum Egr valve position setpoint threshold to realise diagnosis on Zone 4"
		VALUE
		0x80045fac
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_max_zon_4 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_min_zon_1
		"Minimum Egr valve position setpoint threshold to realise diagnosis on Zone 1"
		VALUE
		0x80045faa
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_min_zon_1 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_min_zon_2
		"Minimum Egr valve position setpoint threshold to realise diagnosis on Zone 2"
		VALUE
		0x80045fa8
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_min_zon_2 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_min_zon_3
		"Minimum Egr valve position setpoint threshold to realise diagnosis on Zone 3"
		VALUE
		0x80045fa6
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_min_zon_3 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_emtv_min_zon_4
		"Minimum Egr valve position setpoint threshold to realise diagnosis on Zone 4"
		VALUE
		0x80045fa4
		RSA_RecordLayout_VALUE_SWORD
		400
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_emtv_min_zon_4 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_ena_t
		"Delay time for diagnosis enable"
		VALUE
		0x80045d74
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_ena_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_ena_t_lkg
		"Delay time for diagnosis enable in overload particulate filter"
		VALUE
		0x80046420
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_ena_t_lkg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_err_max
		"Maximum accumulator value to broken filter detection"
		VALUE
		0x80045d70
		RSA_RecordLayout_VALUE_SLONG
		131070
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		-65535.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_diag_err_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_err_min
		"Minimum accumulator value to broken filter detection"
		VALUE
		0x80045d6c
		RSA_RecordLayout_VALUE_SLONG
		131070
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		-65535.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_diag_err_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_fms_hys_zon_1
		"Difference of total fuel quantity thresholds to authorize diagnosis for Zone 1"
		VALUE
		0x80045fa2
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_diag_fms_hys_zon_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_fms_hys_zon_2
		"Difference of total fuel quantity thresholds to authorize diagnosis for Zone 2"
		VALUE
		0x80045fa0
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_diag_fms_hys_zon_2 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_fms_hys_zon_3
		"Difference of total fuel quantity thresholds to authorize diagnosis for Zone 3"
		VALUE
		0x80045f9e
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_diag_fms_hys_zon_3 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_fms_hys_zon_4
		"Difference of total fuel quantity thresholds to authorize diagnosis for Zone 4"
		VALUE
		0x80045f9c
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_diag_fms_hys_zon_4 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_max_zon_1
		"Maximum threshold engine speed to authorise diagnosis on Zone 1"
		VALUE
		0x80045f9a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_max_zon_1 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_max_zon_2
		"Maximum threshold engine speed to authorise diagnosis on Zone 2"
		VALUE
		0x80045f98
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_max_zon_2 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_max_zon_3
		"Maximum threshold engine speed to authorise diagnosis on Zone 3"
		VALUE
		0x80045f96
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_max_zon_3 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_max_zon_4
		"Maximum threshold engine speed to authorise diagnosis on Zone 4"
		VALUE
		0x80045f94
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_max_zon_4 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_min_zon_1
		"Minimum threshold engine speed to authorise diagnosis on Zone 1"
		VALUE
		0x80045f92
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_min_zon_1 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_min_zon_2
		"Minimum threshold engine speed to authorise diagnosis on Zone 2"
		VALUE
		0x80045f90
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_min_zon_2 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_min_zon_3
		"Minimum threshold engine speed to authorise diagnosis on Zone 3"
		VALUE
		0x80045f8e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_min_zon_3 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_n_min_zon_4
		"Minimum threshold engine speed to authorise diagnosis on Zone 4"
		VALUE
		0x80045f8c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_diag_n_min_zon_4 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_ovl_max
		"Maximum accumulator value for over load filter detection"
		VALUE
		0x8004641e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_diag_ovl_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_rgn_nr_min
		"Minimun successful regeneration for diagnosis"
		VALUE
		0x80045d6a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_pft_diag_rgn_nr_min 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_rgn_nr_min_lkg
		"Minimun successful regeneration for diagnosis in overload particulate filter"
		VALUE
		0x8004641c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_pft_diag_rgn_nr_min_lkg 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_sum_nr_zon_1
		"Number of necessary point to validate mean calculation on Zone 1"
		VALUE
		0x80045f8a
		RSA_RecordLayout_VALUE_UWORD
		1000
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_sum_nr_zon_1 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_sum_nr_zon_2
		"Number of necessary point to validate mean calculation on Zone 2"
		VALUE
		0x80045f88
		RSA_RecordLayout_VALUE_UWORD
		1000
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_sum_nr_zon_2 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_sum_nr_zon_3
		"Number of necessary point to validate mean calculation on Zone 3"
		VALUE
		0x80045f86
		RSA_RecordLayout_VALUE_UWORD
		1000
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_sum_nr_zon_3 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_sum_nr_zon_4
		"Number of necessary point to validate mean calculation on Zone 4"
		VALUE
		0x80045f84
		RSA_RecordLayout_VALUE_UWORD
		1000
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_sum_nr_zon_4 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_t
		"Filter constant for diagnosis filtering"
		VALUE
		0x80045d68
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_t_lkg
		"Filter constant for diagnosis filtering in overload particulate filter"
		VALUE
		0x8004641a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_diag_t_lkg 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_thd_tia_min
		"Minimum threshold of intake air temperature for enabling CSF diagnosis"
		VALUE
		0x80045d66
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_thd_tia_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_thd_tia_min_lkg
		"Minimum threshold of intake air temperature for enabling CSF diagnosis in overload particulate filter"
		VALUE
		0x80046418
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_diag_thd_tia_min_lkg 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_up_prs_obd_max
		"Threshold for CSF clogged detection"
		VALUE
		0x80045f72
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_up_prs_obd_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_diag_up_prs_obd_min
		"Minimum threshold for CSF clogged detection"
		VALUE
		0x80045f70
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_diag_up_prs_obd_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dil_cor_flp_pr_max
		"Maximum dilution factor for late post deviation from dilution measuring point"
		VALUE
		0x8005527e
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		RB_CONV_0001_FACT
		0
		6.5535
    DISPLAY_IDENTIFIER Cxx_pft_dil_cor_flp_pr_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dil_cor_flp_pr_min
		"Minimum dilution factor for late post deviation from dilution measuring point"
		VALUE
		0x80055bb4
		RSA_RecordLayout_VALUE_SLONG
		6
		RB_CONV_0001_FACT
		-1.0
		5.0
    DISPLAY_IDENTIFIER Cxx_pft_dil_cor_flp_pr_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_1_max
		"High limitation on distance threshold for hot conditions (dep of CSF efficacity )"
		VALUE
		0x80046d98
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_1_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_1_min
		"Low limitation on distance threshold for hot conditions (dep of CSF efficacity )"
		VALUE
		0x80046d96
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_1_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_2_max
		"High limitation on distance threshold for cold conditions (dep of CSF efficacity)"
		VALUE
		0x80046d94
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_2_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_2_min
		"Low limitation on distance threshold for cold conditions (dep of CSF efficacity)"
		VALUE
		0x80046d92
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_2_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_3_max
		"High limitation on distance threshold for mini conditions  (dep of CSF efficacity)"
		VALUE
		0x80046d90
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_3_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_3_min
		"Low limitation on distance threshold for mini conditions  (dep of CSF efficacity)"
		VALUE
		0x80046d8e
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_3_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_4_max
		"High limitation on distance threshold for medium regeneration conditions (dep of CSF efficiency)"
		VALUE
		0x80046d8c
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_4_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_4_min
		"Low limitation on distance threshold for medium regeneration conditions (dep of CSF efficiency)"
		VALUE
		0x80046d8a
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_4_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_5_max
		"High limitation on distance threshold for medium regeneration conditions (dep of CSF efficiency)"
		VALUE
		0x80046d88
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_5_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_5_min
		"Low limitation on distance threshold for limp home conditions"
		VALUE
		0x80046d86
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_5_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_err_forc_max
		"High limitation on distance threshold for forced regeneration in case of failure (dep of CSF efficacity )"
		VALUE
		0x80046d84
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_err_forc_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_err_forc_min
		"Low limitation on distance threshold for forced regeneration in case of failure (dep of CSF efficacity )"
		VALUE
		0x80046d82
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_err_forc_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dist_rgn_ofs_clos_rgn
		"Distance driven threshold offset to activate flag indicating conditons close to CSF regeneration"
		VALUE
		0x80046d12
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_dist_rgn_ofs_clos_rgn 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dp_dft_val
		"Differential pressure default value"
		VALUE
		0x80057df2
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_dp_dft_val 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dp_vrnc_err_max2
		"Maximum normalized differential pressure variance for broken filter release in case of low pressure"
		VALUE
		0x80045d64
		RSA_RecordLayout_VALUE_UWORD
		1
		rErCnwa_xcoFdya_Bqeaoqb_n__400a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pft_dp_vrnc_err_max2 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dp_vrnc_max
		"Maximum value of square of differential pressure"
		VALUE
		0x80045d60
		RSA_RecordLayout_VALUE_ULONG
		16777215
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		0.
		16777215.
    DISPLAY_IDENTIFIER Cxx_pft_dp_vrnc_max 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dp_vrnc_max_lkg
		"Maximum value of square of differential pressure for overload particulate filter"
		VALUE
		0x80046414
		RSA_RecordLayout_VALUE_ULONG
		16777215
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		0.
		16777215.
    DISPLAY_IDENTIFIER Cxx_pft_dp_vrnc_max_lkg 
    FORMAT "%10.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dp_vrnc_ovl_max
		"Maximum normalized differential pressure variance for overload release"
		VALUE
		0x80046412
		RSA_RecordLayout_VALUE_UWORD
		1
		rErCnwa_xcoFdya_Bqeaoqb_n__400a
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pft_dp_vrnc_ovl_max 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dtp_lih_val
		"CSF downstream temperature limp home value for CSF up temp regulator when combustion model is disabled"
		VALUE
		0x80045886
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_dtp_lih_val 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtempcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_dtp_sens_dft_val
		"CSF downstream temperature sensor default value in case of invalid estimated internal temperature."
		VALUE
		0x80058326
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_dtp_sens_dft_val 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efi_act_dly
		"Delay time for the activation of the fuel injector in the exhaust line"
		VALUE
		0x80058db6
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_efi_act_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efi_act_off_dly
		"Delay time for the desactivation of exhaust line opening in case of insufficient temperature"
		VALUE
		0x80058f28
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_efi_act_off_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efi_cmd_ftc
		"Time constant for exhaust fuel injector command integrator"
		VALUE
		0x80058db4
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_efi_cmd_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efi_ff_t
		"Maximal sampling time acceptable for the ECU"
		VALUE
		0x80058db2
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_efi_ff_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efi_prs_ftc
		"Filter time constant for the relative pressure of fuel injected in exhaust line"
		VALUE
		0x80058db0
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_efi_prs_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efi_pwm_min
		"Minimum value for cycling opening percentage of the fuel injector in exhaust line"
		VALUE
		0x80058dae
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_efi_pwm_min 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efy_prct_chg_end_dft
		"Default value for CSF efficiency of soot emissions in case of failure"
		VALUE
		0x80046d80
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_efy_prct_chg_end_dft 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efy_prct_intv
		"Default value for CSF efficiency of storage soot emission"
		VALUE
		0x8004664e
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_efy_prct_intv 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efy_prct_lih_val
		"CSF soot emissions storage efficiency limp home value for CSF up temp regulation"
		VALUE
		0x80045884
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_efy_prct_lih_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_efy_prct_sot_comb_dft
		"Default value for CSF efficiency to enable the interpolation of the combusted soot mass."
		VALUE
		0x80067fa0
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_efy_prct_sot_comb_dft 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_clc_fac
		"Constant for air flow calculation"
		VALUE
		0x80057dd6
		RSA_RecordLayout_VALUE_UWORD
		0.04
		rcfmwFb_alBjDuc_nEjjqEb_mPKR10a
		0.
		0.04
    DISPLAY_IDENTIFIER Cxx_pft_egaf_clc_fac 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_clc_t_fil
		"Filter time constant for volumic flow calculation"
		VALUE
		0x80057df0
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_egaf_clc_t_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utempcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_clc_t_utp_fil
		"Filter time constant for upstream temperature calculation"
		VALUE
		0x8005832c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_egaf_clc_t_utp_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_dev_ms
		"Maximum value of volumic flow derivative for soot estimation"
		VALUE
		0x8004664c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		ykuBijd_yAhnlEa_ffapzdb_ih_Raa0
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_egaf_dev_ms 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_err_min
		"Minimum air mass flow difference for broken filter release"
		VALUE
		0x80045d5c
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_egaf_err_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_fil_t_fil
		"Filter time constant for filtered Qvol"
		VALUE
		0x80057dd4
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_egaf_fil_t_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_ovl_min
		"Minimum air flow difference for overload filter release"
		VALUE
		0x80046410
		RSA_RecordLayout_VALUE_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_egaf_ovl_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_t_fil
		"Filter time constant for volumic flow"
		VALUE
		0x8004664a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_egaf_t_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_urb_driv_cdn
		"Air flow limit for urban driving condition"
		VALUE
		0x80046648
		RSA_RecordLayout_VALUE_UWORD
		2000
		movAqed_DtteCgd_cloonha_Bh__10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_egaf_urb_driv_cdn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_egaf_xurb_driv_cdn
		"Air flow limit for extra-urban driving condition"
		VALUE
		0x80046646
		RSA_RecordLayout_VALUE_UWORD
		2000
		movAqed_DtteCgd_cloonha_Bh__10a
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_egaf_xurb_driv_cdn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ehr_ms_esti_min
		"Minimum value of ehr of the CSF soot mass estimated during the regeneration"
		VALUE
		0x80046948
		RSA_RecordLayout_VALUE_ULONG
		0.065535
		zvldabd_plckxob_dwyrutb_k__00o0
		0.
		0.065535
    DISPLAY_IDENTIFIER Cxx_pft_ehr_ms_esti_min 
    FORMAT "%12.10" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ehr_o2_fac_sot_min
		"Minimum value of estimation of O2 concentration at the end of the first ehr of the particule filter"
		VALUE
		0x80046946
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_ehr_o2_fac_sot_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_eng_drvn_t_tia_cor_cnd
		"Engine condition maximum time to compute mean value of inlet air temperature"
		VALUE
		0x800580fe
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_eng_drvn_t_tia_cor_cnd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_esti_req_dist_prot_lvl
		"Level of confidence fixed, for required distances estimation"
		VALUE
		0x80046ce6
		RSA_RecordLayout_VALUE_UBYTE
		0.5
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		0.5
		1.
    DISPLAY_IDENTIFIER Cxx_pft_esti_req_dist_prot_lvl 
    FORMAT "%9.7" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ext_ar
		"External surface of the particle sool filter"
		VALUE
		0x80046944
		RSA_RecordLayout_VALUE_UWORD
		65.535
		tysfkbc_CCoqjod_hCDmFFa_mCRa00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_pft_ext_ar 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fac_sot_comb
		"Factor on soot mass for status of combusted soot mass."
		VALUE
		0x80067f9f
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_pft_fac_sot_comb 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fac_sot_stop
		"Factor on soot mass for regeneration identification"
		VALUE
		0x80067f9e
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_pft_fac_sot_stop 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_exprsmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fac_up_prs_0
		"Zero order coefficient for downstream pressure estimation"
		VALUE
		0x80057dfc
		RSA_RecordLayout_VALUE_SWORD
		65535
		CtFwfod_leeccbc_rBvivld_BaCRa0a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cxx_pft_fac_up_prs_0 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_exprsmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fac_up_prs_1
		"First order coefficient for downstream pressure estimation"
		VALUE
		0x80057dfa
		RSA_RecordLayout_VALUE_SWORD
		655350
		rjeccdd_jblzjsb_kBFllma_B2DA010
		-327680.
		327670.
    DISPLAY_IDENTIFIER Cxx_pft_fac_up_prs_1 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_exprsmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fac_up_prs_2
		"Second order coefficient for downstream pressure estimation"
		VALUE
		0x80057df8
		RSA_RecordLayout_VALUE_SWORD
		65535000
		yeeojyb_qFtgBBa_upakrld_Bs2_a0a
		-32768000.
		32767000.
    DISPLAY_IDENTIFIER Cxx_pft_fac_up_prs_2 
    FORMAT "%9.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ff_pft_hot
		"Minimum threshold on injected quantity (mg/s) for transition to the hot CSF state"
		VALUE
		0x80067f9c
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_ff_pft_hot 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ff_rgn_err
		"Maximum threshold on injected quantity (mg/s) for transition to regeneration failure state"
		VALUE
		0x80067f9a
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_ff_rgn_err 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ff_rgn_err_hot
		"Maximum threshold on injected quantity (mg/s) for transition to regeneration failure state with hot CSF"
		VALUE
		0x80067f98
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_ff_rgn_err_hot 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ff_sum_sta_cata_min_2
		"Minimum fuel injection quantity threshold for transition to rgn_request state (failure mode)"
		VALUE
		0x80067efa
		RSA_RecordLayout_VALUE_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_ff_sum_sta_cata_min_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_spdreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ff_sum_sta_spd_req
		"Minimum fuel injected quantity for request to regenerate"
		VALUE
		0x80046d00
		RSA_RecordLayout_VALUE_ULONG
		65535
		htcDCta_bFrnkyc_dCEgxCc_msA_10a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_ff_sum_sta_spd_req 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlcsmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fil_1_t
		"Time constant for fuel consumption filtering"
		VALUE
		0x80057dee
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_fil_1_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtempcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fil_t
		"Time constant for temperature filtering"
		VALUE
		0x80058324
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_fil_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_cold_0
		"Minimum injected quantity threshold for cold condition (vehicle speed failure mode)"
		VALUE
		0x8006811e
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_cold_0 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_cold_1
		"Minimum injected quantity treshold for cold condition (coolant temperature failure mode)"
		VALUE
		0x8006811c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		kcAgawb_cszkxob_ykbdhoa_l_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_cold_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_driv_0
		"Minimum injected quantity threshold for driving conditions"
		VALUE
		0x8006811a
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_driv_0 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_driv_1
		"Minimum injected quantity threshold for driving conditions"
		VALUE
		0x80068118
		RSA_RecordLayout_VALUE_UWORD
		655.35
		kcAgawb_cszkxob_ykbdhoa_l_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_driv_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_driv_2
		"Minimum injected quantity threshold for driving conditions"
		VALUE
		0x80068116
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_driv_2 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_driv_rgn_forc
		"Minimum injected quantity threshold for driving conditions in case of forced regeneration"
		VALUE
		0x80068114
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_driv_rgn_forc 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_forc_rgn
		"Minimum injected quantity threshold for forced regeneration conditions"
		VALUE
		0x80068112
		RSA_RecordLayout_VALUE_UWORD
		655.35
		kcAgawb_cszkxob_ykbdhoa_l_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_forc_rgn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_hot_0
		"Minimum injected quantity threshold for hot conditions (vehicle speed failure mode)"
		VALUE
		0x80068110
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_hot_0 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_hot_1
		"min inj qty threshold for hot conditions"
		VALUE
		0x8006810e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		kcAgawb_cszkxob_ykbdhoa_l_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_hot_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_med_0
		"Min inj qty threshold for medium rgn conditions (veh speed fail mode)"
		VALUE
		0x8006810c
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_med_0 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fim_thd_med_1
		"min inj qty threshold for medium conditions"
		VALUE
		0x8006810a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		kcAgawb_cszkxob_ykbdhoa_l_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_fim_thd_med_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fms_dg_ig_init_low_lim
		"Lower value of TBF loop deviation limit for I and D parts reinitialization."
		VALUE
		0x80044dae
		RSA_RecordLayout_VALUE_SWORD
		2400
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_fms_dg_ig_init_low_lim 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_fms_dg_ig_init_up_lim
		"Upper value of TBF loop deviation limit for I and D parts reinitialization"
		VALUE
		0x80044dac
		RSA_RecordLayout_VALUE_SWORD
		2400
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_fms_dg_ig_init_up_lim 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_bas_asd
		"Default value of basic mass flow on after-sale regeneration condition"
		VALUE
		0x80044daa
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_bas_asd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_d_ftc
		"Filtering time contant for the derivative part of injected fuel mass flow correction."
		VALUE
		0x80044da8
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_d_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_dg_ada
		"Adaptative coefficient for the derivative gain of injected fuel mass flow correction"
		VALUE
		0x80044da6
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_dg_ada 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_ig_ada
		"Adaptative coefficient for the integral gain of injected fuel mass flow correction"
		VALUE
		0x80044da4
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_ig_ada 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_max_ada_gain
		"Adaptation gain for maximum injected fuel mass flow correction"
		VALUE
		0x80044da2
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_max_ada_gain 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_max_asd
		"Maximum value of PID corrected mass flow on after-sale regeneration condition"
		VALUE
		0x80044da0
		RSA_RecordLayout_VALUE_SWORD
		200
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_max_asd 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_min_ada_gain
		"Adaptation gain for minimum injected fuel mass flow correction"
		VALUE
		0x80044d9e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_min_ada_gain 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_min_asd
		"Minimum value of PID corrected mass flow on after-sale regeneration condition"
		VALUE
		0x80044d9c
		RSA_RecordLayout_VALUE_SWORD
		200
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_min_asd 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_pg_ada
		"Adaptative factor for the proportional gain of injected fuel mass flow correction"
		VALUE
		0x80044d9a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_pg_ada 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_inj_fms_reg_ini_val
		"Default output of injected fuel mass flow controller when inactive"
		VALUE
		0x80044d98
		RSA_RecordLayout_VALUE_SWORD
		200
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_inj_fms_reg_ini_val 
    FORMAT "%7.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_load_min_t_rgn_forc
		"Minimum time of activated engine for driving conditions"
		VALUE
		0x80068108
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_load_min_t_rgn_forc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_load_spd_dft_max
		"Calibration of the maximum value of default soot load speed"
		VALUE
		0x80046cce
		RSA_RecordLayout_VALUE_UBYTE
		0.348
		tqfnykb_zrjpzpb_cvihkvb_gC_o00a
		0.002
		0.35
    DISPLAY_IDENTIFIER Cxx_pft_load_spd_dft_max 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_load_spd_dist_intv_min
		"Minimum distance interval for soot load speed calculation"
		VALUE
		0x80046ccc
		RSA_RecordLayout_VALUE_UWORD
		65535
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_load_spd_dist_intv_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_maf_utp_max_sp_ftc
		"Filtrering time constant for TBF maximum value depending on mass air flow"
		VALUE
		0x800458fa
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_maf_utp_max_sp_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_malf_diag_dp_max
		"Maximum threshold of CSF delta pressure filtered to authorize diagnosis."
		VALUE
		0x80045f82
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_pft_malf_diag_dp_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_malf_diag_ena_t
		"Delay time for diagnosis enable."
		VALUE
		0x80045f80
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_malf_diag_ena_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_malf_dp_t
		"Time constant for differencial pressure filtering."
		VALUE
		0x80045f7e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_malf_dp_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_malf_egaf_t
		"Filter constant for exhaust air mass flow diagnosis filtering."
		VALUE
		0x80045f7c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_malf_egaf_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_malf_thd_tia_hys_diff
		"Difference of intake air temperature for enabling CSF diagnosis"
		VALUE
		0x80045f7a
		RSA_RecordLayout_VALUE_SWORD
		240
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_malf_thd_tia_hys_diff 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_malf_thd_tia_min
		"Minimum threshold of intake air temperature for enabling CSF diagnosis."
		VALUE
		0x80045f78
		RSA_RecordLayout_VALUE_SWORD
		240
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_malf_thd_tia_min 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_max_ms_tgt_dft
		"Default soot mass value for maximum predictive target comparison in mileage regeneration detection condition"
		VALUE
		0x80046b84
		RSA_RecordLayout_VALUE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_max_ms_tgt_dft 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_max_rgn_t_comp
		"Minimum time left in regeneration to allow restart"
		VALUE
		0x80067f96
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_max_rgn_t_comp 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_ptissxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_is_n
		"Particle filter idle speed setpoint calibration"
		VALUE
		0x8005aef4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_iter_nr
		"Minimum number of mass model iteration for msot offset calculation."
		VALUE
		0x80046644
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_min_iter_nr 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_load_t
		"min charging time"
		VALUE
		0x80046b82
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_min_load_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_ms_cor_wait_mod
		"Minimum soot mass to activate waiting mode on maximum regeneration errors."
		VALUE
		0x80046d10
		RSA_RecordLayout_VALUE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_min_ms_cor_wait_mod 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_rgn_err_hot_t
		"Time of low temperature for transition to regeneration_failure state with hot CSF"
		VALUE
		0x80067f94
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_min_rgn_err_hot_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_rgn_err_t
		"Time of low temperature for transition to regeneration_failure state"
		VALUE
		0x80067f92
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_min_rgn_err_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_rgn_t
		"Minimum regeneration time"
		VALUE
		0x80067f90
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_min_rgn_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_spd_thd_cold_cdn
		"Minimu vehicle speed threshold for cold conditions"
		VALUE
		0x80068106
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_min_spd_thd_cold_cdn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_spd_thd_hot_cdn
		"Minimum vehicle speed threshold for hot conditions"
		VALUE
		0x80068104
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_min_spd_thd_hot_cdn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_min_spd_thd_med_cdn
		"Minimum vehicle speed threshold for medium rgn conditions"
		VALUE
		0x80068102
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_min_spd_thd_med_cdn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_clc_t_fil
		"Filter time constant for mass value"
		VALUE
		0x80057dd2
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_ms_clc_t_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_cmp_rat_max
		"Maximum value of soot mass left comparison ratio"
		VALUE
		0x80047114
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_pft_ms_cmp_rat_max 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_cmp_rat_min
		"Minimum value of soot mass left comparison ratio"
		VALUE
		0x80047112
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_pft_ms_cmp_rat_min 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_comb_stop
		"Threshold on estimated combusted soot mass for regeneration end detection."
		VALUE
		0x80046b5c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_comb_stop 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_comb_stop_prct
		"Factor for threshold on estimated combusted soot mass for regeneration end detection."
		VALUE
		0x80046b5a
		RSA_RecordLayout_VALUE_UBYTE
		1
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pft_ms_comb_stop_prct 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_cor_lih_val
		"Particulate filter soot mass (corrected) limp home value"
		VALUE
		0x800458f8
		RSA_RecordLayout_VALUE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_ms_cor_lih_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_dft
		"Default soot mass"
		VALUE
		0x80046b80
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_dft 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_dp_dft
		"Limp home default value for Vxx_pft_ms_dp"
		VALUE
		0x80057e02
		RSA_RecordLayout_VALUE_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_ms_dp_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_dp_lih_val
		"CSF equivalent load limp home value"
		VALUE
		0x80045882
		RSA_RecordLayout_VALUE_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_ms_dp_lih_val 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_dp_prs_t_fil
		"PT1 time constant for differential pressure filtering"
		VALUE
		0x80057e00
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_ms_dp_prs_t_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_dp_t_fil
		"PT1 time constant for soot mass filtering"
		VALUE
		0x80057dfe
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_ms_dp_t_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_esti_frst_1
		"Default value of soot mass left in CSF after a successful rgn (declared by diff pressure)"
		VALUE
		0x80046b58
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_esti_frst_1 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_lft_esti_ini_dft
		"Default value for initial soot mass still stored when regeneration request state is left"
		VALUE
		0x80046940
		RSA_RecordLayout_VALUE_ULONG
		0.065535
		zvldabd_plckxob_dwyrutb_k__00o0
		0.
		0.065535
    DISPLAY_IDENTIFIER Cxx_pft_ms_lft_esti_ini_dft 
    FORMAT "%12.10" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_lft_ini_mdl_dft
		"Default value of initial soot mass left for estimation of soot mass during regeneration."
		VALUE
		0x800468be
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_lft_ini_mdl_dft 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_lft_rat_agb_req
		"Default value soot mass left ratio to compute automatic gearbox request in case of failure"
		VALUE
		0x80047110
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_pft_ms_lft_rat_agb_req 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_lft_rat_max
		"Maximum value of soot mass left ratio"
		VALUE
		0x8004710e
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_pft_ms_lft_rat_max 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_lft_rat_min
		"Minimum value of soot mass left ratio"
		VALUE
		0x8004710c
		RSA_RecordLayout_VALUE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Cxx_pft_ms_lft_rat_min 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_lih_val
		"Particulate filter soot mass limp home value for CSF upstream temperature regulation"
		VALUE
		0x80045880
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_lih_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_max
		"Maximum limit of soot mass"
		VALUE
		0x80046642
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_min
		"Minimum limit of soot mass"
		VALUE
		0x80046640
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_new_pft_ofs_max
		"Maximum offset generated by the green effect"
		VALUE
		0x8004663e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_new_pft_ofs_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_new_pft_ofs_min
		"Minimum offset generated by the green effect"
		VALUE
		0x8004663c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_new_pft_ofs_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_ofs_fac_rgn_max
		"Maximum correction factor to compute soot mass offset during regeneration"
		VALUE
		0x8004663a
		RSA_RecordLayout_VALUE_UWORD
		3
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		3.
    DISPLAY_IDENTIFIER Cxx_pft_ms_ofs_fac_rgn_max 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_ofs_fac_rgn_min
		"Minimum correction factor to compute soot mass offset during regeneration"
		VALUE
		0x80046638
		RSA_RecordLayout_VALUE_UWORD
		3
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		3.
    DISPLAY_IDENTIFIER Cxx_pft_ms_ofs_fac_rgn_min 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_ofs_max
		"Maximum estimated soot mass offset for cold start conditions."
		VALUE
		0x80046636
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_ofs_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_ofs_min
		"Minimum Estimated soot mass offset for cold start conditions."
		VALUE
		0x80046634
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_ofs_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_ofs_t_max
		"Maximum time for soot mass offset computation since the activation (cold start conditions)"
		VALUE
		0x80046632
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_ms_ofs_t_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_ofs_t_min
		"Minimum time since last key on for soot mass offset computation (cold start conditions)"
		VALUE
		0x80046630
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_ms_ofs_t_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_prs_max
		"Maximum limit of corrected soot mass"
		VALUE
		0x8004662e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_prs_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_prs_min
		"Minimum limit of corrected soot mass"
		VALUE
		0x8004662c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_prs_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_ref_ms_ofs
		"Referenced soot mass associated to the green effect offset"
		VALUE
		0x8004662a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_ref_ms_ofs 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_1_max
		"High limitation on estimated soot mass threshold for hot conditions (dep of CSF efficiency)"
		VALUE
		0x80046d7e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_1_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_1_min
		"Low limitation on estimated soot mass threshold for hot conditions (dep of CSF efficiency)"
		VALUE
		0x80046d7c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_1_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_2_max
		"High limitation on estimated soot mass threshold for cold conditions (dep of CSF efficiency)"
		VALUE
		0x80046d7a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_2_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_2_min
		"Low limitation on estimated soot mass threshold for cold conditions (dep of CSF efficiency)"
		VALUE
		0x80046d78
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_2_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_3_max
		"High limitation on estimated soot mass threshold for mini conditions  (dep of CSF efficacity)"
		VALUE
		0x80046d76
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_3_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_3_min
		"Low limitation on estimated soot mass threshold for mini conditions  (dep of CSF efficacity)"
		VALUE
		0x80046d74
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_3_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_4_max
		"High limitation on estimated soot mass threshold for medium thermal regeneration conditions (dep of CSF efficiency)"
		VALUE
		0x80046d72
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_4_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_4_min
		"Low limitation on estimated soot mass threshold for medium thermal regeneration conditions (dep of CSF efficiency)"
		VALUE
		0x80046d70
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_4_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_forc_max
		""
		VALUE
		0x80046d6e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_forc_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_forc_min
		""
		VALUE
		0x80046d6c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_forc_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_rgn_ofs_clos_rgn
		"Default value of average intake air temperature of loading state to calculate waiting conditions"
		VALUE
		0x80046d0e
		RSA_RecordLayout_VALUE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_ms_rgn_ofs_clos_rgn 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_sim_dft
		"Default value of ms_sim in case of failure"
		VALUE
		0x80046b7e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_sim_dft 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_sim_sta_swi
		"Switch to choose which mass type is used in ms_sim_sta"
		VALUE
		0x80046b7d
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_pft_ms_sim_sta_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_sta_esti_frst_max
		"Maximum value of soot mass for mass estimation initialization."
		VALUE
		0x80046b56
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_sta_esti_frst_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_sta_lih_val
		"Memory of soot mass at exit of charging state limp home value for CSF up temp regulation"
		VALUE
		0x800458f6
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_sta_lih_val 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_sta_min
		"Minimum soot mass at exit of charging state for status of combusted soot mass."
		VALUE
		0x80067f8e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_sta_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_sta_ofs_dft
		"Default value of memory of soot mass at exit of charging state to calculate cold start condition soot mass offset"
		VALUE
		0x80046628
		RSA_RecordLayout_VALUE_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_ms_sta_ofs_dft 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ms_sta_swi
		"Switch to choose which mass type is used in ms_sta"
		VALUE
		0x80046b7c
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Cxx_pft_ms_sta_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_nr_zon_max
		"Number of different zones of air flow"
		VALUE
		0x80046626
		RSA_RecordLayout_VALUE_UBYTE
		10
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		10.
    DISPLAY_IDENTIFIER Cxx_pft_nr_zon_max 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_o2facxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_o2_esti_fuel_fac
		"Factor for oxygen calculation depending on hydrogen to carbon ratio (fuel composition)."
		VALUE
		0x80058064
		RSA_RecordLayout_VALUE_UWORD
		0.0655
		qAywpeb_ydDurwc_FDrBuAb_1__a0a0
		0.
		0.0655
    DISPLAY_IDENTIFIER Cxx_pft_o2_esti_fuel_fac 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_ofs_clc_tco_thd
		"Engine coolant temperature threshold for msot offset calculation."
		VALUE
		0x80046624
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_ofs_clc_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_csm_max
		"Maximum Engine oil consumption"
		VALUE
		0x80058440
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		Dweusab_Abjlppc_wagagja_kCRa00a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_pft_oil_csm_max 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_csm_min
		"Minimum Engine oil consumption"
		VALUE
		0x8005843e
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		Dweusab_Abjlppc_wagagja_kCRa00a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_pft_oil_csm_min 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_dil_fac
		"Factor for oil dilution speed unit conversion"
		VALUE
		0x8005527c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_SecPerHr
		0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_oil_dil_fac 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_dil_tco_dfl_val
		"Coolant temperature default value for oil dilution strategy in case of failre"
		VALUE
		0x80055273
		RSA_RecordLayout_VALUE_UBYTE
		240
		RB_CONV_1_DegC
		-40
		200
    DISPLAY_IDENTIFIER Cxx_pft_oil_dil_tco_dfl_val 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_dil_toil_dfl_val
		"Oil temperature default value in case of toil default for oil dilution computation"
		VALUE
		0x8005527a
		RSA_RecordLayout_VALUE_UWORD
		240
		RB_CONV_DegC
		-40.0
		200
    DISPLAY_IDENTIFIER Cxx_pft_oil_dil_toil_dfl_val 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_efy_prct_max
		"Maximum CSF efficiency of storage soot emissions dependent on the engine oil consumption"
		VALUE
		0x8005806a
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_oil_efy_prct_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_efy_prct_min
		"Minimum CSF efficiency of storage soot emissions dependent on the engine oil consumption"
		VALUE
		0x80058068
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_oil_efy_prct_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_eva_fac
		"Oil temperature default value in case of toil default for oil dilution computation"
		VALUE
		0x80055278
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		RB_CONV_FACT
		0
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_oil_eva_fac 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_eva_n_min
		"Minimum engine speed to allow oil evaporation"
		VALUE
		0x80055276
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_rpm
		0
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_oil_eva_n_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_eva_t
		"Factor for oil evaporation"
		VALUE
		0x80055274
		RSA_RecordLayout_VALUE_UWORD
		65535
		RB_CONV_Time1_s
		0
		65535
    DISPLAY_IDENTIFIER Cxx_pft_oil_eva_t 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_oil_max_t
		"Maximum time since last regeneration"
		VALUE
		0x80068036
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_oil_max_t 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_pwpf_max
		"maximum soot mass that can be stored in the CSF"
		VALUE
		0x80058066
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		Dweusab_Abjlppc_wagagja_kCRa00a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_pft_pwpf_max 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_req_t_cold_rgn
		"calibration of required time after cold condition detection to validate a confirmed cold opportunity"
		VALUE
		0x80067f86
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_req_t_cold_rgn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_req_t_hot_rgn
		"calibration of required time after hot condition detection to validate a confirmed hot opportunity"
		VALUE
		0x80067f84
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_req_t_hot_rgn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_req_t_med_rgn
		"calibration of required time after med condition detection to validate a confirmed medium opportunity"
		VALUE
		0x80067f82
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_req_t_med_rgn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rest_max_t
		"Maximum time on engine conditions to enable start regeneration activation"
		VALUE
		0x80046b7a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_rest_max_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rest_min_t
		"Minimum time on engine conditions to enable start regeneration activation"
		VALUE
		0x80046b78
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_rest_min_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rest_min_t_csm
		"Minimum time on fuel consumption condition to activate start regeneration"
		VALUE
		0x80046b76
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_rest_min_t_csm 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rest_min_t_utp
		"Minimum time on particle filter upstream temperature condition to activate start regeneration"
		VALUE
		0x80046b74
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_rest_min_t_utp 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_asd_efi_max
		"Maximum Exhaust Fuel Injection Quantity for After sale Regeneration"
		VALUE
		0x80043d6a
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_asd_efi_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_asd_efi_min
		"Minimum Exhaust Fuel Injection Quantity for After sale Regeneration"
		VALUE
		0x80043d68
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_asd_efi_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_asd_flp_max
		"Maximum Late Post Injection Quantity for After sale Regeneration"
		VALUE
		0x80043d66
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_asd_flp_max 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_asd_flp_min
		"Minimum Late Post Injection Quantity for After sale Regeneration"
		VALUE
		0x80043d64
		RSA_RecordLayout_VALUE_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_asd_flp_min 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_ena_rst_t
		"Global timer threshold value to enable soot mass left reseting"
		VALUE
		0x80046b54
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_ena_rst_t 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_err_max_cold_ofs
		"Offset add to Vxx_pft_rgn_err_max_cold_cnd to disable regeneration."
		VALUE
		0x80046d6a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_err_max_cold_ofs 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_err_max_hot
		"Max number of errors in hot conditions since the last succes to apply a distance of forbiden regeneration since the last hot error"
		VALUE
		0x80046d68
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_err_max_hot 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_rgn_err_max_med
		"Max number of errors in med conditions since the last succes to apply a distance of forbiden regeneration since the last med error"
		VALUE
		0x80046d66
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_rgn_err_max_med 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_sldv_dp_open_dly
		"Delay for solenoid valve opening during power latch"
		VALUE
		0x80058f0a
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_sldv_dp_open_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_sldv_dp_pump_dly
		"Delay before solenoid valve opening authorisation during power latch"
		VALUE
		0x80058f08
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_sldv_dp_pump_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_sldv_dp_pwl_rtn_dly
		"Delay for PFT power latch maintain"
		VALUE
		0x80058f06
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_sldv_dp_pwl_rtn_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_spdreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_spd_req_max_t
		"Delaytime before transition to regeneration if conditions satisfied"
		VALUE
		0x80046cfe
		RSA_RecordLayout_VALUE_UWORD
		65535
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pft_spd_req_max_t 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_spd_thd_driv
		"Minimum vehicle speed threshold for driving conditions"
		VALUE
		0x80068100
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_spd_thd_driv 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_spd_thd_driv_rgn_forc
		"Minimum vehicle speed threshold for driving conditions in case of forced regeneration"
		VALUE
		0x800680fe
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_spd_thd_driv_rgn_forc 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_spdreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_spd_vh_spd_req
		"Min vehicle speed for request to regenerate"
		VALUE
		0x80046cfc
		RSA_RecordLayout_VALUE_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_pft_spd_vh_spd_req 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_sys_clc_dtp_ini
		"Minimum estimated CSF donwstream temperature for enabling CSF soot combustion calculation"
		VALUE
		0x8004693e
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_sys_clc_dtp_ini 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_t_fim_driv_fil
		"Time constant for injected quantity filtering (operating point for driving condition)"
		VALUE
		0x800680fc
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_t_fim_driv_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_t_fim_fil
		"Time constant for injected quantity filtering (operating point)"
		VALUE
		0x800680fa
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_t_fim_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_t_spd_driv_fil
		"Time constant for vehicle speed filtering (driving)"
		VALUE
		0x800680f8
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_t_spd_driv_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_t_spd_veh_fil
		"Time constant for vehicle speed filtering (operating point)"
		VALUE
		0x800680f6
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_t_spd_veh_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_t_temp_fil
		"Time constant for upstream temperature filtering (driving conditions)"
		VALUE
		0x800680f4
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_t_temp_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_t_utp_fil
		"Time constant for upstream temperature filtering (operating point)"
		VALUE
		0x800680f2
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_t_utp_fil 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tair_cor_mv_max
		"Maximum value of average value of intake air temperature in charging state."
		VALUE
		0x800580fc
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tair_cor_mv_max 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tair_cor_mv_min
		"Minimum value of average value of intake air temperature in charging state."
		VALUE
		0x800580fa
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tair_cor_mv_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tco_rgn_ena_1_dft
		"Engine coolant temperature default value"
		VALUE
		0x80068034
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tco_rgn_ena_1_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tco_thd_driv_cdn
		"Minimum coolant temperature threshold for driving conditions"
		VALUE
		0x800680f0
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tco_thd_driv_cdn 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtempcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_ini
		"Initial value for CSF filtered temperatures"
		VALUE
		0x80058322
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_temp_ini 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_min_rgn_h
		"High limit of temperature min hysteresis to allow regeneration"
		VALUE
		0x80068033
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_pft_temp_min_rgn_h 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_min_rgn_l
		"Low limit of temperature min hysteresis to allow regeneration"
		VALUE
		0x80068032
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_pft_temp_min_rgn_l 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_reg_act_dly
		"Delay to enable CSF upstream temperature regulation since regeneration enabled"
		VALUE
		0x8004587e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_temp_reg_act_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_reg_ct_stop_dly
		"Delay to disable CSF upstream temperature regulation in engine overrun mode"
		VALUE
		0x8004587c
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_temp_reg_ct_stop_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_thd_cold_0
		"Min inj qty threshold for cold conditions"
		VALUE
		0x800680ee
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_temp_thd_cold_0 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_thd_hot_0
		"Minimum injection quantity threshold for hot conditions"
		VALUE
		0x800680ec
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_temp_thd_hot_0 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_temp_thd_med_0
		"Minimum injection quantity threshold for medium thermal conditions"
		VALUE
		0x800680ea
		RSA_RecordLayout_VALUE_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_temp_thd_med_0 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tia_cor_mem
		"Offset value to engage the storage of Vxx_pft_tia_cor_sta"
		VALUE
		0x800580f8
		RSA_RecordLayout_VALUE_UWORD
		100
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_tia_cor_mem 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tia_cor_vs_thd
		"Minimum value of vehicle speed to activate the storage of intake air temperature"
		VALUE
		0x800580f6
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_tia_cor_vs_thd 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tia_cor_vs_thd_t
		"Turn on delay constant time to activate the storage when the condition on veh spd is fullfilled."
		VALUE
		0x800580f4
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_tia_cor_vs_thd_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tia_mv_chg_end_dft
		"Default value for average intake air temperature in case of failure"
		VALUE
		0x80046b72
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tia_mv_chg_end_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tia_mv_tia_dft
		"Default value of Intake air temperature in case of default"
		VALUE
		0x800580f2
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tia_mv_tia_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tia_mv_wait_cdn_dft
		"Default value of intake air temperature average value of loading state to caluclate waiting conditions"
		VALUE
		0x80046d0c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tia_mv_wait_cdn_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tia_rgn_ena_1_dft
		"Intake air temperature default value"
		VALUE
		0x80068030
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_tia_rgn_ena_1_dft 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_tmr_max_chk_temp
		"Max time in check_temperature mode before transition to chargingstate."
		VALUE
		0x80067f62
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_tmr_max_chk_temp 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_up_prs_obd_max_def_t
		"Error debouncing time for CSF clogged detection"
		VALUE
		0x80045f6e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_up_prs_obd_max_def_t 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_up_prs_obd_max_ok_t
		"Debouncing time for CSF clogged detection"
		VALUE
		0x80045f6c
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_up_prs_obd_max_ok_t 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_cata_min_1
		"Temperature threshold for transition to rgn or to catalyst_heating state"
		VALUE
		0x80067f60
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_cata_min_1 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_cata_min_2
		"Minimum temperature threshold for transition to regeneration_request"
		VALUE
		0x80067ef8
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_cata_min_2 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utempcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_dft
		"default value of CSF upstream temperature"
		VALUE
		0x8005832a
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_dft 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_dev_min
		"Minimum particule filter temperature utp deviation"
		VALUE
		0x80058342
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_dev_min 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_fast_dev
		"Minimum temperature fast deviation"
		VALUE
		0x80058340
		RSA_RecordLayout_VALUE_UWORD
		2000
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		0.
		2000.
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_fast_dev 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_h
		"particule filter temperature utp for SRC low signal diagnosis"
		VALUE
		0x8005833e
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_h 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_n_min
		"Minimum engine speed for diagnosis condition"
		VALUE
		0x8005833c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_n_min 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_n_min_pup
		"Minimum engine speed for diagnosis condition in case of pull up commutation"
		VALUE
		0x8005833a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_n_min_pup 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_no_dev_cdn
		"Maximum difference between first and current filtered temperature"
		VALUE
		0x80058338
		RSA_RecordLayout_VALUE_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_no_dev_cdn 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_tco_min
		"Minimum coolant temperature for non deviation diagnosis condition"
		VALUE
		0x80058336
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_tco_min 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_tco_min_pup
		"Minimum engine coolant temperature for diagnosis condition in case of pull up commutation"
		VALUE
		0x80058334
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_tco_min_pup 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_temp_min
		"first break point of temperature or minimum possible value"
		VALUE
		0x80058332
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_temp_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_tqi_min
		"Minimum torque indicated for diagnosis condition"
		VALUE
		0x80058330
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_tqi_min 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_diag_tqi_min_pup
		"Minimum torque indicated for diagnosis condition in case of pull up commutation"
		VALUE
		0x8005832e
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_pft_utp_diag_tqi_min_pup 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_inj_fms_fac_cor
		"Adaptation gain of injected fuel mass flow setting"
		VALUE
		0x80044d96
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_utp_inj_fms_fac_cor 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_lih_val
		"CSF upstream temperature limp home value"
		VALUE
		0x8004587a
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_lih_val 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_max_thd
		"Maximum value for particulate filter upstream temperature"
		VALUE
		0x80040112
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_max_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_mv_min_thermal_dft
		"particulate filter upstream temperature avairage minimum value"
		VALUE
		0x80040110
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_mv_min_thermal_dft 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_ofs_sat_max
		"Maximum value for Offset"
		VALUE
		0x80043ba6
		RSA_RecordLayout_VALUE_UWORD
		2400
		RB_CONV_AtCatDgn_DegC_1200
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_ofs_sat_max 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_ofs_sat_min
		"Minimum value for Offset"
		VALUE
		0x80043ba4
		RSA_RecordLayout_VALUE_UWORD
		2400
		RB_CONV_AtCatDgn_DegC_1200
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_ofs_sat_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_pft_hot
		"Minimum threshold on upstream temperature for transition to the hot CSF state"
		VALUE
		0x80067f8c
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_pft_hot 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_reg_off_is_dly
		"Time delay for the deactivation of CSF upstream temperature regulator during idle speed"
		VALUE
		0x80045878
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_utp_reg_off_is_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_reg_off_is_n_thd
		"Minimum engine speed value which the engine is considered at idle speed"
		VALUE
		0x80045876
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pft_utp_reg_off_is_n_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_reg_off_thd
		"Threshold relative to CSF up temp regulation activation state for regulation deactivation"
		VALUE
		0x80045874
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pft_utp_reg_off_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_reg_off_utp_thd
		"CSF upstream temperature threshold value for CSF up tempe regulator deactivation"
		VALUE
		0x80045872
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_reg_off_utp_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_reg_on_thd
		"Threshold relative to CSF up temp regulation activation state for regulation activation"
		VALUE
		0x80045870
		RSA_RecordLayout_VALUE_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cxx_pft_utp_reg_on_thd 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_reg_on_utp_ftc
		"CSF upstream temperature filtering time constant to enable CSF up temp regulation"
		VALUE
		0x8004586e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_utp_reg_on_utp_ftc 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_reg_on_utp_thd
		"CSF upstream temperature threshold value for CSF up temp regulator activation"
		VALUE
		0x8004586c
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_reg_on_utp_thd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_rest_min
		"Minimum value of particle filter upstream temperature to activate start regeneration condition"
		VALUE
		0x80046b70
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_rest_min 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_rgn_err
		"Maximum threshold on upstream temperature for transition to regeneration failure state"
		VALUE
		0x80067f8a
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_rgn_err 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_rgn_err_hot
		"Maximum threshold on upstream temperature for transition to regeneration failure state with hot CSF"
		VALUE
		0x80067f88
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_rgn_err_hot 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_sens_err
		"Correction of CSF upstream temperature setpoint due to temperature sensor tolerance."
		VALUE
		0x800458f4
		RSA_RecordLayout_VALUE_SWORD
		2400
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_sens_err 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_thd_cold_cdn
		"Minimum upstream temperature threshold for cold conditions"
		VALUE
		0x800680e8
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_thd_cold_cdn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_thd_driv_cdn
		"Minimum upstream temperature threshold for driving conditions"
		VALUE
		0x800680e6
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_thd_driv_cdn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_thd_hot_cdn
		"Minimum upstream temperature threshold for hot conditions"
		VALUE
		0x800680e4
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_thd_hot_cdn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_thd_med_cdn
		"Minimum upstream temperature threshold for medium conditions"
		VALUE
		0x800680e2
		RSA_RecordLayout_VALUE_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cxx_pft_utp_thd_med_cdn 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_utp_wup_ol_cmd
		"Temporization between WU and OL when CSF utp sensor is defective"
		VALUE
		0x8004586a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_utp_wup_ol_cmd 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlvsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_vs_fil_t
		"Time constant for vehicle speed filtering"
		VALUE
		0x8006b220
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pft_vs_fil_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlvsxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_vs_ini
		"Initial value for CSF filtered vehicle speed"
		VALUE
		0x8006b21e
		RSA_RecordLayout_VALUE_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_pft_vs_ini 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_wait_mod_min_vh_dist
		"Vehicle distance threshold for the choice of waiting mode strategy"
		VALUE
		0x80046d0a
		RSA_RecordLayout_VALUE_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		0.
		1048560.
    DISPLAY_IDENTIFIER Cxx_pft_wait_mod_min_vh_dist 
    FORMAT "%7.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_wait_ms_ofs
		"Mass offset for waiting mode hysteresis."
		VALUE
		0x80046d08
		RSA_RecordLayout_VALUE_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_pft_wait_ms_ofs 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pft_wht
		"Particulate soot filter weight"
		VALUE
		0x8004693c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		tlquvwc_clelwCd_hCDzbFa_kCRa00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_pft_wht 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pn_pwst_min_is_n
		"Power steering accelerated idle speed (EGB in neutral mode or MGB)"
		VALUE
		0x8005ae6c
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_pn_pwst_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pos_reg_clos_req
		"a_as_maf_ctl_eitcaes_xxx_xx_d_a/Positive slope value in case of regular closing request"
		VALUE
		0x80062198
		RSA_RecordLayout_VALUE_ULONG
		65535
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pos_reg_clos_req 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_pos_slo_clos_req
		"a_as_maf_ctl_eitcaes_xxx_xx_d_a/Positive slope value in case of slow closing request"
		VALUE
		0x80062194
		RSA_RecordLayout_VALUE_ULONG
		65535
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_pos_slo_clos_req 
    FORMAT "%7.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_dly_bfr_resu
		"Turn off delay allowed to loose post injection conditions"
		VALUE
		0x80043b7d
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		RB_CONV_AtCatDgn_Time_01s
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_post_chk_dly_bfr_resu 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_gear_min
		"Minimum gear engaged to hold post injection active"
		VALUE
		0x80043b7e
		RSA_RecordLayout_VALUE_UBYTE
		7
		RB_CONV_AtCatDgn_Gear
		-1.
		6.
    DISPLAY_IDENTIFIER Cxx_post_chk_gear_min 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_n_h_thd_1
		"Upper limit on engine speed for the maximum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043bb2
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_post_chk_n_h_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_n_h_thd_2
		"Upper limit on engine speed for the minimum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043bb0
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_post_chk_n_h_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_n_l_thd_1
		"Lower limit on engine speed for the maximum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043bb6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_post_chk_n_l_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_n_l_thd_2
		"Lower limit on engine speed for the minimum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043bb4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_post_chk_n_l_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_tqi_h_thd_1
		"Upper limit on torque for the maximum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043bae
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_post_chk_tqi_h_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_tqi_h_thd_2
		"Upper limit on torque for the minimum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043bac
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_post_chk_tqi_h_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_tqi_l_thd_1
		"Lower limit on torque for the maximum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043baa
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_post_chk_tqi_l_thd_1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_post_chk_tqi_l_thd_2
		"Lower limit on torque for the minimum threshold of the hysteresis in post injection enabled conditions"
		VALUE
		0x80043ba8
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_post_chk_tqi_l_thd_2 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pow_apmp_hys
		"Cxx_pow_apmp_hys"
		VALUE
		0x8005926a
		RSA_RecordLayout_VALUE_SWORD
		655350
		VA_F_10_p0_17
		-327680
		327670
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pow_r_fil
		"Cxx_pow_r_fil"
		VALUE
		0x800597c6
		RSA_RecordLayout_VALUE_UBYTE
		10.2
		VA_F_0v04_p0_7
		0
		10.2
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_prmt_n_ac_dsb_dly
		"Maximum prolonged engine speed duration before AC compressor inhibition"
		VALUE
		0x8005ced8
		RSA_RecordLayout_VALUE_UBYTE
		25.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		25.5
    DISPLAY_IDENTIFIER Cxx_prmt_n_ac_dsb_dly 
    FORMAT "%4.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_prmt_n_ac_dsb_hys
		"Prolonged engine speed hysteresis of the AC compressor inhibition threshold"
		VALUE
		0x8005ced6
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_prmt_n_ac_dsb_hys 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_prmt_n_ac_dsb_thd
		"Maximum prolonged engine speed before AC compressor inhibition"
		VALUE
		0x8005ced4
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_prmt_n_ac_dsb_thd 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_prog_nr1
		"Software number (byte 0)"
		VALUE
		0x80056f73
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_prog_nr1 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_prog_nr2
		"Software number (byte 1)"
		VALUE
		0x80056f72
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_prog_nr2 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_prs_dft_min_is_n
		"Minimum after-sale idle speed setpoint"
		VALUE
		0x8005ade8
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_prs_dft_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_psh_meca_pow
		"Post heating mechanical power"
		VALUE
		0x8006b33e
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_psh_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ptc_min_is_n
		"PTC idle speed setpoint calibration"
		VALUE
		0x8005ae38
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_ptc_min_is_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ptq_ftc
		"Time constant of difference pressure filtering curve"
		VALUE
		0x800415e4
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_ptq_ftc 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ptq_max
		"Max value of the pumping torque"
		VALUE
		0x800415e2
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Cxx_ptq_max 
    FORMAT "%11.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pwst_is_acel_rtn_dly
		"Power steering accelerated idle speed prolongation duration"
		VALUE
		0x8005ae6a
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_pwst_is_acel_rtn_dly 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_lossxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_pwst_prs_tql
		"Torque loss from power steering"
		VALUE
		0x800415de
		RSA_RecordLayout_VALUE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cxx_pwst_prs_tql 
    FORMAT "%10.5" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rat_gear_stab_dly
		"Delay to identify the ratio stability"
		VALUE
		0x80058860
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_rat_gear_stab_dly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_raw_sens_tco_ini
		"Raw engine coolant temperature on init"
		VALUE
		0x80058438
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_raw_sens_tco_ini 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rbst_el_csm_dsb_gear_dly
		"Turnoff delay on gear condition in engine robustness strategy"
		VALUE
		0x8005cd90
		RSA_RecordLayout_VALUE_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cxx_rbst_el_csm_dsb_gear_dly 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rbst_el_csm_dsb_n
		"Engine speed threshold to request electrical consumers deactivation in engine robustness strategy"
		VALUE
		0x8005cd8e
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_rbst_el_csm_dsb_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rbst_el_csm_dsb_tco_hys
		"Engine coolant temperature hysteresis in engine robustness strategy"
		VALUE
		0x8005cd8c
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_rbst_el_csm_dsb_tco_hys 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rbst_el_csm_ena_n
		"Engine speed threshold to request electrical consumers reactivation in engine robustness strategy"
		VALUE
		0x8005cd8a
		RSA_RecordLayout_VALUE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cxx_rbst_el_csm_ena_n 
    FORMAT "%8.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_ref_max_pow
		"Reference max power for powertrain setpoint normalisation"
		VALUE
		0x800597d6
		RSA_RecordLayout_VALUE_UBYTE
		500000
		drbdAab_snynrtd_cpBhbcd_W__500a
		0.
		500000.
    DISPLAY_IDENTIFIER Cxx_ref_max_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rel_err_fil
		"Time constant of the first order filter on the relative error"
		VALUE
		0x80058aba
		RSA_RecordLayout_VALUE_UBYTE
		2550
		pCFAdab_ECDfnCb_dAegbrc_s_R01oa
		0.
		2550.
    DISPLAY_IDENTIFIER Cxx_rel_err_fil 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rel_err_thd_max
		"Maximal error of detection to avoid the errors due to the bends"
		VALUE
		0x80058ab8
		RSA_RecordLayout_VALUE_UWORD
		0.450002
		jkrACBa_BAgsrcb_zlhfntb_n_a824a
		0.
		0.450002
    DISPLAY_IDENTIFIER Cxx_rel_err_thd_max 
    FORMAT "%8.6" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rest_dspl_arw_down_dly
		"Cxx_rest_dspl_arw_down_dly"
		VALUE
		0x800592f6
		RSA_RecordLayout_VALUE_UWORD
		1310.7
		VA_F_0v02_p0_4
		0
		1310.7
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rest_dspl_arw_up_dly
		"Cxx_rest_dspl_arw_up_dly"
		VALUE
		0x800592f4
		RSA_RecordLayout_VALUE_UWORD
		1310.7
		VA_F_0v02_p0_4
		0
		1310.7
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_rgbepcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rgb_pump_act_dly
		"Delay before the authorization of the robotized gearbox pump activation."
		VALUE
		0x8006b34c
		RSA_RecordLayout_VALUE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cxx_rgb_pump_act_dly 
    FORMAT "%4.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxfs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rgb_pump_meca_pow
		"Robotized gearbox electro hydraulical pump mechanical power"
		VALUE
		0x8006b33c
		RSA_RecordLayout_VALUE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Cxx_rgb_pump_meca_pow 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rgn_dsb_max_t
		"Max time of regeneration forbidding"
		VALUE
		0x8006802e
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_rgn_dsb_max_t 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rps_bch_mod_val
		"Rail pressure during bench mode"
		VALUE
		0x80068efc
		RSA_RecordLayout_VALUE_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cxx_rps_bch_mod_val 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rps_cor_sp_pft_asd_rgn
		"Rail pressure set point during asd rgn"
		VALUE
		0x8004d1e6
		RSA_RecordLayout_VALUE_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cxx_rps_cor_sp_pft_asd_rgn 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rps_grd_prs_dec_prs
		"Maximal decrease gradient of rail pressure"
		VALUE
		0x80068efa
		RSA_RecordLayout_VALUE_UWORD
		4500
		ahqcwla_mcvrhmc_acrzCga_bp__a0a
		0.
		4500.
    DISPLAY_IDENTIFIER Cxx_rps_grd_prs_dec_prs 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rps_lim
		"Rail pressure limitation"
		VALUE
		0x80068ef8
		RSA_RecordLayout_VALUE_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cxx_rps_lim 
    FORMAT "%4.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_rsa_did_lim_val_cfm
		"Limit identifier of RSA DID part"
		VALUE
		0x80056f6a
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_rsa_did_lim_val_cfm 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_run_mdf1_off_tco_thd
		"Offset on Cxx_mdf_1_cmd_ena_thd_tco to deactivate mdf1 (engine running)."
		VALUE
		0x8006b094
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_run_mdf1_off_tco_thd 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_run_mdf1_off_tco_thd_h
		"Additive offset used to deactivate mdf1 on high temp. mode (engine running)."
		VALUE
		0x8006b092
		RSA_RecordLayout_VALUE_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cxx_run_mdf1_off_tco_thd_h 
    FORMAT "%5.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cxx_run_vh_min_is_n_dsb
		"Threshold composed to V/Neng ratio, which desables the running vehicle idle speed setpoint"
		VALUE
		0x800413fa
		RSA_RecordLayout_VALUE_SWORD
		210
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		-10.
		200.
    DISPLAY_IDENTIFIER Cxx_run_vh_min_is_n_dsb 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rup_lkg_fac_tol_thd
		"Factor to define the range of dynamic diagnosis for PFT relative upstream pressure"
		VALUE
		0x800580b4
		RSA_RecordLayout_VALUE_UWORD
		65535
		nCzokha_cokgekd_myezmBc_hisA_a0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_rup_lkg_fac_tol_thd 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rup_lkg_neg_thd
		"Negative threshold to define the range of the dynamic diag for volumic exhaust flow"
		VALUE
		0x800580b2
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		zACxkkc_ssivyfc_azzAlyb_kE__0a0
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_rup_lkg_neg_thd 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rup_lkg_pos_thd
		"Positive threshold to define the range of the dynamic diag for volumic exhaust flow"
		VALUE
		0x800580b0
		RSA_RecordLayout_VALUE_UWORD
		6.5535
		zACxkkc_ssivyfc_azzAlyb_kE__0a0
		0.
		6.5535
    DISPLAY_IDENTIFIER Cxx_rup_lkg_pos_thd 
    FORMAT "%6.4" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rup_lkg_rup_ftc
		"PFT relative upstream pressure filtering time constant"
		VALUE
		0x800580ae
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_rup_lkg_rup_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rup_lkg_sys_egaf_ftc
		"Exhaust gas flow filtering time constant"
		VALUE
		0x800580ac
		RSA_RecordLayout_VALUE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cxx_rup_lkg_sys_egaf_ftc 
    FORMAT "%6.1" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_amp_max
		"Maximum atmospheric pressure to allow learning"
		VALUE
		0x800580aa
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_rupc_amp_max 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_amp_min
		"Minimum atmospheric pressure to allow learning"
		VALUE
		0x800580a8
		RSA_RecordLayout_VALUE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cxx_rupc_amp_min 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_dif_max
		"Maximum correction for the PFT relative pressure"
		VALUE
		0x800580a6
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_rupc_dif_max 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cxx_rupc_dif_min
		"Minimum correction for the PFT relative pressure"
		VALUE
		0x800580a4
		RSA_RecordLayout_VALUE_SWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cxx_rupc_dif_min 
    FORMAT "%6.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
