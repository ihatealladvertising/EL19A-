/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_inj4.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b92
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_inj4 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568b8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ip_lght_tco[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ip_lght_tco[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568bc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ip_lght_tco[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568be
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ip_lght_tco[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568c0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ip_lght_tco[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ip_lght_tco.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568c2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ip_lght_tco 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b7c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_hbdg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b7e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_hbdg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b80
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_hbdg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b82
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_hbdg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b84
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_hbdg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_hbdg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b86
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_it_hbdg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b70
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_ofs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b72
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_ofs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b74
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_ofs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b76
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_ofs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b78
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_ofs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_ofs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b7a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_it_ofs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b64
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_reg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b66
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_reg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b68
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_reg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b6a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_reg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b6c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_it_reg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_it_reg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b6e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_it_reg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b58
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_maf_reg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b5a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_maf_reg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b5c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_maf_reg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b5e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_maf_reg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b60
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_maf_reg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_maf_reg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b62
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_maf_reg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b4c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_mafs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b4e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_mafs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b50
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_mafs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b52
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_mafs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b54
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_mafs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_mafs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b56
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_mafs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x8005696c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_map[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005696e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_map[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056970
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_map[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056972
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_map[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056974
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_map[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_map.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056976
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_map 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b40
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_oil_dil[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b42
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_oil_dil[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b44
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_oil_dil[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b46
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_oil_dil[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b48
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_oil_dil[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_oil_dil.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b4a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_oil_dil 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b34
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b36
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b38
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b3a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b3c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b3e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_pft 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b28
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_rgn[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b2a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_rgn[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b2c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_rgn[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b2e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_rgn[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b30
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_rgn[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_rgn.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b32
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_pft_rgn 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b1c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_utp[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b1e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_utp[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b20
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_utp[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b22
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_utp[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b24
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pft_utp[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pft_utp.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b26
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_pft_utp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b10
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_1[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b12
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_1[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b14
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_1[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b16
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_1[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b18
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_1[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_1.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b1a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_pws_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056b04
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_2[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056b06
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_2[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056b08
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_2[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056b0a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_2[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b0c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_2[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_2.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b0e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_pws_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056af8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_3[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056afa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_3[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056afc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_3[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056afe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_3[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056b00
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_pws_3[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_pws_3.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056b02
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_pws_3 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a14
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rail_prs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a16
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rail_prs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a18
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rail_prs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a1a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rail_prs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a1c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rail_prs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rail_prs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a1e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_rail_prs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568e8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rup[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568ea
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rup[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568ec
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rup[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568ee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rup[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568f0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_rup[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_rup.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568f2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_rup 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056aec
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_amp[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056aee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_amp[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056af0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_amp[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056af2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_amp[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056af4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_amp[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_amp.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056af6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_amp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800567ec
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_egr_temp[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800567ee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_egr_temp[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800567f0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_egr_temp[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800567f2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_egr_temp[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800567f4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_egr_temp[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_egr_temp.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800567f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_egr_temp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056ae0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_emtv[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056ae2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_emtv[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056ae4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_emtv[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056ae6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_emtv[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056ae8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_emtv[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_emtv.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056aea
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_emtv 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056ad4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ex_prs[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056ad6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ex_prs[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056ad8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ex_prs[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056ada
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ex_prs[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056adc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ex_prs[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ex_prs.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056ade
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_ex_prs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056ac8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_it[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056aca
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_it[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056acc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_it[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056ace
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_it[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056ad0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_it[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_it.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056ad2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_it 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056abc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_maf[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056abe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_maf[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056ac0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_maf[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056ac2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_maf[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056ac4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_maf[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_maf.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056ac6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_maf 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056ab0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_map[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056ab2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_map[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056ab4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_map[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056ab6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_map[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056ab8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_map[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_map.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056aba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_map 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568f4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_rup[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_rup[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568f8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_rup[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_rup[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568fc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_rup[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_rup.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_rup 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056aa4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tco[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056aa6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tco[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056aa8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tco[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056aaa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tco[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056aac
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tco[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tco.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056aae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_tco 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a98
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tia[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a9a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tia[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a9c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tia[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a9e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tia[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056aa0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_tia[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_tia.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056aa2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_tia 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056810
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_heat[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056812
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_heat[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056814
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_heat[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056816
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_heat[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056818
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_heat[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_heat.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005681a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_ups_heat 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x8005681c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_lamb[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005681e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_lamb[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056820
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_lamb[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056822
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_lamb[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056824
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_lamb[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_lamb.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056826
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_ups_lamb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056828
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_pump[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005682a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_pump[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x8005682c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_pump[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005682e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_pump[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056830
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_pump[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_pump.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056832
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_ups_pump 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056834
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_virt[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056836
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_virt[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056838
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_virt[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005683a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_virt[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x8005683c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_virt[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_virt.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005683e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_ups_virt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056840
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_wire[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056842
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_wire[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056844
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_wire[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056846
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_wire[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056848
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_ups_wire[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_ups_wire.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005684a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_ups_wire 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056960
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_wfl[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056962
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_wfl[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056964
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_wfl[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056966
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_wfl[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056968
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sens_wfl[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sens_wfl.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005696a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sens_wfl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568dc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sfty_tq[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568de
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sfty_tq[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568e0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sfty_tq[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568e2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sfty_tq[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568e4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_sfty_tq[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_sfty_tq.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568e6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_sfty_tq 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800567f8
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_cmd[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800567fa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_cmd[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800567fc
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_cmd[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800567fe
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_cmd[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056800
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_cmd[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_cmd.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056802
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_spg_cmd 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a8c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_reg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a8e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_reg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a90
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_reg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a92
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_reg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a94
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_spg_reg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_spg_reg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a96
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_spg_reg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x800568ac
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbf_fct[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x800568ae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbf_fct[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x800568b0
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbf_fct[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x800568b2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbf_fct[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x800568b4
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbf_fct[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbf_fct.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x800568b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_tbf_fct 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a80
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a82
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a84
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a86
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a88
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a8a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_tbt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a74
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt_reg[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a76
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt_reg[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a78
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt_reg[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a7a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt_reg[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a7c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tbt_reg[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tbt_reg.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a7e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_tbt_reg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a68
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd1[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a6a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd1[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a6c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd1[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a6e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd1[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a70
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd1[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd1.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a72
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_thpl_cmd1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a5c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd2[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a5e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd2[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a60
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd2[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a62
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd2[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a64
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd2[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd2.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a66
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_thpl_cmd2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a50
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd3[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a52
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd3[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a54
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd3[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a56
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd3[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a58
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_thpl_cmd3[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_thpl_cmd3.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a5a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_thpl_cmd3 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x8005687c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tqi_cor[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005687e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tqi_cor[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056880
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tqi_cor[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056882
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tqi_cor[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056884
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_tqi_cor[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_tqi_cor.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056886
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_tqi_cor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056954
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056956
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056958
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005695a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x8005695c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005695e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_unk_thpl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056948
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl1[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005694a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl1[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x8005694c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl1[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005694e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl1[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056950
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl1[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl1.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056952
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_unk_thpl1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x8005693c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl2[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005693e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl2[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056940
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl2[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056942
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl2[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056944
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl2[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl2.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056946
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_unk_thpl2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056930
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl3[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056932
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl3[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056934
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl3[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056936
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl3[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056938
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl3[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl3.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005693a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_unk_thpl3 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056924
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl4[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056926
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl4[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056928
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl4[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005692a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl4[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x8005692c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_unk_thpl4[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_unk_thpl4.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005692e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_unk_thpl4 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x8005684c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ecu[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005684e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ecu[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056850
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ecu[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056852
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ecu[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056854
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ecu[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ecu.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056856
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ups_ecu 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056870
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ro2[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056872
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ro2[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056874
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ro2[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056876
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ro2[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056878
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_ro2[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_ro2.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005687a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ups_ro2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056864
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_tip[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056866
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_tip[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056868
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_tip[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005686a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_tip[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x8005686c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_tip[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_tip.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x8005686e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ups_tip 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056858
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_uo2[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005685a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_uo2[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x8005685c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_uo2[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005685e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_uo2[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056860
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_ups_uo2[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_ups_uo2.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056862
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_ups_uo2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a44
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a46
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a48
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a4a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a4c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a4e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_vb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a38
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb_rly[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a3a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb_rly[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a3c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb_rly[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a3e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb_rly[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a40
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vb_rly[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vb_rly.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a42
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_vb_rly 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056a2c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vnt[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x80056a2e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vnt[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x80056a30
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vnt[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x80056a32
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vnt[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056a34
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_vnt[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_vnt.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056a36
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_vnt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[0]
		""
		VALUE
		0x80056918
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_wpmp_tcr[0] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[1]
		""
		VALUE
		0x8005691a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_wpmp_tcr[1] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[2]
		""
		VALUE
		0x8005691c
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_wpmp_tcr[2] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[3]
		""
		VALUE
		0x8005691e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_wpmp_tcr[3] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[4]
		""
		VALUE
		0x80056920
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Ctx_ffm_did_wpmp_tcr[4] 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Pxx_dgdftmng_dtc_wpmp_tcr.Cxx_dtc_hmb_xxx
		""
		VALUE
		0x80056922
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_hmb_wpmp_tcr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_03.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of FAN1 or its relay"
		VALUE
		0x80056f68
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_03 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_03.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of FAN1 and its relay"
		VALUE
		0x80056f54
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_03 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_03.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of FAN1 and its relay"
		VALUE
		0x80056f5a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_03 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_03.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of FAN1 and its relay"
		VALUE
		0x80056f58
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_03 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_03.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of FAN1 and its relay"
		VALUE
		0x80056f5e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_03 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_03.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of FAN1 and its relay"
		VALUE
		0x80056f56
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_03 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_03.Cxx_tac_ton_stac_xx
		"Activation time for a static test of FAN1 and its relay"
		VALUE
		0x80056f5c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_03 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_04.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of FAN2 or its relay"
		VALUE
		0x80056f50
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_04 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_04.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of FAN2 and its relay"
		VALUE
		0x80056f3c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_04 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_04.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of FAN2 and its relay"
		VALUE
		0x80056f42
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_04 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_04.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of FAN2 and its relay"
		VALUE
		0x80056f40
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_04 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_04.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of FAN2 and its relay"
		VALUE
		0x80056f46
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_04 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_04.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of FAN2 and its relay"
		VALUE
		0x80056f3e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_04 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_04.Cxx_tac_ton_stac_xx
		"Activation time for a static test of FAN2 and its relay"
		VALUE
		0x80056f44
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_04 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_05.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of electronic water pump for turbocharger cooling"
		VALUE
		0x80056f38
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_05 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_05.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of electronic water pump for turbocharger cooling"
		VALUE
		0x80056f24
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_05 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_05.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of electronic water pump for turbocharger cooling"
		VALUE
		0x80056f2a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_05 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_05.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of electronic water pump for turbocharger cooling"
		VALUE
		0x80056f28
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_05 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_05.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of electronic water pump for turbocharger cooling"
		VALUE
		0x80056f2e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_05 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_05.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of electronic water pump for turbocharger cooling"
		VALUE
		0x80056f26
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_05 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_05.Cxx_tac_ton_stac_xx
		"Activation time for a static test of electronic water pump for turbocharger cooling"
		VALUE
		0x80056f2c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_05 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of glow plug or its relay"
		VALUE
		0x80056f20
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_11 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of glow plug and its relay"
		VALUE
		0x80056f0c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_11 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of glow plug and its relay"
		VALUE
		0x80056f12
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_11 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of glow plug and its relay"
		VALUE
		0x80056f10
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_11 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of glow plug and its relay"
		VALUE
		0x80056f16
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_11 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of glow plug and its relay"
		VALUE
		0x80056f0e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_11 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_ton_stac_xx
		"Activation time for a static test of glow plug and its relay"
		VALUE
		0x80056f14
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_11 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of glow plug and its relay"
		VALUE
		0x80056f1a
		RSA_RecordLayout_VALUE_UWORD
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_11 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of glow plug and its relay"
		VALUE
		0x80056f1e
		RSA_RecordLayout_VALUE_UWORD
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_11 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of glow plug and its relay"
		VALUE
		0x80056f18
		RSA_RecordLayout_VALUE_UWORD
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_11 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_11.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of glow plug and its relay"
		VALUE
		0x80056f1c
		RSA_RecordLayout_VALUE_UWORD
		100
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		0.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_11 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of EGR flap"
		VALUE
		0x80056f08
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_12 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of EGR flap"
		VALUE
		0x80056ef4
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_12 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of EGR flap"
		VALUE
		0x80056efa
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_12 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of EGR flap"
		VALUE
		0x80056ef8
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_12 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of EGR flap"
		VALUE
		0x80056efe
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_12 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of EGR flap"
		VALUE
		0x80056ef6
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_12 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_ton_stac_xx
		"Activation time for a static test of EGR flap"
		VALUE
		0x80056efc
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_12 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of EGR flap"
		VALUE
		0x80056f02
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_12 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of EGR flap"
		VALUE
		0x80056f06
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_12 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of EGR flap"
		VALUE
		0x80056f00
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_12 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_12.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of EGR flap"
		VALUE
		0x80056f04
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_12 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of diesel intake air throttle"
		VALUE
		0x80056ef0
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_13 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of diesel intake air throttle"
		VALUE
		0x80056edc
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_13 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of diesel intake air throttle"
		VALUE
		0x80056ee2
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_13 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of diesel intake air throttle"
		VALUE
		0x80056ee0
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_13 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of diesel intake air throttle"
		VALUE
		0x80056ee6
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_13 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of diesel intake air throttle"
		VALUE
		0x80056ede
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_13 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_ton_stac_xx
		"Activation time for a static test of diesel intake air throttle"
		VALUE
		0x80056ee4
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_13 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of diesel intake air throttle"
		VALUE
		0x80056eea
		RSA_RecordLayout_VALUE_UWORD
		200
		ioDywdb_Admtpyb_jtsmfwc_fA_0a60
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_13 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of diesel intake air throttle"
		VALUE
		0x80056eee
		RSA_RecordLayout_VALUE_UWORD
		200
		ioDywdb_Admtpyb_jtsmfwc_fA_0a60
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_13 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of diesel intake air throttle"
		VALUE
		0x80056ee8
		RSA_RecordLayout_VALUE_UWORD
		200
		ioDywdb_Admtpyb_jtsmfwc_fA_0a60
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_13 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_13.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of diesel intake air throttle"
		VALUE
		0x80056eec
		RSA_RecordLayout_VALUE_UWORD
		200
		ioDywdb_Admtpyb_jtsmfwc_fA_0a60
		-100.
		100.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_13 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of EGR cooling bypass solenoid"
		VALUE
		0x80056ed8
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_14 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of EGR cooling bypass solenoid"
		VALUE
		0x80056ec4
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_14 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of EGR cooling bypass solenoid"
		VALUE
		0x80056eca
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_14 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of EGR cooling bypass solenoid"
		VALUE
		0x80056ec8
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_14 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of EGR cooling bypass solenoid"
		VALUE
		0x80056ece
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_14 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of EGR cooling bypass solenoid"
		VALUE
		0x80056ec6
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_14 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_ton_stac_xx
		"Activation time for a static test of EGR cooling bypass solenoid"
		VALUE
		0x80056ecc
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_14 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of EGR cooling bypass solenoid"
		VALUE
		0x80056ed2
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_14 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of EGR cooling bypass solenoid"
		VALUE
		0x80056ed6
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_14 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of EGR cooling bypass solenoid"
		VALUE
		0x80056ed0
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_14 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_14.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of EGR cooling bypass solenoid"
		VALUE
		0x80056ed4
		RSA_RecordLayout_VALUE_UWORD
		400
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		-200.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_14 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_17.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of 5th injector diesel dosing valve and its gavage pump"
		VALUE
		0x80056ec0
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_17 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_17.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of 5th injector diesel dosing valve and its gavage pump"
		VALUE
		0x80056eac
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_17 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_17.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of 5th injector diesel dosing valve and its gavage pump"
		VALUE
		0x80056eb2
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_17 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_17.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of 5th injector diesel dosing valve and its gavage pump"
		VALUE
		0x80056eb0
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_17 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_17.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of 5th injector diesel dosing valve and its gavage pump"
		VALUE
		0x80056eb6
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_17 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_17.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of 5th injector diesel dosing valve and its gavage pump"
		VALUE
		0x80056eae
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_17 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_17.Cxx_tac_ton_stac_xx
		"Activation time for a static test of 5th injector diesel dosing valve and its gavage pump"
		VALUE
		0x80056eb4
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_17 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of 5th injector"
		VALUE
		0x80056ea8
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_18 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of 5th injector"
		VALUE
		0x80056e94
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_18 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of 5th injector"
		VALUE
		0x80056e9a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_18 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_toff_io_xx
		"Deactivation time for an I/O control test of 5th injector"
		VALUE
		0x80056e98
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_18 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of 5th injector"
		VALUE
		0x80056e9e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_18 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of 5th injector"
		VALUE
		0x80056e96
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_18 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_ton_stac_xx
		"Activation time for a static test of 5th injector"
		VALUE
		0x80056e9c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_18 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of 5th injector"
		VALUE
		0x80056ea2
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_18 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of 5th injector"
		VALUE
		0x80056ea6
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_18 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of 5th injector"
		VALUE
		0x80056ea0
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_18 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_18.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of 5th injector"
		VALUE
		0x80056ea4
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_18 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of diesel turbocharger command valve"
		VALUE
		0x80056e90
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_26 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of diesel turbocharger command valve"
		VALUE
		0x80056e7c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_26 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of diesel turbocharger command valve"
		VALUE
		0x80056e82
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_26 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_toff_io_xx
		"Activation time for an I/O control test of diesel turbocharger command valve"
		VALUE
		0x80056e80
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_26 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of diesel turbocharger command valve"
		VALUE
		0x80056e86
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_26 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of diesel turbocharger command valve"
		VALUE
		0x80056e7e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_26 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_ton_stac_xx
		"Activation time for a static test of diesel turbocharger command valve"
		VALUE
		0x80056e84
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_26 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of diesel turbocharger command valve"
		VALUE
		0x80056e8a
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_26 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of diesel turbocharger command valve"
		VALUE
		0x80056e8e
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_26 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of diesel turbocharger command valve"
		VALUE
		0x80056e88
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_26 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_26.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of diesel turbocharger command valve"
		VALUE
		0x80056e8c
		RSA_RecordLayout_VALUE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_26 
    FORMAT "%6.2" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of thermoplunger relay 1"
		VALUE
		0x80056e78
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_41 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of thermoplunger relay 1"
		VALUE
		0x80056e64
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_41 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of thermoplunger relay 1"
		VALUE
		0x80056e6a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_41 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_toff_io_xx
		"Activation time for an I/O control test of thermoplunger relay 1"
		VALUE
		0x80056e68
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_41 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of thermoplunger relay 1"
		VALUE
		0x80056e6e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_41 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of thermoplunger relay 1"
		VALUE
		0x80056e66
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_41 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_ton_stac_xx
		"Activation time for a static test of thermoplunger relay 1"
		VALUE
		0x80056e6c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_41 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of thermoplunger relay 1"
		VALUE
		0x80056e72
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_41 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of thermoplunger relay 1"
		VALUE
		0x80056e76
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_41 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of thermoplunger relay 1"
		VALUE
		0x80056e70
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_41 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_41.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of thermoplunger relay 1"
		VALUE
		0x80056e74
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_41 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of thermoplunger relay 2"
		VALUE
		0x80056e60
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_42 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of thermoplunger relay 2"
		VALUE
		0x80056e4c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_42 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of thermoplunger relay 2"
		VALUE
		0x80056e52
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_42 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_toff_io_xx
		"Activation time for an I/O control test of thermoplunger relay 2"
		VALUE
		0x80056e50
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_42 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of thermoplunger relay 2"
		VALUE
		0x80056e56
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_42 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of thermoplunger relay 2"
		VALUE
		0x80056e4e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_42 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_ton_stac_xx
		"Activation time for a static test of thermoplunger relay 2"
		VALUE
		0x80056e54
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_42 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of thermoplunger relay 2"
		VALUE
		0x80056e5a
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_42 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of thermoplunger relay 2"
		VALUE
		0x80056e5e
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_42 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of thermoplunger relay 2"
		VALUE
		0x80056e58
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_42 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_42.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of thermoplunger relay 2"
		VALUE
		0x80056e5c
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_42 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_nc_io_xx
		"Number of cycles to complete the I/O control test of thermoplunger relay 3"
		VALUE
		0x80056e48
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_tac_nc_io_43 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_tini_io_xx
		"Initialization time for an I/O control test of thermoplunger relay 3"
		VALUE
		0x80056e34
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_io_43 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_tini_stac_xx
		"Initialization time for a static test of thermoplunger relay 3"
		VALUE
		0x80056e3a
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_tini_stac_43 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_toff_io_xx
		"Activation time for an I/O control test of thermoplunger relay 3"
		VALUE
		0x80056e38
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_io_43 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_toff_stac_xx
		"Deactivation time for a static test of thermoplunger relay 3"
		VALUE
		0x80056e3e
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_toff_stac_43 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_ton_io_xx
		"Activation time for an I/O control test of thermoplunger relay 3"
		VALUE
		0x80056e36
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_io_43 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_ton_stac_xx
		"Activation time for a static test of thermoplunger relay 3"
		VALUE
		0x80056e3c
		RSA_RecordLayout_VALUE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cxx_tac_ton_stac_43 
    FORMAT "%5.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_voff_io_xx
		"Lower substitution value for an I/O control test of thermoplunger relay 3"
		VALUE
		0x80056e42
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_voff_io_43 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_voff_stac_xx
		"Lower substitution value for the static test of thermoplunger relay 3"
		VALUE
		0x80056e46
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_voff_stac_43 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_von_io_xx
		"Higher substitution value for an I/O control test of thermoplunger relay 3"
		VALUE
		0x80056e40
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_von_io_43 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Tac_cal_set_43.Cxx_tac_von_stac_xx
		"Higher substitution value for the static test of thermoplunger relay 3"
		VALUE
		0x80056e44
		RSA_RecordLayout_VALUE_UWORD
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Cxx_tac_von_stac_43 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ac_prs_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800567e9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ac_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ac_prs_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800567e8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ac_prs_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ac_prs_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800567dd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ac_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ac_prs_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800567dc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ac_prs_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800567d1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800567ce
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x800567d2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800567d0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800567d0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800567d0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_1.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800567c5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_1.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800567c2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_1.Cxx_obd_dc_xxx
		""
		VALUE
		0x800567c6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_1.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800567c4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_1.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800567c4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_1.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800567c4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_2.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800567b9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_2.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800567b6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_2.Cxx_obd_dc_xxx
		""
		VALUE
		0x800567ba
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_2.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800567b8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_2.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800567b8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_secu_2.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800567b8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_tot.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800567ad
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_tot.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800567aa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_tot.Cxx_obd_dc_xxx
		""
		VALUE
		0x800567ae
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_tot.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800567ac
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_tot.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800567ac
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_tot.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800567ac
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800567a1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_v1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005679e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_v1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x800567a2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_v1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800567a0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_v1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800567a0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_v1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800567a0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_v1_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056795
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_v1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056792
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_v1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056796
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_v1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056794
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_v1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056794
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_v1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v1_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056794
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_v1_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056789
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_v2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056786
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_v2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005678a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_v2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056788
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_v2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056788
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_v2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056788
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_v2_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005677d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_acel_pdl_v2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005677a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_acel_pdl_v2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005677e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_acel_pdl_v2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005677c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_acel_pdl_v2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005677c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_acel_pdl_v2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_acel_pdl_v2_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005677c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_acel_pdl_v2_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056771
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_actr_rly_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005676e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_actr_rly_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056772
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_actr_rly_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056770
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_actr_rly_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056770
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_actr_rly_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056770
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_actr_rly_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056765
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_actr_rly_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056762
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_actr_rly_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056766
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_actr_rly_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056764
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_actr_rly_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056764
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_actr_rly_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056764
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_actr_rly_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056759
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_actr_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056756
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_actr_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005675a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_actr_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056758
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_actr_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056758
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_actr_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_actr_rly_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056758
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_actr_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005674d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_agb_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005674a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_agb_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005674e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_agb_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005674c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_agb_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005674c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_agb_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005674c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_agb_data_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_seq_ctr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056741
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_agb_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_seq_ctr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005673e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_agb_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_seq_ctr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056742
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_agb_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_seq_ctr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056740
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_agb_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_seq_ctr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056740
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_agb_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_seq_ctr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056740
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_agb_data_seq_ctr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_tout.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056735
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_agb_data_tout 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_tout.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056732
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_agb_data_tout 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_tout.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056736
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_agb_data_tout 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_tout.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056734
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_agb_data_tout 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_tout.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056734
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_agb_data_tout 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_data_tout.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056734
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_agb_data_tout 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_no_frm.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056729
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_agb_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_no_frm.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056726
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_agb_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_no_frm.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005672a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_agb_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_no_frm.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056728
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_agb_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_no_frm.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056728
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_agb_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_agb_no_frm.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056728
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_agb_no_frm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_amp_reg_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055da5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_amp_reg_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_amp_reg_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055da2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_amp_reg_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_amp_reg_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055da6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_amp_reg_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_amp_reg_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055da4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_amp_reg_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_amp_reg_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055da4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_amp_reg_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_amp_reg_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055da4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_amp_reg_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_bgin_clu_cmp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562f1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_bgin_clu_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_bgin_clu_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562f0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_bgin_clu_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_bgin_clu_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562e5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_bgin_clu_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_bgin_clu_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562e4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_bgin_clu_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_brk_pdl_cmp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562d9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_brk_pdl_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_brk_pdl_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562d8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_brk_pdl_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cata_nok_cge.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005671d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cata_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cata_nok_cge.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005671a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_cata_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cata_nok_cge.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005671e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_cata_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cata_nok_cge.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005671c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_cata_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cata_nok_cge.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005671c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_cata_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cata_nok_cge.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005671c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cata_nok_cge 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_clu_cnt_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056711
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_clu_cnt_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_clu_cnt_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056710
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_clu_cnt_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560e1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_crk_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800560de
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_crk_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x800560e2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_crk_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800560e0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_crk_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800560e0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_crk_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560e0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_crk_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cmp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e65
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cmp.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e62
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cmp.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e66
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cmp.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e64
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cmp.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e64
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e64
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_crk_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cyc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560d5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_crk_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cyc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800560d2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_crk_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cyc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800560d6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_crk_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cyc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800560d4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_crk_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cyc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800560d4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_crk_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_cyc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560d4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_crk_cyc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_no_sig.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ff1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_crk_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_no_sig.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055fee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_crk_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_no_sig.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ff2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_crk_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_no_sig.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ff0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_crk_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_no_sig.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ff0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_crk_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_no_sig.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ff0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_crk_no_sig 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e4d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_crk_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e4a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_crk_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e4e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_crk_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e4c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_crk_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e4c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_crk_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e4c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_crk_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_shp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e59
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_crk_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_shp.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e56
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_crk_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_shp.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e5a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_crk_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_shp.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e58
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_crk_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_shp.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e58
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_crk_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_crk_shp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e58
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_crk_shp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_cmp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562cd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cru_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562cc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cru_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_sl_swi_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562c1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cru_sl_swi_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_sl_swi_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562c0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cru_sl_swi_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_sl_tot.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562b5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cru_sl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_sl_tot.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562b4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cru_sl_tot 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_vs_cmp.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800562a9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cru_vs_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_vs_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800562a8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cru_vs_cmp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_whl_cmd_nok.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005629d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cru_whl_cmd_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_whl_cmd_nok.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005629c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cru_whl_cmd_nok 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_whl_cmd_oc_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056291
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_whl_cmd_oc_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056290
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_whl_cmd_oor.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056285
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_cru_whl_cmd_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_cru_whl_cmd_oor.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056284
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_cru_whl_cmd_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056705
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_doc1_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056702
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_doc1_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056706
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_doc1_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056704
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_doc1_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056704
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_doc1_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056704
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_doc1_utp_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566f9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_doc1_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_doc1_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566fa
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_doc1_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566f8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_doc1_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566f8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_doc1_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566f8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_doc1_utp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566ed
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_doc1_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566ea
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_doc1_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566ee
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_doc1_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566ec
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_doc1_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566ec
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_doc1_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_doc1_utp_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566ec
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_doc1_utp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_itl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055fe5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ecm_err_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_itl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055fe2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ecm_err_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_itl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055fe6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ecm_err_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_itl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055fe4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ecm_err_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_itl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055fe4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ecm_err_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_itl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055fe4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ecm_err_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_no_norm.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055db1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ecm_err_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_no_norm.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055dae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ecm_err_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_no_norm.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055db2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ecm_err_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055db0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ecm_err_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_no_norm.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055db0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ecm_err_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_err_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055db0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ecm_err_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_bus_mcut.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e35
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_bus_mcut.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e32
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_bus_mcut.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e36
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_bus_mcut.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e34
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_bus_mcut.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e34
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_bus_mcut.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e34
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_cpt_blk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055dc9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_cpt_blk.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055dc6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_cpt_blk.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055dca
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_cpt_blk.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055dc8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_cpt_blk.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055dc8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_cpt_blk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055dc8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_no_norm.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055dbd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ecm_inj_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_no_norm.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055dba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ecm_inj_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_no_norm.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055dbe
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ecm_inj_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055dbc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ecm_inj_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_no_norm.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055dbc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ecm_inj_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_inj_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055dbc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ecm_inj_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_1.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e29
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ecm_mon_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_1.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e26
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ecm_mon_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_1.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e2a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ecm_mon_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_1.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e28
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ecm_mon_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_1.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e28
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ecm_mon_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_1.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e28
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ecm_mon_secu_1 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_2.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e1d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ecm_mon_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_2.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e1a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ecm_mon_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_2.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e1e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ecm_mon_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_2.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e1c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ecm_mon_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_2.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e1c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ecm_mon_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ecm_mon_secu_2.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e1c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ecm_mon_secu_2 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566e1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_efi_inj_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566de
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_efi_inj_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566e2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_efi_inj_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566e0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_efi_inj_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566e0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_efi_inj_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566e0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_efi_inj_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566d5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_efi_inj_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566d2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_efi_inj_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566d6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_efi_inj_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566d4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_efi_inj_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566d4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_efi_inj_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566d4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_efi_inj_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566c9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_efi_inj_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566c6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_efi_inj_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566ca
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_efi_inj_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566c8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_efi_inj_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566c8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_efi_inj_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_inj_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566c8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_efi_inj_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056279
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_efi_sldv_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056276
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_efi_sldv_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005627a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_efi_sldv_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056278
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_efi_sldv_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056278
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_efi_sldv_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056278
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_efi_sldv_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005626d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_efi_sldv_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005626a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_efi_sldv_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005626e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_efi_sldv_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005626c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_efi_sldv_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005626c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_efi_sldv_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005626c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_efi_sldv_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056261
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_efi_sldv_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005625e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_efi_sldv_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056262
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_efi_sldv_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056260
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_efi_sldv_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056260
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_efi_sldv_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_efi_sldv_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056260
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_efi_sldv_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_blk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c91
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_egr_byp_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_blk.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055c8e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_egr_byp_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_blk.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055c92
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_egr_byp_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_blk.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055c90
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_egr_byp_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_blk.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055c90
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_egr_byp_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_blk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c90
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_egr_byp_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056099
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_egr_byp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056096
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_egr_byp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005609a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_egr_byp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056098
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_egr_byp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056098
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_egr_byp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056098
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_egr_byp_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005608d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_egr_byp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005608a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_egr_byp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005608e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_egr_byp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005608c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_egr_byp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005608c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_egr_byp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_egr_byp_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005608c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_egr_byp_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_flow_meca.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566bd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_emtv_flow_meca 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_flow_meca.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_emtv_flow_meca 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_flow_meca.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566be
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_emtv_flow_meca 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_flow_meca.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566bc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_emtv_flow_meca 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_flow_meca.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566bc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_emtv_flow_meca 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_flow_meca.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566bc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_emtv_flow_meca 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_el.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566b1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_emtv_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_el.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566ae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_emtv_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_el.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566b2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_emtv_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_el.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566b0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_emtv_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_el.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566b0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_emtv_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_el.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566b0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_emtv_hbdg_el 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_ovh.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800566a5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_emtv_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_ovh.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800566a2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_emtv_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_ovh.Cxx_obd_dc_xxx
		""
		VALUE
		0x800566a6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_emtv_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800566a4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_emtv_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_ovh.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800566a4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_emtv_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_hbdg_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800566a4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_emtv_hbdg_ovh 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_ofs_no_norm.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056699
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_emtv_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_ofs_no_norm.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056696
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_emtv_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_ofs_no_norm.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005669a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_emtv_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_ofs_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056698
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_emtv_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_ofs_no_norm.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056698
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_emtv_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_ofs_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056698
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_emtv_ofs_no_norm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005668d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_emtv_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005668a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_emtv_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005668e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_emtv_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005668c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_emtv_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005668c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_emtv_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005668c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_emtv_reg_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk_open.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056681
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_emtv_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk_open.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005667e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_emtv_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk_open.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056682
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_emtv_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056680
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_emtv_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk_open.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056680
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_emtv_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056680
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_emtv_reg_blk_open 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_dirt.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056675
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_emtv_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_dirt.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056672
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_emtv_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_dirt.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056676
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_emtv_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_dirt.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056674
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_emtv_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_emtv_reg_dirt.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056674
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_emtv_reg_dirt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
