    DISPLAY_IDENTIFIER Vbx_cf_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ed8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006edd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006eda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006edc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006edc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006edc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006edc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006edc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007004 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007009 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007006 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000700e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007010 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007015 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007012 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007014 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007014 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007014 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007014 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007014 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007016 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007018 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007021 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000701e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007020 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007020 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007020 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007020 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007020 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007022 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007027 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007024 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007026 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007026 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007026 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007026 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj4_shp.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007026 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000705e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007063 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007060 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007062 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007062 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007062 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007062 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_inj_oor.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007062 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007028 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006c9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ca8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006caa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006caf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cbb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007154 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007159 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007156 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007158 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007158 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007158 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007158 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007158 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000715e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000702e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007033 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007030 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007032 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007032 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007032 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007032 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_map_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007032 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007160 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007165 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007162 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007164 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007164 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007164 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007164 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007164 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ccd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_no_lk.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007076 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007078 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000707a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007166 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007168 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000716a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cdf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ceb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ce8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cf8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_1_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006cfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_2_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_pws_3_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006de8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006ded 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_rup_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_amp_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007148 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000714e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007153 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007150 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007152 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007152 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007152 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007152 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007152 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d27 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d33 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d39 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_it_nok.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_maf_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d51 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_map_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_rup_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d63 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_tia_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007112 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007117 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007114 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007116 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007116 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007116 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007116 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007116 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007118 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000711e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007123 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007120 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007122 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007122 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007122 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007122 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007122 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007124 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007129 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007126 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007128 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007128 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007128 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007128 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007128 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007111 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007110 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007110 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007110 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007110 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007110 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007106 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007108 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000710a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007100 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007105 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007102 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007104 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007104 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007104 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007104 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_virt_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007104 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_wire_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000712e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070ff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_ups_wire_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f31 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sens_wfl_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sfty_tq_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sfty_tq_clc_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007141 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000713e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007140 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007140 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007140 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007140 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sfty_tq_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007140 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_sfty_tq_supl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00070e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007142 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007147 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007144 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007146 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007146 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007146 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007146 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007146 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007034 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007039 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007036 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000703e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_chr.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d81 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_h.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d87 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_l.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tbt_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006f84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_tbt_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd1_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd1_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.Vxx_dfctr_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_dfctr_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.Vxx_dtc_stt_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_dtc_stt_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.Vxx_rdn_xxx
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rdn_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x01 
    DISPLAY_IDENTIFIER Vbx_cf_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_clf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vbx_clf_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_df_old_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Vbx_df_old_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Vbx_dfctr_sat_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x40 
    DISPLAY_IDENTIFIER Vbx_rdn_thpl_cmd2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
