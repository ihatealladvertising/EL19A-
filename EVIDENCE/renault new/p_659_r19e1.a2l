    DISPLAY_IDENTIFIER Vxx_emtv_psn_clos_pos_slop 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0004dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_cmd
		"Position sent to the regulator by the monitoring system, during open loop control."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_cmd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ed4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ctl
		"Ouput of the R Controller."
		SLONG
		ltvDhsb_dlbBqsd_CwvACca_n_7a150
		1
		100
		-100.
		99.9999999534339
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ctl 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ctl_0
		"Output of the first component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		3000.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ctl_0 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004a54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ctl_1
		"Output of the second component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		3000.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ctl_1 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004a58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ctl_2
		"Output of the third component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		3000.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ctl_2 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004a5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ctl_3
		"Output of the fourth component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		3000.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ctl_3 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004a60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_cutt
		"Abolute closed position value read, due to the cutting."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_cutt 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000eec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_err_2
		"Emtv position error (for OBD service 06)"
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_err_2 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0007664 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_lim_cutt
		"Range near the closed thrust to reduce the approach speed in the case of a cutting detection."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_lim_cutt 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000eee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_lim_down
		"Range near the closed thrust to activate the thrust approach strategy."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_lim_down 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ed6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_lim_down_1
		"Range near the closed thrust to activate the thrust approach strategy. Used by the mon. system."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_lim_down_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ef0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_lim_down_thd
		"Position threshold to activate the approach strategy near the closed thrust."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_lim_down_thd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_lim_up
		"Range near the open thrust to activate the thrust approach strategy."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_lim_up 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ed8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_lim_up_thd
		"Position threshold to activate the approach strategy near the open thrust."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_lim_up_thd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ofs_clos
		"Current value of the closed thrust position used by the regulation system."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ofs_clos 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000eda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ofs_down
		"Minimum value of the position setpoint (Position of the closed thrust)."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ofs_down 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000edc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ofs_lim_down_1
		"Value of the range near the thrust used by the monitoring system during the offset learning."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ofs_lim_down_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ef2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_ofs_up
		"Maximum value of the absolute position setpoint."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_ofs_up 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ede 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_raw_mv_tot
		"Sliding mean value of the raw position."
		UWORD
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_raw_mv_tot 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0000d48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_raw_stab
		"Value of the position used as a reference for the check of position stability."
		UWORD
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_raw_stab 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0000d4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_reg_1
		"Raw position used by the controller."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_reg_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_reg_2
		"Absolute position value given by the sensor after the measurement adaptation."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_reg_2 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_reg_3
		"Absolute position value given by the sensor after the dead zone filter."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_reg_3 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_rel
		"EMTV position relative to the closed thrust."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_rel 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_1
		"Position setpoint used by the monitoring system."
		UWORD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_1 
    FORMAT "%9.4" 
    ECU_ADDRESS 0xd0000ef4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_cho
		"Chosen value between mapped and computed value for the evp setpoint in maf regulation"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_cho 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_cmd
		"Position setpoint sent by the monitoring system."
		UWORD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_cmd 
    FORMAT "%9.4" 
    ECU_ADDRESS 0xd0000ee0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_cor
		"Absolute position setpoint used by the thrust approach strategy."
		UWORD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_cor 
    FORMAT "%9.4" 
    ECU_ADDRESS 0xd0000f2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_cor_1
		"Input of the position setpoint slope. Used during the thrust approach."
		UWORD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_cor_1 
    FORMAT "%9.4" 
    ECU_ADDRESS 0xd0000f30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_ctl
		"Output of the T Controller."
		SLONG
		ltvDhsb_dlbBqsd_CwvACca_n_7a150
		1
		100
		-100.
		99.9999999534339
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_ctl 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_ctl_0
		"Output of the first component of the T controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		3000.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_ctl_0 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004a68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_ctl_1
		"Output of the second component of the T controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		3000.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_ctl_1 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004a6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_ctl_2
		"Output of the third component of the T controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		3000.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_ctl_2 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004a70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_mod
		"Used to indicate if the position setpoint has to be modified by the thrust approach strategy."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		16.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_mod 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001d0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_pp
		"Egr valve position setpoint in pp mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_pp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00015d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_pr
		"Egr valve position setpoint in pr mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00015d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_pwl
		"Position Setpoint during Power Latch."
		UWORD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_pwl 
    FORMAT "%9.4" 
    ECU_ADDRESS 0xd0000ef6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_reg
		"Absolute position setpoint really given to the RST controller."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_reg 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_rij
		"Egr valve position setpoint in rij mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00015d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_psn_sp_slop
		"Position setpoint given by a slope system, when position and setpoint are near a thrust."
		UWORD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_emtv_psn_sp_slop 
    FORMAT "%9.4" 
    ECU_ADDRESS 0xd0000f34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_reg_h_thd
		"Maximal value for the error loop in the emtv regulation"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_reg_h_thd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_reg_l_thd
		"Minimal value for the error loop in the emtv regulation"
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_reg_l_thd 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000ec6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp
		"Value of the emtv position setpoint after overun switch"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_ecm
		"Value of the emtv position setpoint after failure mode switch"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_ecm 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_lim
		"Variable for EGR valve command after shut-off in rij, pr and pp modes"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_lim 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_max
		"Value of the position saturation threshold depending on the operating point and combustion mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000161c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_max_co
		"Position saturation threshold consolidated value function of operating point and combustion mode"
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_max_co 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000158a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_max_pp
		"Value of the position saturation threshold depending on the operating point in pp mode"
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_max_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001592 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_max_pr
		"Value of the position saturation threshold depending on the operating point in pr mode"
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_max_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000159a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_max_rij
		"Value of the position saturation threshold depending on the operating point in rij mode"
		UWORD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_max_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asspvcoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asspvcoo_econpux_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_on_off
		"Egr valve position setpoint after closing position"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_on_off 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000168a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asspvcoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asspvcoo_econpux_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_on_off_ecm
		"Egr valve position setpoint after closing position and before Monitool bypass"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_on_off_ecm 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000168c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_sp_on_off_sat_1
		"Temporary variable for Emtv setpoint before slope switch"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_emtv_sp_on_off_sat_1 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_t_pwl
		"Timer delay of the PWL mode."
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_emtv_t_pwl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000ef8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_lim_down
		"Minimum value of the emtv command voltage."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_emtv_v_lim_down 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000ee2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_lim_down_1
		"Value of the low voltage limitation used by the monitoring system."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_emtv_v_lim_down_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000efa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_lim_up
		"Maximum value of the emtv command voltage."
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_emtv_v_lim_up 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000ee4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_lim_up_1
		"Value of the high voltage limitation used by the monitoring system."
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_emtv_v_lim_up_1 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000efc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_ofs_lim_down
		"Maximum negative voltage command during the closing of the component."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_emtv_v_ofs_lim_down 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000efe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_sp
		"Voltage setpoint given by the RST regulator and sent to the component."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_emtv_v_sp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000f36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_sp_cmd
		"Voltage setpoint for open loop control. Value sent to the H bridge."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_emtv_v_sp_cmd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000ee6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_emtv_v_sp_cor_lim
		"Voltage setpoint given to the H bridge."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_emtv_v_sp_cor_lim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000f1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ena_cut_n_ofs
		"enable cut engine offset"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_ena_cut_n_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00009fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_eng_ac_min_is_n
		"Air conditioning minimum idle speed for engine needs"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_eng_ac_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007772 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_synchro_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_eng_angl
		"Angular position of engine"
		UWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		0.
		719.98
    DISPLAY_IDENTIFIER Vxx_eng_angl 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_eng_run_ena_swlk
		"Engine running authorisation dependent on the anti theft strategy"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_eng_run_ena_swlk 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiesi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiesi_mngtxcs_data.c' */
/begin MEASUREMENT
		Vxx_eng_stop_req_ccu
		"Emergency engine stop request"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_eng_stop_req_ccu 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiesi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiesi_mngtxcs_data.c' */
/begin MEASUREMENT
		Vxx_eng_stop_req_rgb
		"Engine stop requested by robotized gearbox"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_eng_stop_req_rgb 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cdd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiesi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiesi_mngtxcs_data.c' */
/begin MEASUREMENT
		Vxx_eng_stop_req_ssg
		"Engine stop requested by SSG"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_eng_stop_req_ssg 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_lossxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_eng_tql
		"Engine torque losses"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_eng_tql 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_esd_did_nr
		"RSA_API_ExtendedSnapshotData number of DID to store"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_esd_did_nr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000227f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_esd_ind
		"RSA_API_ExtendedSnapshotData calling diagnosis identifier"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_esd_ind 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_esd_ind_ini
		"Current initial index to save requested data"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_esd_ind_ini 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002280 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_esd_ind_max
		"Initial index of free space in Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_esd_ind_max 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002281 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_esd_siz
		"Requested extended snapshot size in bytes to be saved"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_esd_siz 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002282 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_esti_icmaf_kgh
		"The estimated air mass flow without EGR"
		UWORD
		bCkDtxb_iBmhrgb_vDEgpCc_khA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_esti_icmaf_kgh 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000755c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_esti_tqe
		"Estimated effective engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_esti_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_esti_tqi
		"Estimated indicate engine torque"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_esti_tqi 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs
		"Exhaust manifold pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000db4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_cho
		"Exhaust manifold pressure chosen for exhaust limitation pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_cho 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000a66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_amp_bas_sp_pr
		"Atmospheric pressure corrected exhaust pressure setpoint in pft regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_amp_bas_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007810 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_amp_bas_sp_rij
		"Atmospheric pressure corrected exhaust pressure setpoint in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_amp_bas_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007824 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_amp_tkof_sp_pr
		"Atmospheric pressure corrected exhaust pressure setpoint for take off assistance in pft regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_amp_tkof_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007812 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_amp_tkof_sp_rij
		"Atmospheric pressure corrected exhaust pressure setpoint for take off assistance in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_amp_tkof_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007826 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_bas_sp_pr
		"Exhaust manifold setpoint pressure before air temp and atm. pressure correction in pft regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_bas_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007814 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_bas_sp_rij
		"Exhaust manifold setpoint pressure before air temp and atm. pressure correction in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_bas_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007828 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_cor_sp_pr
		"Exhaust pressure setpoint corrected for atmospheric pressure and intake air temperature in pft regeneration mode."
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_cor_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007816 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_cor_sp_rij
		"Exhaust pressure setpoint corrected for atmospheric pressure and intake air temperature in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_cor_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000782a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_max_sp
		"Maximum exhaust pressure setpoint."
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_max_sp 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000a6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_max_sp_pr
		"Maximum exhaust pressure setpoint in pft regeneration mode."
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_max_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001544 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_max_sp_rij
		"Maximum exhaust pressure setpoint in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_max_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007836 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_pft_cor_sp_pr
		"Exhaust pressure setpoint corrected for amp, tia and particule filter upstream pressure in pft regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_pft_cor_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007818 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_pft_cor_sp_rij
		"Exhaust pressure setpoint corrected for amp, tia and particule filter upstream pressure in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_pft_cor_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000782c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_sp
		"Exhaust pressure setpoint without limp home"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_sp 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000a6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_sp_pr
		"Exhaust manifold setpoint pressure in pft regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007822 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_sp_rij
		"Exhaust manifold setpoint pressure in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007838 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_tia_cor_pr
		"Basic intake air temperature correction of exhaust pressure setpoint in pft regeneration mode"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_tia_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000781a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_tia_cor_rij
		"Basic intake air temperature correction of exhaust pressure setpoint in regular injection mode"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_tia_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000782e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_tia_tkof_pr
		"Basic intake air temperature correction of exhaust pressure setpoint for take off assistance in pft regeneration mode"
		SWORD
		bFvxscc_Ayimzfb_CwzqyDc_Ba__a0a
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_tia_tkof_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000781c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_tia_tkof_rij
		"Basic intake air temperature correction of exhaust pressure setpoint for take off assistance in regular injection mode"
		SWORD
		bFvxscc_Ayimzfb_CwzqyDc_Ba__a0a
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_tia_tkof_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007830 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_tkof_sp_pr
		"Exhaust pressure setpoint for take off assistance in pft regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_tkof_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000781e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_lim_tkof_sp_rij
		"Exhaust pressure setpoint for take off assistance in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_lim_tkof_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007832 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_prs_sp
		"Exhaust manifold setpoint pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_ex_prs_sp 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000a68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ex_reg_apl_down
		"Negative exhaust pressure deviation diagnostic criteria"
		UWORD
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_ex_reg_apl_down 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001350 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_engsftx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ext_ctrl_eng_test_sf
		"External controls denial engine status flags"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ext_ctrl_eng_test_sf 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001954 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monisft_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ext_ctrl_test_sf
		"External controls denial status flags"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ext_ctrl_test_sf 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007550 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fac_dist_ms_1
		"Factor_dist_thresh_hot* (100% of distance and fac of  soot mass (hot conditions))"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_fac_dist_ms_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006638 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fac_dist_ms_2
		"Factor_dist_thresh_cold*(100% of soot mass and fac of distance (cold conditions))"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_fac_dist_ms_2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000663a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fac_dist_ms_4
		"Factor_dist_thresh_pas*(100% of soot mass and fac of distance (medium thermal rgn conditions))"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_fac_dist_ms_4 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000663c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fac_ms_dist_1
		"Factor_dist_thres_hot*(100% of soot mass and fac of distance (hot conditions))"
		UWORD
		cDnjuxa_imylsBc_FdEgbrc_kC_0ooa
		1
		100
		0.
		300000.
    DISPLAY_IDENTIFIER Vxx_fac_ms_dist_1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000663e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fac_ms_dist_2
		"Factor_dist_thres_cold*(100% of soot mass and fac of distance (cold conditions))"
		UWORD
		cDnjuxa_imylsBc_FdEgbrc_kC_0ooa
		1
		100
		0.
		300000.
    DISPLAY_IDENTIFIER Vxx_fac_ms_dist_2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006640 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fac_ms_dist_4
		"Factor_dist_thres_cold*(100% of soot mass and fac of distance (med thermal rgn conditions))"
		UWORD
		cDnjuxa_imylsBc_FdEgbrc_kC_0ooa
		1
		100
		0.
		300000.
    DISPLAY_IDENTIFIER Vxx_fac_ms_dist_4 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006642 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_driv_spt_fac
		"Driver sportivity factor given by 'fast' adaptation algorithm"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_fast_driv_spt_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002353 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_off_dly
		"Vxx_fast_off_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002360 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_off_gear_sel
		"Vxx_fast_off_gear_sel"
		UBYTE
		VA_F_1_m1_24
		2
		100
		-1
		254
    ECU_ADDRESS 0xd0001d9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_off_gear_sel_bk
		"Vxx_fast_off_gear_sel_bk"
		UBYTE
		VA_F_1_m1_24
		2
		100
		-1
		254
    ECU_ADDRESS 0xd0001d95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_off_kd_n_thd
		"Vxx_fast_off_kd_n_thd"
		UWORD
		VA_F_0v25_p0_7
		2
		100
		0
		16383.75
    ECU_ADDRESS 0xd0007732 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_off_max_dly
		"Vxx_fast_off_max_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002361 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_off_no_pdl_dly
		"Vxx_fast_off_no_pdl_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002362 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fast_on_gear_sel
		"Vxx_fast_on_gear_sel"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001d9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fil_alt_pow
		"Filtered alternator mechanical power"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_fil_alt_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000e62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_fil_alt_pow_load_trs
		"Alternator filtered power used for transitional detection"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_fil_alt_pow_load_trs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000765a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fim_sum_mux_dies[0]
		"Vector of diesel consumption for the mux [total, Nominal]"
		ULONG
		zdbvomb_zEuFced_rjyApva_mt__5a0
		1
		100
		0.
		600.
    DISPLAY_IDENTIFIER Vxx_fim_sum_mux_dies_0_ 
    FORMAT "%9.5" 
    ECU_ADDRESS 0xd0004ad0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fim_sum_mux_dies[1]
		"Vector of diesel consumption for the mux [total, Nominal]"
		ULONG
		zdbvomb_zEuFced_rjyApva_mt__5a0
		1
		100
		0.
		600.
    DISPLAY_IDENTIFIER Vxx_fim_sum_mux_dies_1_ 
    FORMAT "%9.5" 
    ECU_ADDRESS 0xd0004ad4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fim_sum_mux_dies_PREV[0]
		"Previous value: vector of diesel consumption for the mux [total, Nominal]"
		ULONG
		zdbvomb_zEuFced_rjyApva_mt__5a0
		1
		100
		0.
		600.
    DISPLAY_IDENTIFIER Vxx_fim_sum_mux_dies_PREV_0_ 
    FORMAT "%9.5" 
    ECU_ADDRESS 0xd0004ad8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fim_sum_mux_dies_PREV[1]
		"Previous value: vector of diesel consumption for the mux [total, Nominal]"
		ULONG
		zdbvomb_zEuFced_rjyApva_mt__5a0
		1
		100
		0.
		600.
    DISPLAY_IDENTIFIER Vxx_fim_sum_mux_dies_PREV_1_ 
    FORMAT "%9.5" 
    ECU_ADDRESS 0xd0004adc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_flp_max_pr
		"Maximum Final quantity of late post injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_flp_max_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00063f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_flp_min_pr
		"Minimum Final quantity of late post injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_flp_min_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00063f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv
		"Main injection advance"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_amp_cor_pr
		"Atmospheric pressure correction for main advance during pr"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_amp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000183c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_amp_fac_pr
		"Slow process of atmospheric pressure factor's correction for main advance during pr"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_adv_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007aa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_amp_tco_cor_rij
		"Atmospheric pressure correction for main advance"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_amp_tco_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_amp_tco_fac_rij
		"Slow process of atmospheric pressure factor's correction for main advance"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_adv_amp_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006724 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_aut_eng_cor_rij
		"Correction of autnomous engine correction for main advance during rij"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_aut_eng_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_aut_eng_fac_rij
		"Factor of autnomous engine correction for main advance"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_adv_aut_eng_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006726 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_aut_eng_t
		"Timer of autnomous engine correction for main advance"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_fms_adv_aut_eng_t 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000c6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_cold_tco_rij
		"main advance for cold coolant temperature"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_cold_tco_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_cor_pr
		"correction for main advance during pr"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000183e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_cor_rij
		"correction for main advance"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_cor_spc_pr
		"Specific correction for main advance during pr"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_cor_spc_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001840 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_dp_map_cor_rij
		"Delta mass air pressure pressure correction for main advance during rij"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_dp_map_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_dp_rps_cor_pr
		"Delta rail pressure correction for main advance during pr"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_dp_rps_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001842 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_dp_rps_cor_rij
		"Delta rail pressure pressure correction for main advance during rij"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_dp_rps_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_gear_rij
		"Correction of main advance set point with specific gearbox ratio."
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_gear_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_ms_dp_cor_pr
		"Particulate filter mass soot correction for main advance during pr"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_ms_dp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001844 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_mv_tco_rij
		"main advance for medium coolant temperature"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_mv_tco_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_spc_cor_rij
		"Specific correction for main advance"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_spc_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_tco_cor_pr
		"Coolant temperature correction for main advance during pr"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_tco_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001846 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_tco_fac_pr
		"Coolant temperature factor for interpollation 3D during pr"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_adv_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007aaa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_tco_fac_rij
		"Coolant temperature factor for interpollation 3D"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_adv_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006728 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_tia_cor_pr
		"Intake air temperature correction for main advance"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_tia_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001848 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_tia_fac_pr
		"Slow process of intake air temperature factor's correction for main advance during pr"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_adv_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007aac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_tia_tco_cor_rij
		"Intake air temperature correction for main advance"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_adv_tia_tco_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_adv_tia_tco_fac_rij
		"Slow process of intake air temperature factor's correction for main advance"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_adv_tia_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd000672a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_aftr_efy
		"After injection efficiency ratio"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_aftr_efy 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001796 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_amp_fac_pr
		"Factor of atmospheric pressure correction for quantity of global injection during pft rgn"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00063f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_angl_dif_nxt_cyl_lpos
		"Angle between TDCs of two consecutive cylinders, which use the same electronic bench of ECU"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_angl_dif_nxt_cyl_lpos 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_angl_dif_nxt_cyl_lpos2
		"Angle between TDCs of two consecutive cylinders, which use the same electronic bench of ECU"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_angl_dif_nxt_cyl_lpos2 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_adv_pr
		"Basic main advance during pr"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_bas_adv_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001838 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_adv_rij
		"basic advance of main injection in rij mode"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_bas_adv_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_faf_rij
		"Basic quantity of after injection during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_bas_faf_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_fp1_pr
		"Basic quantity of pre-injection 1 during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_bas_fp1_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_fp1_rij
		"Basic quantity of pre-injection 1 during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_bas_fp1_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_fp2_pr
		"Basic quantity of pre-injection 2 during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_bas_fp2_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000ba8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_fp2_rij
		"Basic quantity of pre-injection 2 during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_bas_fp2_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_fpo_pr
		"Basic quantity of post injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_bas_fpo_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_taf_rij
		"Basic separation of after injection during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_bas_taf_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007a96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_tlp_pr
		"Basic angle of late post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_bas_tlp_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_tp1_pr
		"Basic separation of pre-injection 1 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_bas_tp1_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006732 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_tp1_rij
		"Basic separation of pre-injection 1 during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_bas_tp1_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_tp2_pr
		"Basic separation of pre-injection 2 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_bas_tp2_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006748 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_tp2_rij
		"Basic separation of pre-injection 2 during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_bas_tp2_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000ca8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_bas_tpo_pr
		"Basic angle of post injection in pr mode"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_bas_tpo_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000cc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_comb_mod_swi_t
		"Duration of the combustion mode transitions for injection"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_fms_comb_mod_swi_t 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000c10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_adv_npu
		"main advance set point during regular injection during npu"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_adv_npu 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0006758 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_adv_pr
		"main advance set point during regular injection during pr"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_adv_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000183a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_adv_rij
		"main advance set point during regular injection"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_adv_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_adv_spu
		"main advance set point during regular injection during spu"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_adv_spu 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000675a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_adv_sta
		"main advance set point during Starting Combustion Mode"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_adv_sta 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000184a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_faf_npu
		"Corrected quantity of after injection during nox purge"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_faf_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_faf_rij
		"Corrected quantity of after injection during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_faf_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_faf_spu
		"Corrected quantity of after injection during sox purge"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_faf_spu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_flp_ocd
		"Corrected quantity of late post injection during ocd"
		UWORD
		RB_CONV_AtCatDgn_1_100_mg_strk
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_flp_ocd 
    ECU_ADDRESS 0xd00063de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_flp_pr
		"Corrected quantity of late post injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_flp_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp1_npu
		"Corrected quantity of pre injection 1 during nox purge"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp1_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp1_pr
		"Corrected quantity of pre injection 1 during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp1_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp1_rij
		"Corrected quantity of pre-injection 1 during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp1_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp1_spu
		"Corrected quantity of pre injection 1 during sox purge"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp1_spu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp1_sta
		"Corrected quantity of pre-injection 1 during Starting Combustion Mode"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp1_sta 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000179c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp2_npu
		"Corrected quantity of pre-injection 2 during nox purge"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp2_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp2_pr
		"Corrected quantity of pre-injection2 during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp2_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp2_rij
		"Corrected quantity of pre-injection 2 during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp2_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp2_spu
		"Corrected quantity of pre-injection2 during sox purge"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp2_spu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000be0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fp2_sta
		"Corrected quantity of pre-injection 2 during Starting Combustion Mode"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fp2_sta 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000179e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fpo_npu
		"Corrected quantity of post injection during start regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fpo_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fpo_pr
		"Corrected quantity of post injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fpo_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_fpo_spu
		"Corrected quantity of post injection during sox regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_fpo_spu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000be4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_pr
		"Environmental correction for quantity of global injection during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_cor_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00063fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_taf_npu
		"Corrected separation of after injection during nox purge"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_taf_npu 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000675c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_taf_rij
		"Corrected separation of after injection during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_taf_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007a94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_taf_spu
		"Corrected separation of after injection during sox purge"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_taf_spu 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000675e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tlp_ocd
		"Corrected angle of late post injection during ocd"
		UWORD
		RB_CONV_AtCatDgn_002_deg_Crk
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tlp_ocd 
    ECU_ADDRESS 0xd00063e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tlp_pr
		"Corrected angle of late post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tlp_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp1_npu
		"Corrected separation of pre injection 1 during nox purge"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp1_npu 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006760 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp1_pr
		"Corrected separation of pre injection 1 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp1_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006730 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp1_rij
		"Corrected separation of pre-injection 1 during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp1_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp1_spu
		"Corrected separation of pre injection 1 during sox purge"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp1_spu 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006762 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp1_sta
		"Corrected separation of pre-injection 1 during Starting Combustion Mode"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp1_sta 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000185a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp2_npu
		"Corrected separation of pre-injection 2 during nox purge"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp2_npu 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006764 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp2_pr
		"Corrected separation of pre-injection2 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp2_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006746 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp2_rij
		"Corrected separation of pre-injection 2 during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp2_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000ca6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp2_spu
		"Corrected separation of pre-injection2 during sox purge"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp2_spu 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006766 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tp2_sta
		"Corrected separation of pre-injection 2 during Starting Combustion Mode"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tp2_sta 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000185c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tpo_npu
		"Corrected angle of post injection during start regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tpo_npu 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0006768 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tpo_pr
		"Corrected angle of post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tpo_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000cc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_cor_tpo_spu
		"Corrected angle of post injection during sox regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_cor_tpo_spu 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000676a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_dif_post
		"post injection absolute separation relative to end of previous injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_dif_post 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_efi_flp_cor
		"Mass Flow Global Injection corrected during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_efi_flp_cor 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_efi_maf_err_fil
		"Filtered mass air flow error"
		UWORD
		tClffab_hirDflc_mxtqjrd_mtA_o00
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_fms_efi_maf_err_fil 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00063fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_efi_max_pr
		"Maximum quantity of exhaust fuel injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_efi_max_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_efi_min_pr
		"Minimum quantity of exhaust fuel injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_efi_min_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_main_aftr
		"Estimation of main fuel quantity at main step"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_esti_main_aftr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000173c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_main_post
		"Estimation of main fuel flow after post limited fuel flow"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_esti_main_post 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000175a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_main_wio_aftr
		"Estimation of main fuel quantity at main step without taking in account the after fuel flow"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_esti_main_wio_aftr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001746 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_main_wio_post
		"Estimation of main fuel flow at post step without post fuel flow contribution"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_esti_main_wio_post 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001766 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_aftr
		"estimation of after injection duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_aftr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000173e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_lpos
		"estimation of late post injection duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_lpos 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000b5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_lpos1
		"estimation of late post injection 1 duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_lpos1 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000b60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_lpos1_angl
		"Angle estimation of late post injection 1 duration"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_lpos1_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_lpos2
		"estimation of late post injection 2 duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_lpos2 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000b62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_lpos2_angl
		"Angle estimation of late post injection 2 duration"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_lpos2_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_lpos_angl
		"Angle estimation of late post injection duration"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_lpos_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_main
		"estimation of main injection duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_main 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000b70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_pinj1
		"estimation of pre-injection 1 duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_pinj1 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001752 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_pinj2
		"estimation of pre-injection 2 duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_pinj2 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000b76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_post
		"estimation of post injection duration"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_post 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000175c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_wish_main_aftr
		"estimation of main duration at after injection quantity step"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_wish_main_aftr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001740 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_ti_wish_main_post
		"estimation of main duration at post injection quantity step"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_fms_esti_ti_wish_main_post 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000175e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_wish_main_aftr
		"Estimated quantity of main injection at after injection step"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_esti_wish_main_aftr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001748 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_esti_wish_main_post
		"Estimated quantity of main injection at post injection step"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_esti_wish_main_post 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001760 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf
		"After injection quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_faf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001742 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_amp_cor_rij
		"Atmospheric pressure correction for quantity of after injection during regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_faf_amp_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0007a5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_amp_fac_rij
		"Atmospheric pressure correction for quantity of after injection during refular injection"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_faf_amp_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007a5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_cold_tco_rij
		"Quantity of after injection for cold coolant temperature during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_faf_cold_tco_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_cor_rij
		"Correction for quantity of after injection during regular injection"
		UWORD
		fmmmApb_sBgvABb_isuEced_mtA0000
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_faf_cor_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007a60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_mv_tco_rij
		"Quantity of after injection for medium coolant temperature during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_faf_mv_tco_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_tco_fac_rij
		"Factor of coolant temperature correction for quantity of after injection during regular injection"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_faf_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007a64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_tia_cor_rij
		"Intake air temperature correction for quantity of after injection during regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_faf_tia_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0007a66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_faf_tia_fac_rij
		"Factor of intake air temperature correction for quantity of after injection during regular injection"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_faf_tia_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007a68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_bfr_lpos
		"Fuel flow of the injection before the late post injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_bfr_lpos 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00017d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_bfr_post
		"Fuel flow of the injection before the post injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_bfr_post 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000c4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_cyl_comb
		"fuel consumption, sum of fuel mass burn on the cylinder, pinj1, pinj2, main, after, post"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_cyl_comb 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001028 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_cyl_tot
		"fuel consumption, sum of fuel mass injecte on the cylinder, pinj1, pinj2, main, after, post, late post"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_cyl_tot 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000102a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_main
		"Main injection quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_main 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_aftr
		"Minimal fuel quantity for after injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_aftr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000174a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_lpost
		"Minimal injectable quantity for late post"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_lpost 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_lpost1
		"Minimal injectable quantity for late post 1"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_lpost1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_lpost2
		"Minimal injectable quantity for late post 2"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_lpost2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_main
		"Minimal injectable quantity for main injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_main 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_pinj1
		"Minimal fuel quantity for pre - injection 1"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_pinj1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001758 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_pinj2
		"Minimal fuel quantity for pre - injection 2"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_pinj2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_min_post
		"Minimal fuel quantity for post injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_min_post 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001768 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucbofuo_adacxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_tot
		"Total injection quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_tot 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001022 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mxiflxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fim_tot_max
		"Maximum flow provided by the system"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fim_tot_max 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001304 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_flp
		"Late post injection quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_flp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_flp1
		"Late post injection 1 quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_flp1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_flp2
		"Late post injection 2 quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_flp2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_flp_maf_err_fil
		"Filtered mass air flow error"
		UWORD
		tClffab_hirDflc_mxtqjrd_mtA_o00
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_fms_flp_maf_err_fil 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00063fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_flp_max_pr
		"Maximum quantity of late post injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_flp_max_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_flp_min_pr
		"Minimum quantity of late post injection during pft regeneration"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_flp_min_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_flp_split_rat
		"Split factor of late post injection 1 and 2"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_fms_flp_split_rat 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd00019c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1
		"Pre-injection 1 quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001754 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_amp_cor_pr
		"Atmospheric pressure correction for quantity of pre-injection 1 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_amp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_amp_cor_rij
		"Atmospheric pressure correction for quantity of pre-injection 1 regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_amp_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_amp_fac_pr
		"Factor of atmospheric pressure correction for quantity of pre-injection 1 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000b98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_amp_fac_rij
		"Factor of atmospheric pressure interpolation for quantity of pre-injection 1"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_amp_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00066ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_cold_tco_rij
		"Quantity of pre-injection 1 for cold coolant temperature during rij"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_cold_tco_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_cor_pr
		"Correction for quantity of pre-injection 1 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_cor_rij
		"Correction for quantity of pre-injection 1 during regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_mv_tco_rij
		"Quantity of pre-injection 1 for medium coolant temperature during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_mv_tco_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_tco_cor_pr
		"Coolant temperature correction for quantity of pre-injection 1 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_tco_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_tco_fac_pr
		"Factor of coolant temperature correction for quantity of pre-injection 1 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000b9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_tco_fac_rij
		"Factor of atmospheric pressure interpolation for quantity of pre-injection during regular injection"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00066ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_tia_cor_pr
		"Intake air temperature correction for quantity of pre-injection 1 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_tia_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_tia_cor_rij
		"Intake air temperature correction for quantity of pre-injection 1 regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_tia_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_tia_fac_pr
		"Factor of intake air temperature correction for quantity of pre-injection 1 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000ba2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp1_tia_fac_rij
		"Factor of intake air temperature interpolation for quantity of pre-injection 1"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp1_tia_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00066ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2
		"Pre-injection 2 quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_amp_cor_pr
		"Atmospheric pressure correction for quantity of pre-injection 2 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_amp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000baa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_amp_cor_rij
		"Atmospheric pressure correction for quantity of pre-injection 2 regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_amp_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00066f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_amp_fac_pr
		"Factor of atmospheric pressure correction for quantity of pre-injection 2 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_amp_fac_rij
		"Factor of atmospheric pressure interpolation for quantity of pre-injection 2"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_amp_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00066f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_cold_tco_rij
		"Quantity of pre-injection 2 for cold coolant temperature during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_cold_tco_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_cor_pr
		"Correction for quantity of pre-injection 2 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000bae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_cor_rij
		"Correction for quantity of pre-injection 2 during regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00066f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_mv_tco_rij
		"Quantity of pre-injection 2 for medium coolant temperature during regular injection"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_mv_tco_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_tco_cor_pr
		"Coolant temperature correction for quantity of pre-injection 2 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_tco_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000bb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_tco_fac_pr
		"Factor of coolant temperature correction for quantity of pre-injection 2 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_tco_fac_rij
		"Factor of coolantr temperature interpolation for quantity of pre-injection 2"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00066fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_tia_cor_pr
		"Intake air temperature correction for quantity of pre-injection 2 during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_tia_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000bb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_tia_cor_rij
		"Intake air temperature correction for quantity of pre-injection 2 regular injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_tia_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00066fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_tia_fac_pr
		"Factor of intake air temperature correction for quantity of pre-injection 2 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fp2_tia_fac_rij
		"Factor of intake air temperature interpolation for quantity of pre-injection 2"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fp2_tia_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006700 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo
		"Post injection quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fpo 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001762 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo_amp_cor_pr
		"Atmospheric pressure correction for quantity of post injection during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fpo_amp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000bc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo_amp_fac_pr
		"Factor of atmospheric pressure correction for quantity of post injection during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fpo_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo_cor_pr
		"Correction for quantity of post injection during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fpo_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000bcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo_tco_cor_pr
		"Coolant temperature correction for quantity of post injection during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fpo_tco_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000bce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo_tco_fac_pr
		"Factor of coolant temperature correction for quantity of post injection during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fpo_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo_tia_cor_pr
		"Intake air temperature correction for quantity of post injection during pft regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_fpo_tia_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000bd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_fpo_tia_fac_pr
		"Factor of intake air temperature correction for quantity of post injection during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_fpo_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_lp_efy
		"Late post injection efficiency ratio"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_lp_efy 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00009e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_ms_dp_fac_pr
		"Factor of CSF equivalent load correction for quantity of global injection during pft rgn"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_ms_dp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006400 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_phi_end_aftr
		"Angle of the end of after injection"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_phi_end_aftr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_phi_max_pinj1
		"Earliest opening angle for pre - injection 1"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_phi_max_pinj1 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_phi_max_pinj2
		"Earliest opening angle possibe for pre-injection2"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_phi_max_pinj2 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_phi_min_aftr
		"Latest injector closing angle for after injection"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_phi_min_aftr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_phi_min_lpos
		"Latest injector closing for late post injection"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_phi_min_lpos 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_phi_min_lpos2
		"Latest injector closing for late post 2 injection"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_phi_min_lpos2 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_phi_min_post
		"Latest injector closing angle possible for post injection"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_phi_min_post 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj
		"Value of the pre injection activation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019c5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_amp_cut
		"Amtopheric pressure cut of pre injection"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_amp_cut 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_bas_cut
		"Basic cut of pre injection"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_bas_cut 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_comb_mod_cut
		"Combustion mode cut of pre injection"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_comb_mod_cut 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_cut_1
		"The pre injection cut one"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_cut_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000bba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_cut_2
		"The pre injection cut two"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_cut_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000bbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_cut_3
		"The pre injection cut three"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_cut_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_cut_4
		"The pre injection cut four"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_cut_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000bc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_cut_5
		"The pre injection cut five"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_cut_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000bc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_cut_tco
		"Index breakpoint variable of coolant temperature"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		8.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_cut_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_cut_tia
		"Index breakpoint variable of intake air temperature"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		8.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_cut_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_gear_cut
		"Gearbox ratio cut of pre injection"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_gear_cut 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_nbr
		"The number of pre injection cut"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_nbr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_nbr_old
		"The old number of pre injection cut"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_nbr_old 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_new
		"New value of the pre injection activation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_new 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_pinj_old
		"Old value of the pre injection activation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_pinj_old 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_post_efy
		"Post injection efficiency ratio"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_post_efy 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001798 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_prectl_cor
		"pre-controlled temperature correction"
		UWORD
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_fms_prectl_cor 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd000640e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_sep_min_aftr
		"Minimal timing of separation for after injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_sep_min_aftr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_sep_min_lpos
		"Minimal separation timing between late post and the previous injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_sep_min_lpos 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_sep_min_lpos2
		"Minimal separation timing between late post 2 and the previous injection"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_sep_min_lpos2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_sep_min_post
		"Minimal separation with the previous injection concerning post injection timing"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_sep_min_post 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_t_min_nxt_cyl
		"Minimal realizable time between late post injection and next cylinder one on the same electric bench (electrical constrain)"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_t_min_nxt_cyl 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_t_min_nxt_cyl_lpos2
		"Minimal realizable time between late post injection 2 and next cylinder one on the same electric bench (electrical constrain)"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_t_min_nxt_cyl_lpos2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf
		"separation of after injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_amp_cor_rij
		"Atmospheric pressure correction for separation of after injection during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf_amp_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007a98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_amp_fac_rij
		"Atmospheric pressure correction for separation of after injection during refular injection"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_taf_amp_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007a9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_cold_tco_rij
		"separation of after injection for cold coolant temperature during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf_cold_tco_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007a9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_cor_rij
		"Correction for separation of after injection during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007a9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_max
		"minimal separation (maximal angle) for after injection"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_min
		"maximal separation (minimal angle) of after injection"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf_min 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_mv_tco_rij
		"separation of after injection for medium coolant temperature during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf_mv_tco_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007aa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_tco_fac_rij
		"Factor of coolant temperature correction for separation of after injection during regular injection"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_taf_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007aa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_tia_cor_rij
		"Intake air temperature correction for separation of after injection during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_taf_tia_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007aa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_taf_tia_fac_rij
		"Factor of intake air temperature correction for separation of after injection during regular injecti"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_taf_tia_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0007aa6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tia_fac_pr
		"Factor of intake air temperature correction for quantity of global injection during pft rgn"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006402 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp1
		"angle of late post 1 injection"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp1 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp1_min_shf
		"minimum angle of late post injection 1 due to the absolute position of late post injection 2"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp1_min_shf 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp2
		"Late post injection 2 desired timing separatin"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tlp2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp2_max_abs_angl
		"Absolute angle Late Post 2 injection value due to the miaximum absolute angle"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp2_max_abs_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp2_min_abs_angl
		"Absolute angle Late Post 2 injection value due to the minimum absolute angle and the next cylinder"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp2_min_abs_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp2_min_end
		"Minimum angle of Late Post 2 injection value due to the minimum absolute angle"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp2_min_end 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp2_nxt_cyl
		"Absolute angle Late Post 2 injection value due to the first injection of the next cylinder"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp2_nxt_cyl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_amp_cor_pr
		"Atmospheric pressure correction for angle of late post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_amp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_amp_fac_pr
		"Factor of atmospheric pressure correction for angle of late post injection during pft rgn"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_cor_pr
		"correction for angle of late post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_max
		"maximal angle of late post injection"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_min
		"minimum angle of late post injection 1"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_min 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_min_end
		"minimal angle of late post injection due to common minimal angle for injection."
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_min_end 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_nxt_cyl
		"minimum angle of late post injection due to injection in next cylinder."
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_nxt_cyl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_tco_cor_pr
		"Coolant temperature correction for angle of late post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_tco_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_tco_fac_pr
		"Factor of coolant temperature correction for angle of late post injection during pft rgn"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_tia_cor_pr
		"Intake air temperature correction for angle of late post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_tia_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tlp_tia_fac_pr
		"Factor of intake air temperature correction for angle of late post injection during pft rgn"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tlp_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1
		"separation of pre-injection 1"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_amp_cor_pr
		"Atmospheric pressure correction for separation of pre-injection 1 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_amp_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006734 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_amp_cor_rij
		"Atmospheric pressure correction for separation of pre-injection 1 regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_amp_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_amp_fac_pr
		"Factor of atmospheric pressure correction for separation of pre-injection 1 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006736 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_amp_fac_rij
		"Factor of atmospheric pressure interpolation for separation of pre-injection 1"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_amp_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_cold_tco_rij
		"separation of pre-injection 1 for cold coolant temperature during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_cold_tco_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_cor_pr
		"Correction for separation of pre-injection 1 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006738 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_cor_rij
		"Correction for separation of pre-injection 1 during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_max
		"maximal separation of pre-injection 1"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_min
		"minimal separation for pre-injection 1"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_min 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_mv_tco_rij
		"separation of pre-injection 1 for medium coolant temperature during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_mv_tco_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_tco_cor_pr
		"Coolant temperature correction for separation of pre-injection 1 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_tco_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000673a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_tco_fac_pr
		"Factor of coolant temperature correction for separation of pre-injection 1 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd000673c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_tco_fac_rij
		"Factor of atmospheric pressure interpolation for separation of pre-injection during regular injectio"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_tia_cor_pr
		"Intake air temperature correction for separation of pre-injection 1 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_tia_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000673e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_tia_cor_rij
		"Intake air temperature correction for separation of pre-injection 1 regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_tia_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_tia_fac_pr
		"Factor of intake air temperature correction for separation of pre-injection 1 during pft regeneratio"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006740 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp1_tia_fac_rij
		"Factor of intake air temperature interpolation for separation of pre-injection 1"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp1_tia_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2
		"separation for pre-injection 2"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_amp_cor_pr
		"Atmospheric pressure correction for separation of pre-injection 2 during pr"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_amp_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000674a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_amp_cor_rij
		"Atmospheric pressure correction for separation of pre-injection 2 regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_amp_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000caa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_amp_fac_pr
		"Factor of atmospheric pressure correction for separation of pre-injection 2 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd000674c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_amp_fac_rij
		"Factor of atmospheric pressure interpolation for separation of pre-injection 2"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_amp_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000cac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_cold_tco_rij
		"separation of pre-injection 2 for cold coolant temperature during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_cold_tco_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_cor_pr
		"Correction for separation of pre-injection 2 during pft regeneration"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000674e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_cor_rij
		"Correction for separation of pre-injection 2 during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000cb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_max
		"maximal separation for pre-injection 2"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_min
		"minimal separation for pre-injection 2"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_min 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_mv_tco_rij
		"separation of pre-injection 2 for medium coolant temperature during regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_mv_tco_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000cb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_tco_cor_pr
		"Coolant temperature correction for separation of pre-injection 2 during pr"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_tco_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006750 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_tco_fac_pr
		"Factor of coolant temperature correction for separation of pre-injection 2 during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006752 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_tco_fac_rij
		"Factor of coolantr temperature interpolation for separation of pre-injection 2"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_tia_cor_pr
		"Intake air temperature correction for separation of pre-injection 2 during pr"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_tia_cor_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006754 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_tia_cor_rij
		"Intake air temperature correction for separation of pre-injection 2 regular injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_tia_cor_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000cb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_tia_fac_pr
		"Factor of intake air temperature correction for separation of pre-injection 2 during pft regeneratio"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0006756 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tp2_tia_fac_rij
		"Factor of intake air temperature interpolation for separation of pre-injection 2"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tp2_tia_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000cb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo
		"separation of post injection"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_amp_cor_pr
		"Atmospheric pressure correction for angle of post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_amp_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_amp_fac_pr
		"Factor of atmospheric pressure correction for angle of post injection during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000cc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_bfr_angl
		"Angle of beginning of post separation"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_bfr_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_cor_pr
		"Correction for angle of post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000cca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_max
		"maximal angle (minimal separation) of post injection"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_min
		"minimal angle (maximal separation) of post injection"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_min 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_tco_cor_pr
		"Coolant temperature correction for angle of post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_tco_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_tco_fac_pr
		"Factor of coolant temperature correction for angle of post injection during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000cce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_tia_cor_pr
		"Intake air temperature correction for angle of post injection during pft regeneration"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_tia_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000cd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_tpo_tia_fac_pr
		"Factor of intake air temperature correction for angle of post injection during pft regeneration"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_fms_tpo_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_afterxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_faf
		"After injection desired quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_faf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001778 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_faf_lim
		"After injection wished quantity after limitation by both limitations (minimal main injection quantity and maximum flow)"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_faf_lim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001744 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_fim_main
		"Main injection desired quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_fim_main 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000179a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_lpostxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_flp
		"Late post injection desired quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_flp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001794 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_flp1
		"Late post injection 1 desired quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_flp1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_flp2
		"Late post injection 2 desired quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_flp2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_flp_acum
		"late post injection wished quantity incuding cylinder to cylinder accumulation"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_flp_acum 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_flp_lim
		"limited late post injection wished quantity incuding cylinder to cylinder accumulation"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_flp_lim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_flp_lim_old
		"Old limited late post injection wished quantity incuding cylinder to cylinder accumulation"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_flp_lim_old 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_fp1
		"Desired quantity pre-injection 1"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_fp1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00017a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_fp2
		"Pre-injection 2 desired quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_fp2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_fpo
		"Post injection desired quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_fpo 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00017ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_fpo_lim
		"Post injection wished quantity after check by both limitations"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_fpo_lim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001764 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_min_faf
		"After injection wished quantity after limitation by the minimal main injection quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_min_faf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000174c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_min_fp1
		"Pre-injection 1 wished quantity after limitation by the minimal injectable fuel quantity."
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_min_fp1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001756 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_min_fp2
		"Pre-injection 2 desired quantity after limitation by the minimal injectable fuel quantity."
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_min_fp2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000b7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_min_fpo
		"Post injection wished quantity after limitation by the minimal injectable fuel quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_fms_wish_min_fpo 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000176a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_afterxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_taf
		"After injection desired angle"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_taf 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001818 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_taf_angl
		"wished separation angle of after injection"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_taf_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00017c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_taf_max
		"After injection desired angle after maximal limitation."
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_taf_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_taf_min_max
		"After injection desired angle after maximal and minimal limitation."
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_taf_min_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tlp
		"Late post injection desired angle"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tlp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001830 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tlp2
		"Late post injection 2 desired timing separation"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tlp2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00017fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tlp2_ang
		"Late post 2 injection desired angle separation"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tlp2_ang 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001800 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tlp2_max
		"Late post injection 2 maximum desired timing separation"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tlp2_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001802 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tlp_max
		"Late Post wished angle after max limitation."
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tlp_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001804 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tlp_min_max
		"Late Post wished angle after min and max limitations."
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tlp_min_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001806 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tlp_t
		"Duration of late post injection"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tlp_t 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001808 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp1
		"Desired separation of pre-injection 1"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000cba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp1_angl
		"wished separation angle of pre-injection 1"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp1_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp1_angl_abv
		"Wished absolute angle of pre-injection 1"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp1_angl_abv 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp1_min
		"Pre-injection 1 wished separation after min limitation."
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp1_min 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp1_min_max
		"Pre-injection 1 wished separation after min and max limitations."
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp1_min_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp2
		"Pre-injection 2 desired separation"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000cbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp2_angl
		"wished separation, as an angle, of pre-injection 2"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp2_angl 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp2_angl_abv
		"wished absolute angle of pre-injection 2"
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp2_angl_abv 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp2_min
		"Pre-injection 2 wished separation after min limitation."
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp2_min 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tp2_min_max
		"Pre-injection 2 wished separation after min and max limitations."
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tp2_min_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tpo
		"Post injection desired angle"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tpo 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000cd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tpo_max
		"Post injection wished angle after maximal limitation."
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tpo_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tpo_min_max
		"Post injection wished angle after maximal and minimal limitations."
		UWORD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tpo_min_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000c46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_fms_wish_tpo_t
		"timing of post injection"
		UWORD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_fms_wish_tpo_t 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000c48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_free_shf_acel
		"Vxx_free_shf_acel"
		SLONG
		VA_F_0v0004_p0_10
		2
		100
		-858993.4592
		858993.4588
    ECU_ADDRESS 0xd0004bd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fspfzxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_free_shf_pdl
		"Vxx_free_shf_pdl"
		UWORD
		VA_F_0v125_p0_14
		2
		100
		0
		8191.875
    ECU_ADDRESS 0xd00010ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_frst_edge_dly
		"EGR by-pass throttle activation delay"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_frst_edge_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_frz_gear_sel
		"Vxx_frz_gear_sel"
		UBYTE
		VA_F_1_m1_24
		2
		100
		-1
		254
    ECU_ADDRESS 0xd0001da2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_fslsvxx_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_fsl_forc_sp
		"Driving force requested by Fixed Speed Limiter"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_fsl_forc_sp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0004ae0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_fslinxx_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_fsl_max_vs_sp_kmh
		"Requested speed for fixed speed limiter or statutory limiter"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_fsl_max_vs_sp_kmh 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001092 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ftc_dyn
		"Factor of filtering of the engine speed to teh dynamic setpoint"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_ftc_dyn 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001236 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ftc_dyn_n_drv
		"Filtered derivate of engine speed"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_ftc_dyn_n_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001238 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_gbxatxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gbx_max_tqe_sp
		"Gearbox setpoint request which will be sent to torque arbitration in max bloc."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_gbx_max_tqe_sp 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_gbxatxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gbx_max_tqe_tgt
		"Gearbox slow request which will be sent to torque arbitration in max bloc."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_gbx_max_tqe_tgt 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_gbxatxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gbx_min_tqe_sp
		"Gearbox setpoint request which will be sent to torque arbitration in min bloc."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_gbx_min_tqe_sp 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_gbxatxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gbx_min_tqe_tgt
		"Gearbox slow request which will be sent to torque arbitration in min bloc."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_gbx_min_tqe_tgt 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_gcu_ecu_stt_diag
		"State of Gaz Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_gcu_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gear
		"Gear engaged ( [-1 0 1 2 3 4 5 6] )"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001c7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gear_bk
		"Vxx_gear_bk"
		UBYTE
		VA_F_1_m1_24
		2
		100
		-1
		254
    ECU_ADDRESS 0xd0001d96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_gear_df_tran
		"Gear engaged ( [-1 0 1 2 3 4 5 6] )"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_gear_df_tran 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00019b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_gear_fzy
		"Gear engaged ( [-1 0 1 2 3 4 5 6] ) after consolidation for fuzzyfication"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_gear_fzy 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0002393 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gear_lim
		"Vxx_gear_lim"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001d87 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gear_lim_inc
		"Vxx_gear_lim_inc"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001d89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gear_lim_tq_dif
		"Vxx_gear_lim_tq_dif"
		UBYTE
		VA_F_1_p1_1
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001db5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_gear_sel
		"Vxx_gear_sel"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001da5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_gear_spg
		"Gear engaged specific for supercharger control strategy ( [-1 0 1 2 3 4 5 6] )"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_gear_spg 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001e51 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_svcecom_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_get_ind_pres_iter
		"Current last index scaned by RSA_API_GetIDXByDTC function"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_get_ind_pres_iter 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007ae4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_in_cam_toth_per
		"Duration between two intake camshaft events"
		UWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_in_cam_toth_per 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ind_fail_redg
		"Diagnosis identifier associated to Vbx_cf_xxx rising edge event"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ind_fail_redg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ind_mfo_redg
		"Diagnosis identifier of OBD confirmed failure rising edge"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ind_mfo_redg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ind_obd_clf_redg
		"Diagnosis identifier of OBD confirmed latched rising edge"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ind_obd_clf_redg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ind_obd_fedg
		"Diagnosis identifier of OBD pending or confirmed failure falling edge or overwriting"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ind_obd_fedg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ind_pfo_redg
		"Diagnosis identifier of OBD pending failure rising edge"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_ind_pfo_redg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_init_timeout
		"New timeout initialization request"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_init_timeout 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_injctxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_inj_avl_nr
		"Number of available cylinders. (Only failures decrease the number)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vxx_inj_avl_nr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_inj_cmd_max_nr
		"Potential max number of injection per stroke that the system is able to achieve"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_inj_cmd_max_nr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00020e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_inj_vld_min_is_n
		"Injector failure idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_inj_vld_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007748 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_inrt_doc_mdl_dly
		"Filtered value of delay for inert DOC model"
		UBYTE
		RB_CONV_AtCatDgn_Time_1s
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_inrt_doc_mdl_dly 
    ECU_ADDRESS 0xd000203e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ip_ecu_stt
		"cluster ECU status for CAN"
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_ip_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ip_ecu_stt_ctr
		"Cluster Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ip_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ip_ecu_stt_ctr_mem_dec
		"CLUSTER : current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ip_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ip_ecu_stt_ctr_mem_prev
		"CLUSTER : current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ip_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_ip_ecu_stt_diag
		"State of Cluster Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_ip_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_ast_ofs
		"Offset (depending coolant temperature) about idle speed setpoint to create after start state threshold"
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_is_ast_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00011e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_cdn_h_n_dly
		"Delay after start"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_is_cdn_h_n_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00011e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_d_cor
		"Derivative correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_is_d_cor 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_d_fac
		"Factor of derivative correction function of Tco and difference between engine and idle speed"
		UWORD
		uBFsuAd_hvfAplb_zlBDusd_NrC_1a0
		1
		100
		0.
		7.9990234375
    DISPLAY_IDENTIFIER Vxx_is_d_fac 
    FORMAT "%11.9" 
    ECU_ADDRESS 0xd00011cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_alcoxxx_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_fuel_typ_rat_tra
		"Ratio dedicated to the idle speed regulation renamed"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_is_fuel_typ_rat_tra 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001948 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_gear
		"Gear engaged"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vxx_is_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_cor
		"Integral torque correction of Idle Speed Regulator"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_is_i_cor 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001216 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_cor_ini
		"Initial torque value of idle speed regulator integral  correction"
		SLONG
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		1
		100
		-1024.
		1023.999996875
    DISPLAY_IDENTIFIER Vxx_is_i_cor_ini 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd0004ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_cor_ini_ad
		"Integral torque correction of Idle Speed Regulator after update with the adaptive torque"
		SLONG
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		1
		100
		-1024.
		1023.999996875
    DISPLAY_IDENTIFIER Vxx_is_i_cor_ini_ad 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd0004cd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_cor_prev
		"Integral torque correction of Idle Speed Regulator"
		SLONG
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		1
		100
		-1024.
		1023.999996875
    DISPLAY_IDENTIFIER Vxx_is_i_cor_prev 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd0004cd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_cor_wio_set
		"Integral torque correction of Idle Speed Regulator without ti fix integral correction under certain conditions"
		SLONG
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		1
		100
		-1024.
		1023.999996875
    DISPLAY_IDENTIFIER Vxx_is_i_cor_wio_set 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd0004cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_cor_wit_set
		"Integral torque correction of Idle Speed Regulator with fix integral correction under certain conditions"
		SLONG
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		1
		100
		-1024.
		1023.999996875
    DISPLAY_IDENTIFIER Vxx_is_i_cor_wit_set 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd0004cdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_fac
		"Current integral correction factor for Idle Speed regulator"
		UWORD
		afehFbd_BkiipFd_DFrgCuc_Nrj_ao0
		1
		100
		0.
		55.9990234375
    DISPLAY_IDENTIFIER Vxx_is_i_fac 
    FORMAT "%7.4" 
    ECU_ADDRESS 0xd000120e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_out_fil
		"Decrementation integral correction when idle speed regulation is disable"
		SLONG
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		1
		100
		-1024.
		1023.999996875
    DISPLAY_IDENTIFIER Vxx_is_i_out_fil 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd0004ce0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_i_zon_out_dly
		"Temporization of initialization of recognition of exit of engine speed hook"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_is_i_zon_out_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000773a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_in_deci_dly
		"Variable that indicates a forced activate state when engine speed is reacher"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_is_in_deci_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00011e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_in_dly
		"Interdiction delay to entry in activate idle speed state"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_is_in_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00011f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_in_n_thd
		"Variable of offset about idle speed setpoint to enter in condition state idle speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_is_in_n_thd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00011f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_n_is_i
		"Engine speed threshold to decrease or increase integral"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_is_n_is_i 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001210 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_n_is_i_grd
		"Torque gradient to decrease or increase the integral"
		UWORD
		xdBqnAa_fmFFrja_Dkxfxyb_Np__1a0
		1
		100
		0.
		7.9998779296875
    DISPLAY_IDENTIFIER Vxx_is_n_is_i_grd 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001212 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_n_sp
		"Final idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_is_n_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00009a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_n_sp_dif
		"Difference between nomimal engine speed setpoint and the final setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_is_n_sp_dif 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000de0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_n_stab_fac
		"Anti-pumping factor"
		UWORD
		mjxFltb_kfnvCoc_mCDcAhb_B__020a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_is_n_stab_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00011e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_out_ast_dly
		"Delay to fore input in condition idle speed state"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_is_out_ast_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00011ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_out_n_thd
		"Variable of offset about idle speed setpoint to exit of condition idle speed state"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_is_out_n_thd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00011ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_out_sta_dly
		"Delay to exit of start state to condition state directly"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_is_out_sta_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00011ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_p_cor
		"Proportional correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_is_p_cor 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001226 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idctrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_is_tqe_raw
		"Raw idle speed torque"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_is_tqe_raw 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idctrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_is_tqe_sp
		"Setpoint idle speed torque"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_is_tqe_sp 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idctrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_is_tqe_tgt
		"Target idle speed torque"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_is_tqe_tgt 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001200 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_lossxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_is_tql
		"engine torque losses for idle"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_is_tql 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_abs_psn
		"Raw value of the position in percent of the sensor supply voltage."
		UWORD
		wmkbkad_wwidqld_lsCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_abs_psn 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000daa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_abs_psn_1
		"Raw value of the position in percent of the sensor supply voltage"
		UWORD
		wmkbkad_wwidqld_lsCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_abs_psn_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000dae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_chr_psn
		"Absolute position given by the sensor, in percent of the sensor supply voltage."
		UWORD
		wmkbkad_wwidqld_lsCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_chr_psn 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000db0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_clos_ctr
		"Time counter to ensure that the valve is closed."
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1024.
    DISPLAY_IDENTIFIER Vxx_it_clos_ctr 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000fa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_msocoxx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_cmd_cut_npu
		"Variable for inlet throttle command after EGR shut-off in npu mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_cmd_cut_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000783a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_cmd_val
		"Output of the S controller."
		SLONG
		sdFCuzd_Bbcpwsd_kxphmtc_n_99o55
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_it_cmd_val 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_cmd_val_1
		"Output of the S1 component of the S controller."
		SLONG
		sdFCuzd_Bbcpwsd_kxphmtc_n_99o55
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_it_cmd_val_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_cmd_val_2
		"Output of the S2 component of the S controller."
		SLONG
		sdFCuzd_Bbcpwsd_kxphmtc_n_99o55
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_it_cmd_val_2 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_cmd_val_3
		"Output of the S3 component of the S controller."
		SLONG
		sdFCuzd_Bbcpwsd_kxphmtc_n_99o55
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_it_cmd_val_3 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_cmd_val_lim
		"Voltage setpoint given by the RST Controller."
		SLONG
		sdFCuzd_Bbcpwsd_kxphmtc_n_99o55
		1
		100
		-25.
		24.9999999883585
    DISPLAY_IDENTIFIER Vxx_it_cmd_val_lim 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004a9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_ctl_err
		"Difference between the outputs of the T and R controller. Similar to a position error."
		SLONG
		fBnckhb_ozrejBa_yFBnwba_n_90540
		1
		100
		-50.
		49.9999999767169
    DISPLAY_IDENTIFIER Vxx_it_ctl_err 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004aa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_ctl_err_lim
		"Saturated value of Vxx_it_ctl_err. Input of the S controller."
		SWORD
		FvuyuAd_lwkEihc_wlsckqb_n_o6o33
		1
		100
		-25.
		24.9992370605469
    DISPLAY_IDENTIFIER Vxx_it_ctl_err_lim 
    FORMAT "%9.5" 
    ECU_ADDRESS 0xd0000fe6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_frn_cps_v
		"Friction Compensation Voltage added to Vxx_it_cmd_val_lim."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_it_frn_cps_v 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000fe8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_ofs_clos_frst_ctr
		"Counter of right offset learnings if 3 learning attempts are needed for the first offset learning of clos. thrust"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1024.
    DISPLAY_IDENTIFIER Vxx_it_ofs_clos_frst_ctr 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000faa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_ofs_ctr_1
		"Number of iterations to calculate the medium value of the position during Offset Learning."
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1000.
    DISPLAY_IDENTIFIER Vxx_it_ofs_ctr_1 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000fac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_ofs_open_frst_ctr
		"Counter of right offset learnings if 3 learning attempts are needed for the first offset learning of open thrust"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1024.
    DISPLAY_IDENTIFIER Vxx_it_ofs_open_frst_ctr 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000fae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_open_ctr
		"Time counter to ensure that the valve is open."
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1024.
    DISPLAY_IDENTIFIER Vxx_it_open_ctr 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000fb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_cmd
		"Position sent to the regulator by the control system."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_cmd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ctl
		"Ouput of the R Controller."
		SLONG
		ltvDhsb_dlbBqsd_CwvACca_n_7a150
		1
		100
		-100.
		99.9999999534339
    DISPLAY_IDENTIFIER Vxx_it_psn_ctl 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004aa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ctl_0
		"Output of the first component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		2999.99997765925
    DISPLAY_IDENTIFIER Vxx_it_psn_ctl_0 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004aa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ctl_1
		"Output of the second component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		2999.99997765925
    DISPLAY_IDENTIFIER Vxx_it_psn_ctl_1 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004aac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ctl_2
		"Output of the third component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		2999.99997765925
    DISPLAY_IDENTIFIER Vxx_it_psn_ctl_2 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004ab0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ctl_3
		"Output of the fourth component of the R controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		2999.99997765925
    DISPLAY_IDENTIFIER Vxx_it_psn_ctl_3 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004ab4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_err
		"Position error while regulating"
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_err 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_lim_down
		"Range near the low voltage thrust where thrust approach strategy is activated."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_lim_down 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_lim_down_thd
		"Position threshold to activate the approach strategy near the closed thrust."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_lim_down_thd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000fea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_lim_up
		"Range near the high voltage thrust where the thrust approach strategy is activated."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_lim_up 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_lim_up_thd
		"Position threshold to activate the approach strategy near the open thrust."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_lim_up_thd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000fec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_max_val
		"Maximal allowed value of the inlet trottle position depending of the combustion mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_max_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000158c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_max_val_pp
		"Map for maximal value of the itp in EGR regulation mode when rgn_prmt mode is on"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_max_val_pp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001594 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_max_val_pr
		"Maximal allowed value of the inlet trottle in rgn mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_max_val_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000159c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_max_val_rij
		"Maximal allowed value of the inlet trottle position in rij combustion mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_max_val_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00015a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ooitpsp_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ocl_hys
		"Value of the itp in open loop after hysteresis"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_ocl_hys 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001650 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ocl_hys_dt1
		"Value of the itp after hysteresis and DT1 filter"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_ocl_hys_dt1 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000162c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ocl_hys_dt1_swt
		"Value of the itp after hysteresis, DT1 filter and switch"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_ocl_hys_dt1_swt 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000162e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ofs_clos
		"Current value of the closed thrust position used by the regulation system."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_clos 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ofs_down
		"Minimum value of the position setpoint (Position of the closed thrust)."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_down 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ofs_open
		"Current value of the open thrust position used by the regulation system."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_open 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000fb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_ofs_up
		"Maximum value of the position setpoint."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_ofs_up 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ooitpsp_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_on_off_cmd
		"Position setpoint of the OnOff inlet throttle controlled in open loop"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_on_off_cmd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001652 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_rat
		"Ratio of the measured positions totally closed or totally open, after a full closing or opening ."
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_it_psn_rat 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001d1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_raw_mv_tot
		"Sliding mean value of the raw position (in % of Vsens)."
		UWORD
		wmkbkad_wwidqld_lsCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_raw_mv_tot 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000dac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_raw_stab
		"Value of the position used as a reference for the check of position stability."
		UWORD
		wmkbkad_wwidqld_lsCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_raw_stab 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000db2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_reg_1
		"IT position used by the regulator."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_reg_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000fee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_reg_2
		"Absolute position value given by the sensor after the measurement adaptation."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_reg_2 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ff0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_reg_3
		"Output of the dead zone filter."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_reg_3 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ff2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_reg_ol_sp
		"Pwm command for inlet throttle to increase the EGR concentration"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_reg_ol_sp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001616 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_rel
		"Throttle position relative to the closed thrust."
		UWORD
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_rel 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0000fe2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itcmdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp
		"Pwm command for inlet throttle"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00015ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_1
		"Position setpoint used by the monitoring system."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_1_0
		"Position setpoint used by the monitoring system"
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_1_0 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_2
		"Position setpoint before inversion cartography."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_2 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_2_0
		"Position setpoint before inversion cartography"
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_2_0 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_3
		"Position setpoint before inversion cartography"
		UWORD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_3 
    FORMAT "%9.4" 
    ECU_ADDRESS 0xd0000fb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_cmd
		"Position setpoint sent by the monitoring system."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_cmd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000f4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_cmd_0
		"Position setpoint sent by the monitoring system"
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_cmd_0 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000fa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_cor
		"Absolute position setpoint used by the thrust approach strategy."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_cor 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ff4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_cor_1
		"Input of the position setpoint slope. Used during the thrust approach."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_cor_1 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ff6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_ctl
		"Output of the T Controller."
		SLONG
		ltvDhsb_dlbBqsd_CwvACca_n_7a150
		1
		100
		-100.
		99.9999999534339
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_ctl 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0004ab8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_ctl_0
		"Output of the first component of the T controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		2999.99997765925
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_ctl_0 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004abc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_ctl_1
		"Output of the second component of the T controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		2999.99997765925
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_ctl_1 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004ac0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_ctl_2
		"Output of the third component of the T controller."
		ULONG
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		1
		100
		0.
		2999.99997765925
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_ctl_2 
    FORMAT "%14.8" 
    ECU_ADDRESS 0xd0004ac4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_mod
		"Used to indicate if the position setpoint has to be modified by the thrust approach strategy."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		16.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_mod 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001d33 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_ofs
		"Position setpoint sent during the first offset learning strategy."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_ofs 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000fb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_pwl
		"Position setpoint during the power latch."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_pwl 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000fb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_reg
		"Absolute position setpoint really given to the RST controller."
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_reg 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ff8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_psn_sp_slop
		"Position setpoint given by a slope system, when position and setpoint are near a thrust."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_it_psn_sp_slop 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ffa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_amp_pp
		"Throttle sat correction by amp in rgn_prmt mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_amp_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_amp_pr
		"Throttle sat correction by amp in rgn mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_amp_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_amp_rij
		"Throttle sat correction by amp in rij mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_amp_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000160a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tco_pp
		"Throttle sat correction by tco in rgn_prmt mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tco_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tco_pr
		"Throttle sat correction by tco in rgn mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tco_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001600 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tco_rij
		"Throttle sat correction by tco in rij mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tco_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000160c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tco_tia_pp
		"Throttle sat correction by tco and tia in rgn_prmt mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tco_tia_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tco_tia_pr
		"Thr_sat correction by tco and tia in rgn mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tco_tia_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001602 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tco_tia_rij
		"Throttle sat correction by tco and tia in rij mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tco_tia_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000160e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tia_pp
		"Throttle sat correction with tia in rgn_prmt mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tia_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tia_pr
		"Throttle sat correction by tia in rgn mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tia_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001604 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_cor_tia_rij
		"Throttle sat correction with tia in rij mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_cor_tia_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001610 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_val
		"Value of the open loop setpoint position for inlet throttle in Throttle Saturation Mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00015ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_val_bas_pp
		"Thr_sat basic setpoint in rgn_prmt mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_val_bas_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_val_bas_pr
		"Thr_sat basic setpoint in rgn mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_val_bas_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001606 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_val_bas_rij
		"Thr_sat basic setpoint in rij mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_val_bas_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001612 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_val_pp
		"Value of the position saturation threshold depending on the operating point in pp mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_val_pp 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_val_pr
		"Value of the position saturation threshold depending on the operating point in pr mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_val_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00015fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_sat_val_rij
		"Value of the position saturation threshold depending on the operating point in rij mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_it_sat_val_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001608 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_t_frst_ofs
		"Timer used during the first offset strategy."
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_it_t_frst_ofs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000fba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_t_pwl_act
		"Time duration of the cleaning sequence."
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_it_t_pwl_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000fbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_lim_down
		"Minimum value of the it command voltage."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_it_v_lim_down 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000fa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_lim_down_1
		"Value of the low voltage limitation used by the monitoring system."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_it_v_lim_down_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000fbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_lim_up
		"Maximum value of the it command voltage."
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_it_v_lim_up 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000fa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_lim_up_1
		"Value of the high voltage limitation used by the monitoring system."
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_it_v_lim_up_1 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000fc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_ofs_lim_down
		"Maximum negative voltage command near the thrust zone, during full closing."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_it_v_ofs_lim_down 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000fc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_ofs_lim_up
		"Maximum positive voltage command near the open thrust (during full opening)."
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_it_v_ofs_lim_up 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000fc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_sp
		"Voltage setpoint given by the RST regulator and sent to the component."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_it_v_sp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000ffc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_sp_cmd
		"Voltage setpoint for open loop control. Value sent to the H bridge."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_it_v_sp_cmd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000fa6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_v_sp_cor_lim
		"Voltage setpoint given to the H bridge."
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_it_v_sp_cor_lim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000fe4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_it_wit_emtv_cmd
		"Command sent to the inlet throttle with or without egr valve saturation"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_it_wit_emtv_cmd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001618 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_engtqxx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_l_eng_tqe
		"low engine minimum effective torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_l_eng_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001268 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_l_prs_ac_diag
		"Diagnosis information: the cooling gas load is too low"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_l_prs_ac_diag 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001e34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_law_gear_sel
		"Vxx_law_gear_sel"
		UBYTE
		VA_F_1_p1_2
		2
		100
		1
		256
    ECU_ADDRESS 0xd0001dab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_rwsxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lft_rwhs
		"Rear left wheel speed"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.34
    DISPLAY_IDENTIFIER Vxx_lft_rwhs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_lacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lg_acel
		"Longitudinal vehicle acceleration"
		SLONG
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_lg_acel 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0004f04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_lacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lg_acel_raw
		"Longitudinal vehicle acceleration raw signal"
		SLONG
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_lg_acel_raw 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0004f08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lim_dif_n
		"difference between the setpoint and the engine speed"
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_lim_dif_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001244 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lim_dif_n_prop
		"difference between the setpiont and the engine speed  + offset of proportional activation"
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_lim_dif_n_prop 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001246 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_drlimxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lim_driv_tqe_sp
		"Effective engine torque setpoint requested by real (pedal) and virtual (ACC/CC/SL) drivers"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_lim_driv_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00011b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_drlimxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lim_driv_tqe_tgt
		"Effective engine torque target requested by real (pedal) and virtual (ACC/CC/SL) drivers"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_lim_driv_tqe_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00011b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_lim_max_rams_tqe
		"Maximum torque allowed by the failsafe mode."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_lim_max_rams_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_lpos_efi_exo_fac
		"Factor for physical fuel flow exotherm adaptation from late post injection to 5th injector."
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_lpos_efi_exo_fac 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006404 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf
		"Mass air flow"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_amp_pp
		"Mass air flow correction by amp in pp mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_amp_pp 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001660 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_amp_pr
		"Mass air flow correction by amp in pr mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_amp_pr 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001672 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_amp_rij
		"Mass air flow correction by amp in rij mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_amp_rij 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd000167e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_byp_pp
		"Mass air flow correction with byp in pp mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_byp_pp 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001662 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_byp_rij
		"Mass air flow correction with byp in rij mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_byp_rij 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001680 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_pft_ovp_pp
		"Mass air flow correction with back-pressure due to particulate filter in pp mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_pft_ovp_pp 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001664 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_pft_ovp_pr
		"Mass air flow correction with back-pressure due to particulate filter in pr mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_pft_ovp_pr 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001674 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_pft_ovp_rij
		"Mass air flow correction with back-pressure due to particulate filter"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_pft_ovp_rij 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001682 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tco_pp
		"Mass air flow basic setpoint with tco correction in pp mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_tco_pp 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001666 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tco_pr
		"Mass air flow basic setpoint with tco correction in pr mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_tco_pr 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001676 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tco_rij
		"Mass air flow basic setpoint with tco correction in rij mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_tco_rij 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001684 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tia_pp
		"Mass air flow correction with tia in pp mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3276.8
		3276.7
    DISPLAY_IDENTIFIER Vxx_maf_cor_tia_pp 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001668 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tia_pr
		"Mass air flow correction with tia in pr mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_tia_pr 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001678 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tia_rij
		"Mass air flow correction with tia in rij mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_tia_rij 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001686 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tkof_pp
		"Mass air flow correction by ttake off in pp mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_tkof_pp 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd000166a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cor_tkof_rij
		"Mass air flow correction by take off in rij mode"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_cor_tkof_rij 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001688 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_cs
		"Mass air flow consolidated by drift sensor diagnosis"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_cs 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_dyn
		"Intake air mass flow across the throttle valve estimated by AsMod in mg/cp"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_dyn 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_dyn_cs
		"Intake air mass flow across the throttle valve estimated by AsMod in mg/cp and consolidated by drift sensor diagnosis"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_dyn_cs 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_dyn_kgh
		"Dynamic mass air flow in kg/h"
		UWORD
		bCkDtxb_iBmhrgb_vDEgpCc_khA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_maf_dyn_kgh 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_dyn_prt
		"Dynamic mass air flow part"
		UWORD
		Dweusab_Abjlppc_wagagja_kCRa00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_maf_dyn_prt 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007564 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_dyn_prt_drv
		"Derivative of dynamic mass air flow part"
		UWORD
		tClffab_hirDflc_mxtqjrd_mtA_o00
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_dyn_prt_drv 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0007566 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_err
		"Maf error (input of the maf regulator)"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_err 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001624 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg
		"Output of the maf I regulator"
		SLONG
		dCxqAad_vCfEADc_yrvpbwb_f__100a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0004dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_1
		"Output of the init of the maf I regulator"
		SLONG
		dCxqAad_vCfEADc_yrvpbwb_f__100a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_1 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0004dd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_2
		"Input of the maf I part"
		SLONG
		dCxqAad_vCfEADc_yrvpbwb_f__100a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_2 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0004ddc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_neg_fac
		"Gain value in the negative part of the window of the maf I regulator"
		UWORD
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_neg_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001630 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_out
		"Output of the maf I regulator"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_out 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001632 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_pos_fac
		"Gain value in the positive part of the window of the maf I regulator"
		UWORD
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_pos_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001634 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_win_fac
		"Gain value in the window of the maf I regulator"
		UWORD
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_win_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001636 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_win_neg
		"Definition of the negative part of the window for the maf I regulator"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_win_neg 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001638 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_i_reg_win_pos
		"Definition of the positive part of the window for the maf I regulator"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_i_reg_win_pos 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000163a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_kgh
		"Mass air flow in kg/h"
		UWORD
		bCkDtxb_iBmhrgb_vDEgpCc_khA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_maf_kgh 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_p_reg
		"Output of the maf P regulator"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_p_reg 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000163c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_p_reg_neg_fac
		"Gain value in the negative part of the window of the maf P regulator"
		UWORD
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_maf_p_reg_neg_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000163e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_p_reg_out
		"Output of maf P regulator"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_p_reg_out 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001640 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_p_reg_pos_fac
		"Gain value in the positive part of the window of the maf p regulator"
		UWORD
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_maf_p_reg_pos_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001642 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_p_reg_win_fac
		"Gain value in the window of the maf p regulator"
		UWORD
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		1
		100
		0.
		5.
    DISPLAY_IDENTIFIER Vxx_maf_p_reg_win_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001644 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_p_reg_win_neg
		"Definition of the negative part of the window for the maf P regulator"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_p_reg_win_neg 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001646 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_p_reg_win_pos
		"Definition of the positive part of the window for the maf I regulator"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_p_reg_win_pos 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001648 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_pft_utp_max_sp
		"Maximum CSF upstream temp set point considering the current mass air flow"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_maf_pft_utp_max_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006458 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_pi_reg_out
		"Sum of P and I regulators with shut-off conditions after limitations"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_pi_reg_out 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000164a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_reg_emtv_psn_out_1
		"Output of the maf regulation block before last saturation"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_reg_emtv_psn_out_1 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000164c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_reg_emtv_psn_out_red
		"Output of the mass air flow regulation block after last saturation"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_reg_emtv_psn_out_red 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001626 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_reg_fac_cor
		"Corrective factor value of the maf regulator gains"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_maf_reg_fac_cor 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_reg_fac_tia_tco_cor
		"Variable chosen for the correction of the maf regulator gains"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_maf_reg_fac_tia_tco_cor 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000164e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_reg_neg_err_max
		"Value of the maximum maf error threshold for OBD service 06"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_reg_neg_err_max 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0000a72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_reg_neg_err_min
		"Value of the minimum maf error for OBD service 06"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_reg_neg_err_min 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0000a74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp
		"Mass air flow setpoint including static and dynamic parts"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001658 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_bas_pp
		"Value of the basic maf setpoint in pp mode"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_bas_pp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000166c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_bas_pr
		"Value of the basic maf setpoint in pr mode"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_bas_pr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000166e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_bas_rij
		"Value of the basic maf setpoint in rij mode"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_bas_rij 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000167a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsbcx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_cor_byp
		"Corrective value of the basic maf setpoint when the egr bypass is enabled"
		SWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_cor_byp 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0001654 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_ecm
		"Mass air flow setpoint including static and dynamic parts (before the switch for after sale regeneration)"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_ecm 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000783c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_lim
		"Limited maf sp"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_lim 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001656 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_lim_ecm
		"Limited maf sp before the Monitool bypass"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_lim_ecm 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000165a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_npu
		"Air mass flow into the cylinder setpoint in npu mode"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_npu 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000165c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_pp
		"Mass air flow setpoint in pp mode"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_pp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000165e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_pr
		"Mass air flow setpoint in pr mode"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_pr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001670 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_maf_sp_rij
		"Mass air flow setpoint in rij mode"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_maf_sp_rij 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000167c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_main_driv_tqe_sp
		"Driver engine torque setpoint without engine brake part (output of torque setpoint map)"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_main_driv_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001100 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_map
		"Manifold pressure value measurement"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_map 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_map_dif
		"Difference pressure to apply on the manifold pressure for adaptation"
		SBYTE
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_map_dif 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001bed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_map_dif_damp
		"Damped difference pressure to apply on the manifold pressure for adaptation"
		SBYTE
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_map_dif_damp 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_map_dif_raw
		"Raw Difference pressure to apply on the manifold pressure for adaptation"
		SBYTE
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_map_dif_raw 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0001bef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_map_fail_val
		"Manifold pressure from sensor"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_map_fail_val 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_map_fil_max_tq
		"Filtered manifold pressure value"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_map_fil_max_tq 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007784 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mapc_ad_pres
		"Corrected pressure used for adaptation"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_mapc_ad_pres 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mapc_hpf_amp
		"Filtered ambient pressure value"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_mapc_hpf_amp 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mapc_hpf_map
		"Manifold pressure value measurement filtered"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_mapc_hpf_map 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_gbxlixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_agb_tqe
		"Maximum automatic gearbox torque."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_agb_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000777c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_avl_pow
		"Vxx_max_avl_pow"
		SWORD
		VA_F_10_p0_17
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd0001094 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_avl_pow_inc
		"Vxx_max_avl_pow_inc"
		SWORD
		VA_F_10_p0_17
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd0001096 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_avl_pow_rat
		"Vxx_max_avl_pow_rat"
		SBYTE
		VA_F_0v01_p0_25
		2
		100
		-1.28
		1.27
    ECU_ADDRESS 0xd0001d88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_max_avl_tqe
		"Maximum effective engine torque at current engine speed"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_avl_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_max_dyn_avl_tqe
		"Maximum available torque with dynamic limitation"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_dyn_avl_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_dyn_avl_tqi
		"Maximum indicated torque with dynamic limitation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_max_dyn_avl_tqi 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_forc
		"Longitudinal force equivalent to a 100% accelerator pedal demand"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_max_forc 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00049a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_gbxlixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_gbx_tqe
		"Maximum torque to project gearbox from mechanical overload."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_gbx_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000777a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_max_gear_avl_tqe
		"Maximal effective engine torque according to the gearbox ratio"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_gear_avl_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
