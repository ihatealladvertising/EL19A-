			fm_sta_emtv_reg_blk.Vxx_rdn_xxx
			fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_emtv_reg_blk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_emtv_reg_blk.Vxx_dtc_stt_xxx
			fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_emtv_reg_blk_open.Vxx_dfctr_xxx
			fm_sta_emtv_reg_blk_open.Vxx_rdn_xxx
			fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_emtv_reg_blk_open.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_emtv_reg_blk_open.Vxx_dtc_stt_xxx
			fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_emtv_reg_dirt.Vxx_dfctr_xxx
			fm_sta_emtv_reg_dirt.Vxx_rdn_xxx
			fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_emtv_reg_dirt.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_emtv_reg_dirt.Vxx_dtc_stt_xxx
			fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_esp_data_chr.Vxx_dfctr_xxx
			fm_sta_esp_data_chr.Vxx_rdn_xxx
			fm_sta_esp_data_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_esp_data_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_esp_data_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_esp_data_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_esp_data_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_esp_data_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_esp_data_seq_ctr.Vxx_dfctr_xxx
			fm_sta_esp_data_seq_ctr.Vxx_rdn_xxx
			fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_esp_data_seq_ctr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_esp_data_seq_ctr.Vxx_dtc_stt_xxx
			fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_esp_no_frm.Vxx_dfctr_xxx
			fm_sta_esp_no_frm.Vxx_rdn_xxx
			fm_sta_esp_no_frm.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_esp_no_frm.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_esp_no_frm.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_esp_no_frm.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_esp_no_frm.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_esp_no_frm.Vxx_dtc_stt_xxx
			fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ex_prs_no_lk.Vxx_dfctr_xxx
			fm_sta_ex_prs_no_lk.Vxx_rdn_xxx
			fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ex_prs_no_lk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ex_prs_no_lk.Vxx_dtc_stt_xxx
			fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ex_prs_nok.Vxx_dfctr_xxx
			fm_sta_ex_prs_nok.Vxx_rdn_xxx
			fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ex_prs_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ex_prs_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_actr_blk_clos.Vxx_dfctr_xxx
			fm_sta_ff_actr_blk_clos.Vxx_rdn_xxx
			fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_actr_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_actr_blk_clos.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_actr_blk_open.Vxx_dfctr_xxx
			fm_sta_ff_actr_blk_open.Vxx_rdn_xxx
			fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_actr_blk_open.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_actr_blk_open.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_actr_crt_down.Vxx_dfctr_xxx
			fm_sta_ff_actr_crt_down.Vxx_rdn_xxx
			fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_actr_crt_down.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_actr_crt_down.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_actr_crt_up.Vxx_dfctr_xxx
			fm_sta_ff_actr_crt_up.Vxx_rdn_xxx
			fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_actr_crt_up.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_actr_crt_up.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_actr_ovh.Vxx_dfctr_xxx
			fm_sta_ff_actr_ovh.Vxx_rdn_xxx
			fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_actr_ovh.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_actr_ovh.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_fct_chr.Vxx_dfctr_xxx
			fm_sta_ff_fct_chr.Vxx_rdn_xxx
			fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_fct_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_fct_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_fct_h_lvl.Vxx_dfctr_xxx
			fm_sta_ff_fct_h_lvl.Vxx_rdn_xxx
			fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_fct_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_fct_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_fct_l_lvl.Vxx_dfctr_xxx
			fm_sta_ff_fct_l_lvl.Vxx_rdn_xxx
			fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_fct_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_fct_l_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_fct_neg_err.Vxx_dfctr_xxx
			fm_sta_ff_fct_neg_err.Vxx_rdn_xxx
			fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_fct_neg_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_fct_neg_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ff_fct_pos_err.Vxx_dfctr_xxx
			fm_sta_ff_fct_pos_err.Vxx_rdn_xxx
			fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ff_fct_pos_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ff_fct_pos_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_actr_blk_clos.Vxx_dfctr_xxx
			fm_sta_fprs_actr_blk_clos.Vxx_rdn_xxx
			fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_actr_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_actr_blk_clos.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_actr_blk_open.Vxx_dfctr_xxx
			fm_sta_fprs_actr_blk_open.Vxx_rdn_xxx
			fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_actr_blk_open.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_actr_blk_open.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_actr_crt_down.Vxx_dfctr_xxx
			fm_sta_fprs_actr_crt_down.Vxx_rdn_xxx
			fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_actr_crt_down.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_actr_crt_down.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_actr_crt_up.Vxx_dfctr_xxx
			fm_sta_fprs_actr_crt_up.Vxx_rdn_xxx
			fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_actr_crt_up.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_actr_crt_up.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_actr_ovh.Vxx_dfctr_xxx
			fm_sta_fprs_actr_ovh.Vxx_rdn_xxx
			fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_actr_ovh.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_actr_ovh.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_fct_chr.Vxx_dfctr_xxx
			fm_sta_fprs_fct_chr.Vxx_rdn_xxx
			fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_fct_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_fct_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_fct_dirt_lkg.Vxx_dfctr_xxx
			fm_sta_fprs_fct_dirt_lkg.Vxx_rdn_xxx
			fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_fct_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_fct_dirt_lkg.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_fct_h_lvl.Vxx_dfctr_xxx
			fm_sta_fprs_fct_h_lvl.Vxx_rdn_xxx
			fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_fct_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_fct_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_fct_l_lvl.Vxx_dfctr_xxx
			fm_sta_fprs_fct_l_lvl.Vxx_rdn_xxx
			fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_fct_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_fct_l_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_fct_neg_err.Vxx_dfctr_xxx
			fm_sta_fprs_fct_neg_err.Vxx_rdn_xxx
			fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_fct_neg_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_fct_neg_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fprs_fct_pos_err.Vxx_dfctr_xxx
			fm_sta_fprs_fct_pos_err.Vxx_rdn_xxx
			fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fprs_fct_pos_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fprs_fct_pos_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fsys_apl_down.Vxx_dfctr_xxx
			fm_sta_fsys_apl_down.Vxx_rdn_xxx
			fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fsys_apl_down.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fsys_apl_down.Vxx_dtc_stt_xxx
			fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fsys_apl_up.Vxx_dfctr_xxx
			fm_sta_fsys_apl_up.Vxx_rdn_xxx
			fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fsys_apl_up.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fsys_apl_up.Vxx_dtc_stt_xxx
			fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fsys_h_lvl.Vxx_dfctr_xxx
			fm_sta_fsys_h_lvl.Vxx_rdn_xxx
			fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fsys_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fsys_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fuel_temp_h.Vxx_dfctr_xxx
			fm_sta_fuel_temp_h.Vxx_rdn_xxx
			fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fuel_temp_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fuel_temp_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_fuel_temp_l.Vxx_dfctr_xxx
			fm_sta_fuel_temp_l.Vxx_rdn_xxx
			fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_fuel_temp_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_fuel_temp_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_glow_cmd_fail.Vxx_dfctr_xxx
			fm_sta_glow_cmd_fail.Vxx_rdn_xxx
			fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_glow_cmd_fail.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_glow_cmd_fail.Vxx_dtc_stt_xxx
			fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_glow_cmd_oc.Vxx_dfctr_xxx
			fm_sta_glow_cmd_oc.Vxx_rdn_xxx
			fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_glow_cmd_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_glow_cmd_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_glow_cmd_scg.Vxx_dfctr_xxx
			fm_sta_glow_cmd_scg.Vxx_rdn_xxx
			fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_glow_cmd_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_glow_cmd_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_glow_cmd_scw.Vxx_dfctr_xxx
			fm_sta_glow_cmd_scw.Vxx_rdn_xxx
			fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_glow_cmd_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_glow_cmd_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_in_cam_chr.Vxx_dfctr_xxx
			fm_sta_in_cam_chr.Vxx_rdn_xxx
			fm_sta_in_cam_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_in_cam_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_in_cam_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_in_cam_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_in_cam_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_in_cam_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_in_cam_crk_cmp.Vxx_dfctr_xxx
			fm_sta_in_cam_crk_cmp.Vxx_rdn_xxx
			fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_in_cam_crk_cmp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_in_cam_crk_cmp.Vxx_dtc_stt_xxx
			fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_in_cam_cyc.Vxx_dfctr_xxx
			fm_sta_in_cam_cyc.Vxx_rdn_xxx
			fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_in_cam_cyc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_in_cam_cyc.Vxx_dtc_stt_xxx
			fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_in_cam_no_sig.Vxx_dfctr_xxx
			fm_sta_in_cam_no_sig.Vxx_rdn_xxx
			fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_in_cam_no_sig.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_in_cam_no_sig.Vxx_dtc_stt_xxx
			fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_in_cam_nok.Vxx_dfctr_xxx
			fm_sta_in_cam_nok.Vxx_rdn_xxx
			fm_sta_in_cam_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_in_cam_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_in_cam_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_in_cam_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_in_cam_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_in_cam_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_chk_sum.Vxx_dfctr_xxx
			fm_sta_inj1_chk_sum.Vxx_rdn_xxx
			fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_chk_sum.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_crt_intv.Vxx_dfctr_xxx
			fm_sta_inj1_crt_intv.Vxx_rdn_xxx
			fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_crt_intv.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_h_lvl.Vxx_dfctr_xxx
			fm_sta_inj1_h_lvl.Vxx_rdn_xxx
			fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_h_puls.Vxx_dfctr_xxx
			fm_sta_inj1_h_puls.Vxx_rdn_xxx
			fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_h_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_h_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_l_lvl.Vxx_dfctr_xxx
			fm_sta_inj1_l_lvl.Vxx_rdn_xxx
			fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_l_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_l_puls.Vxx_dfctr_xxx
			fm_sta_inj1_l_puls.Vxx_rdn_xxx
			fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_l_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_l_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_nok.Vxx_dfctr_xxx
			fm_sta_inj1_nok.Vxx_rdn_xxx
			fm_sta_inj1_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_oc.Vxx_dfctr_xxx
			fm_sta_inj1_oc.Vxx_rdn_xxx
			fm_sta_inj1_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj1_shp.Vxx_dfctr_xxx
			fm_sta_inj1_shp.Vxx_rdn_xxx
			fm_sta_inj1_shp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj1_shp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj1_shp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj1_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj1_shp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj1_shp.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_chk_sum.Vxx_dfctr_xxx
			fm_sta_inj2_chk_sum.Vxx_rdn_xxx
			fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_chk_sum.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_crt_intv.Vxx_dfctr_xxx
			fm_sta_inj2_crt_intv.Vxx_rdn_xxx
			fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_crt_intv.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_h_lvl.Vxx_dfctr_xxx
			fm_sta_inj2_h_lvl.Vxx_rdn_xxx
			fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_h_puls.Vxx_dfctr_xxx
			fm_sta_inj2_h_puls.Vxx_rdn_xxx
			fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_h_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_h_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_l_lvl.Vxx_dfctr_xxx
			fm_sta_inj2_l_lvl.Vxx_rdn_xxx
			fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_l_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_l_puls.Vxx_dfctr_xxx
			fm_sta_inj2_l_puls.Vxx_rdn_xxx
			fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_l_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_l_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_nok.Vxx_dfctr_xxx
			fm_sta_inj2_nok.Vxx_rdn_xxx
			fm_sta_inj2_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_oc.Vxx_dfctr_xxx
			fm_sta_inj2_oc.Vxx_rdn_xxx
			fm_sta_inj2_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj2_shp.Vxx_dfctr_xxx
			fm_sta_inj2_shp.Vxx_rdn_xxx
			fm_sta_inj2_shp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj2_shp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj2_shp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj2_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj2_shp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj2_shp.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_chk_sum.Vxx_dfctr_xxx
			fm_sta_inj3_chk_sum.Vxx_rdn_xxx
			fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_chk_sum.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_crt_intv.Vxx_dfctr_xxx
			fm_sta_inj3_crt_intv.Vxx_rdn_xxx
			fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_crt_intv.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_h_lvl.Vxx_dfctr_xxx
			fm_sta_inj3_h_lvl.Vxx_rdn_xxx
			fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_h_puls.Vxx_dfctr_xxx
			fm_sta_inj3_h_puls.Vxx_rdn_xxx
			fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_h_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_h_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_l_lvl.Vxx_dfctr_xxx
			fm_sta_inj3_l_lvl.Vxx_rdn_xxx
			fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_l_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_l_puls.Vxx_dfctr_xxx
			fm_sta_inj3_l_puls.Vxx_rdn_xxx
			fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_l_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_l_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_nok.Vxx_dfctr_xxx
			fm_sta_inj3_nok.Vxx_rdn_xxx
			fm_sta_inj3_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_oc.Vxx_dfctr_xxx
			fm_sta_inj3_oc.Vxx_rdn_xxx
			fm_sta_inj3_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj3_shp.Vxx_dfctr_xxx
			fm_sta_inj3_shp.Vxx_rdn_xxx
			fm_sta_inj3_shp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj3_shp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj3_shp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj3_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj3_shp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj3_shp.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_chk_sum.Vxx_dfctr_xxx
			fm_sta_inj4_chk_sum.Vxx_rdn_xxx
			fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_chk_sum.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_chk_sum.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_crt_intv.Vxx_dfctr_xxx
			fm_sta_inj4_crt_intv.Vxx_rdn_xxx
			fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_crt_intv.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_crt_intv.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_h_lvl.Vxx_dfctr_xxx
			fm_sta_inj4_h_lvl.Vxx_rdn_xxx
			fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_h_puls.Vxx_dfctr_xxx
			fm_sta_inj4_h_puls.Vxx_rdn_xxx
			fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_h_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_h_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_l_lvl.Vxx_dfctr_xxx
			fm_sta_inj4_l_lvl.Vxx_rdn_xxx
			fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_l_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_l_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_l_puls.Vxx_dfctr_xxx
			fm_sta_inj4_l_puls.Vxx_rdn_xxx
			fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_l_puls.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_l_puls.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_nok.Vxx_dfctr_xxx
			fm_sta_inj4_nok.Vxx_rdn_xxx
			fm_sta_inj4_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_oc.Vxx_dfctr_xxx
			fm_sta_inj4_oc.Vxx_rdn_xxx
			fm_sta_inj4_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj4_shp.Vxx_dfctr_xxx
			fm_sta_inj4_shp.Vxx_rdn_xxx
			fm_sta_inj4_shp.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj4_shp.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj4_shp.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj4_shp.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj4_shp.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj4_shp.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj_cpt_blk.Vxx_dfctr_xxx
			fm_sta_inj_cpt_blk.Vxx_rdn_xxx
			fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj_cpt_blk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj_cpt_blk.Vxx_dtc_stt_xxx
			fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_inj_oor.Vxx_dfctr_xxx
			fm_sta_inj_oor.Vxx_rdn_xxx
			fm_sta_inj_oor.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_inj_oor.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_inj_oor.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_inj_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_inj_oor.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_inj_oor.Vxx_dtc_stt_xxx
			fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ip_lght_tco_ovh.Vxx_dfctr_xxx
			fm_sta_ip_lght_tco_ovh.Vxx_rdn_xxx
			fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ip_lght_tco_ovh.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ip_lght_tco_ovh.Vxx_dtc_stt_xxx
			fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_it_hbdg_el.Vxx_dfctr_xxx
			fm_sta_it_hbdg_el.Vxx_rdn_xxx
			fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_it_hbdg_el.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_it_hbdg_el.Vxx_dtc_stt_xxx
			fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_it_hbdg_ovh.Vxx_dfctr_xxx
			fm_sta_it_hbdg_ovh.Vxx_rdn_xxx
			fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_it_hbdg_ovh.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_it_hbdg_ovh.Vxx_dtc_stt_xxx
			fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_it_ofs_no_norm.Vxx_dfctr_xxx
			fm_sta_it_ofs_no_norm.Vxx_rdn_xxx
			fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_it_ofs_no_norm.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_it_ofs_no_norm.Vxx_dtc_stt_xxx
			fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_it_reg_blk.Vxx_dfctr_xxx
			fm_sta_it_reg_blk.Vxx_rdn_xxx
			fm_sta_it_reg_blk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_it_reg_blk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_it_reg_blk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_it_reg_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_it_reg_blk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_it_reg_blk.Vxx_dtc_stt_xxx
			fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_it_reg_blk_clos.Vxx_dfctr_xxx
			fm_sta_it_reg_blk_clos.Vxx_rdn_xxx
			fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_it_reg_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_it_reg_blk_clos.Vxx_dtc_stt_xxx
			fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_it_reg_blk_open.Vxx_dfctr_xxx
			fm_sta_it_reg_blk_open.Vxx_rdn_xxx
			fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_it_reg_blk_open.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_it_reg_blk_open.Vxx_dtc_stt_xxx
			fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_it_reg_dirt.Vxx_dfctr_xxx
			fm_sta_it_reg_dirt.Vxx_rdn_xxx
			fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_it_reg_dirt.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_it_reg_dirt.Vxx_dtc_stt_xxx
			fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_maf_reg_neg_err.Vxx_dfctr_xxx
			fm_sta_maf_reg_neg_err.Vxx_rdn_xxx
			fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_maf_reg_neg_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_maf_reg_neg_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_mafs_apl_down.Vxx_dfctr_xxx
			fm_sta_mafs_apl_down.Vxx_rdn_xxx
			fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_mafs_apl_down.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_mafs_apl_down.Vxx_dtc_stt_xxx
			fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_mafs_apl_up.Vxx_dfctr_xxx
			fm_sta_mafs_apl_up.Vxx_rdn_xxx
			fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_mafs_apl_up.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_mafs_apl_up.Vxx_dtc_stt_xxx
			fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_map_nok.Vxx_dfctr_xxx
			fm_sta_map_nok.Vxx_rdn_xxx
			fm_sta_map_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_map_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_map_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_map_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_map_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_map_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_oil_dil_nok.Vxx_dfctr_xxx
			fm_sta_oil_dil_nok.Vxx_rdn_xxx
			fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_oil_dil_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_oil_dil_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_dirt.Vxx_dfctr_xxx
			fm_sta_pft_dirt.Vxx_rdn_xxx
			fm_sta_pft_dirt.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_dirt.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_dirt.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_dirt.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_dirt.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_dirt_lkg.Vxx_dfctr_xxx
			fm_sta_pft_dirt_lkg.Vxx_rdn_xxx
			fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_dirt_lkg.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_no_lk.Vxx_dfctr_xxx
			fm_sta_pft_no_lk.Vxx_rdn_xxx
			fm_sta_pft_no_lk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_no_lk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_no_lk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_no_lk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_no_lk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_no_lk.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_nok_cge.Vxx_dfctr_xxx
			fm_sta_pft_nok_cge.Vxx_rdn_xxx
			fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_nok_cge.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_nok_cge.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_rgn_dirt.Vxx_dfctr_xxx
			fm_sta_pft_rgn_dirt.Vxx_rdn_xxx
			fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_rgn_dirt.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_rgn_dirt.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_utp_chr.Vxx_dfctr_xxx
			fm_sta_pft_utp_chr.Vxx_rdn_xxx
			fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_utp_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_utp_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_utp_h.Vxx_dfctr_xxx
			fm_sta_pft_utp_h.Vxx_rdn_xxx
			fm_sta_pft_utp_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_utp_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_utp_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_utp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_utp_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_utp_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_utp_l.Vxx_dfctr_xxx
			fm_sta_pft_utp_l.Vxx_rdn_xxx
			fm_sta_pft_utp_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_utp_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_utp_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_utp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_utp_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_utp_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_utp_neg_err.Vxx_dfctr_xxx
			fm_sta_pft_utp_neg_err.Vxx_rdn_xxx
			fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_utp_neg_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_utp_neg_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pft_utp_pos_err.Vxx_dfctr_xxx
			fm_sta_pft_utp_pos_err.Vxx_rdn_xxx
			fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pft_utp_pos_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pft_utp_pos_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pws_1_h.Vxx_dfctr_xxx
			fm_sta_pws_1_h.Vxx_rdn_xxx
			fm_sta_pws_1_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pws_1_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pws_1_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pws_1_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pws_1_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pws_1_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pws_1_l.Vxx_dfctr_xxx
			fm_sta_pws_1_l.Vxx_rdn_xxx
			fm_sta_pws_1_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pws_1_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pws_1_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pws_1_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pws_1_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pws_1_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pws_2_h.Vxx_dfctr_xxx
			fm_sta_pws_2_h.Vxx_rdn_xxx
			fm_sta_pws_2_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pws_2_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pws_2_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pws_2_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pws_2_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pws_2_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pws_2_l.Vxx_dfctr_xxx
			fm_sta_pws_2_l.Vxx_rdn_xxx
			fm_sta_pws_2_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pws_2_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pws_2_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pws_2_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pws_2_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pws_2_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pws_3_h.Vxx_dfctr_xxx
			fm_sta_pws_3_h.Vxx_rdn_xxx
			fm_sta_pws_3_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pws_3_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pws_3_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pws_3_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pws_3_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pws_3_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_pws_3_l.Vxx_dfctr_xxx
			fm_sta_pws_3_l.Vxx_rdn_xxx
			fm_sta_pws_3_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_pws_3_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_pws_3_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_pws_3_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_pws_3_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_pws_3_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_rail_prs_h.Vxx_dfctr_xxx
			fm_sta_rail_prs_h.Vxx_rdn_xxx
			fm_sta_rail_prs_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_rail_prs_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_rail_prs_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_rail_prs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_rail_prs_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_rail_prs_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_rail_prs_h_lvl.Vxx_dfctr_xxx
			fm_sta_rail_prs_h_lvl.Vxx_rdn_xxx
			fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_rail_prs_h_lvl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_rail_prs_h_lvl.Vxx_dtc_stt_xxx
			fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_rail_prs_l.Vxx_dfctr_xxx
			fm_sta_rail_prs_l.Vxx_rdn_xxx
			fm_sta_rail_prs_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_rail_prs_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_rail_prs_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_rail_prs_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_rail_prs_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_rail_prs_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_rail_prs_plaus.Vxx_dfctr_xxx
			fm_sta_rail_prs_plaus.Vxx_rdn_xxx
			fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_rail_prs_plaus.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_rail_prs_plaus.Vxx_dtc_stt_xxx
			fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_rail_prs_sig_mcut.Vxx_dfctr_xxx
			fm_sta_rail_prs_sig_mcut.Vxx_rdn_xxx
			fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_rail_prs_sig_mcut.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_rail_prs_sig_mcut.Vxx_dtc_stt_xxx
			fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_rup_dirt_lkg.Vxx_dfctr_xxx
			fm_sta_rup_dirt_lkg.Vxx_rdn_xxx
			fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_rup_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_rup_dirt_lkg.Vxx_dtc_stt_xxx
			fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_rup_nok.Vxx_dfctr_xxx
			fm_sta_rup_nok.Vxx_rdn_xxx
			fm_sta_rup_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_rup_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_rup_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_rup_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_rup_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_rup_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_amp_h.Vxx_dfctr_xxx
			fm_sta_sens_amp_h.Vxx_rdn_xxx
			fm_sta_sens_amp_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_amp_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_amp_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_amp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_amp_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_amp_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_amp_l.Vxx_dfctr_xxx
			fm_sta_sens_amp_l.Vxx_rdn_xxx
			fm_sta_sens_amp_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_amp_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_amp_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_amp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_amp_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_amp_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_egr_temp_h.Vxx_dfctr_xxx
			fm_sta_sens_egr_temp_h.Vxx_rdn_xxx
			fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_egr_temp_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_egr_temp_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_egr_temp_l.Vxx_dfctr_xxx
			fm_sta_sens_egr_temp_l.Vxx_rdn_xxx
			fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_egr_temp_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_egr_temp_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_emtv_nok.Vxx_dfctr_xxx
			fm_sta_sens_emtv_nok.Vxx_rdn_xxx
			fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_emtv_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_emtv_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ex_prs_h.Vxx_dfctr_xxx
			fm_sta_sens_ex_prs_h.Vxx_rdn_xxx
			fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ex_prs_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ex_prs_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ex_prs_l.Vxx_dfctr_xxx
			fm_sta_sens_ex_prs_l.Vxx_rdn_xxx
			fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ex_prs_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ex_prs_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_it_nok.Vxx_dfctr_xxx
			fm_sta_sens_it_nok.Vxx_rdn_xxx
			fm_sta_sens_it_nok.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_it_nok.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_it_nok.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_it_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_it_nok.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_it_nok.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_maf_h.Vxx_dfctr_xxx
			fm_sta_sens_maf_h.Vxx_rdn_xxx
			fm_sta_sens_maf_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_maf_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_maf_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_maf_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_maf_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_maf_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_maf_l.Vxx_dfctr_xxx
			fm_sta_sens_maf_l.Vxx_rdn_xxx
			fm_sta_sens_maf_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_maf_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_maf_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_maf_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_maf_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_maf_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_map_h.Vxx_dfctr_xxx
			fm_sta_sens_map_h.Vxx_rdn_xxx
			fm_sta_sens_map_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_map_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_map_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_map_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_map_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_map_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_map_l.Vxx_dfctr_xxx
			fm_sta_sens_map_l.Vxx_rdn_xxx
			fm_sta_sens_map_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_map_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_map_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_map_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_map_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_map_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_rup_h.Vxx_dfctr_xxx
			fm_sta_sens_rup_h.Vxx_rdn_xxx
			fm_sta_sens_rup_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_rup_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_rup_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_rup_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_rup_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_rup_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_rup_l.Vxx_dfctr_xxx
			fm_sta_sens_rup_l.Vxx_rdn_xxx
			fm_sta_sens_rup_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_rup_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_rup_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_rup_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_rup_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_rup_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_tco_h.Vxx_dfctr_xxx
			fm_sta_sens_tco_h.Vxx_rdn_xxx
			fm_sta_sens_tco_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_tco_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_tco_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_tco_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_tco_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_tco_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_tco_l.Vxx_dfctr_xxx
			fm_sta_sens_tco_l.Vxx_rdn_xxx
			fm_sta_sens_tco_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_tco_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_tco_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_tco_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_tco_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_tco_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_tco_sig_mcut.Vxx_dfctr_xxx
			fm_sta_sens_tco_sig_mcut.Vxx_rdn_xxx
			fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_tco_sig_mcut.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_tco_sig_mcut.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_tia_h.Vxx_dfctr_xxx
			fm_sta_sens_tia_h.Vxx_rdn_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_tia_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_tia_l.Vxx_dfctr_xxx
			fm_sta_sens_tia_l.Vxx_rdn_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_tia_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_heat_oc.Vxx_dfctr_xxx
			fm_sta_sens_ups_heat_oc.Vxx_rdn_xxx
			fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_heat_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_heat_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_heat_ovh.Vxx_dfctr_xxx
			fm_sta_sens_ups_heat_ovh.Vxx_rdn_xxx
			fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_heat_ovh.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_heat_ovh.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_heat_scg.Vxx_dfctr_xxx
			fm_sta_sens_ups_heat_scg.Vxx_rdn_xxx
			fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_heat_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_heat_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_heat_scw.Vxx_dfctr_xxx
			fm_sta_sens_ups_heat_scw.Vxx_rdn_xxx
			fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_heat_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_heat_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_lamb_oc.Vxx_dfctr_xxx
			fm_sta_sens_ups_lamb_oc.Vxx_rdn_xxx
			fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_lamb_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_lamb_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_pump_oc.Vxx_dfctr_xxx
			fm_sta_sens_ups_pump_oc.Vxx_rdn_xxx
			fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_pump_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_pump_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_virt_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_virt_oc.Vxx_dfctr_xxx
			fm_sta_sens_ups_virt_oc.Vxx_rdn_xxx
			fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_virt_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_virt_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_wire_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_wire_scg.Vxx_dfctr_xxx
			fm_sta_sens_ups_wire_scg.Vxx_rdn_xxx
			fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_wire_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_wire_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_ups_wire_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_ups_wire_scw.Vxx_dfctr_xxx
			fm_sta_sens_ups_wire_scw.Vxx_rdn_xxx
			fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_ups_wire_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_ups_wire_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_wfl_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_wfl_oc.Vxx_dfctr_xxx
			fm_sta_sens_wfl_oc.Vxx_rdn_xxx
			fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_wfl_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_wfl_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sfty_tq_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sfty_tq_chr.Vxx_dfctr_xxx
			fm_sta_sfty_tq_chr.Vxx_rdn_xxx
			fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sfty_tq_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sfty_tq_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sfty_tq_clc_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sfty_tq_clc_chr.Vxx_dfctr_xxx
			fm_sta_sfty_tq_clc_chr.Vxx_rdn_xxx
			fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sfty_tq_clc_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sfty_tq_clc_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sfty_tq_fail.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sfty_tq_fail.Vxx_dfctr_xxx
			fm_sta_sfty_tq_fail.Vxx_rdn_xxx
			fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sfty_tq_fail.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sfty_tq_fail.Vxx_dtc_stt_xxx
			fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sfty_tq_supl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sfty_tq_supl.Vxx_dfctr_xxx
			fm_sta_sfty_tq_supl.Vxx_rdn_xxx
			fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sfty_tq_supl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sfty_tq_supl.Vxx_dtc_stt_xxx
			fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_spg_cmd_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_spg_cmd_blk_clos.Vxx_dfctr_xxx
			fm_sta_spg_cmd_blk_clos.Vxx_rdn_xxx
			fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_spg_cmd_blk_clos.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_spg_cmd_blk_clos.Vxx_dtc_stt_xxx
			fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_spg_reg_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_spg_reg_apl_down.Vxx_dfctr_xxx
			fm_sta_spg_reg_apl_down.Vxx_rdn_xxx
			fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_spg_reg_apl_down.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_spg_reg_apl_down.Vxx_dtc_stt_xxx
			fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_spg_reg_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_spg_reg_apl_up.Vxx_dfctr_xxx
			fm_sta_spg_reg_apl_up.Vxx_rdn_xxx
			fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_spg_reg_apl_up.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_spg_reg_apl_up.Vxx_dtc_stt_xxx
			fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tbf_fct_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tbf_fct_apl_down.Vxx_dfctr_xxx
			fm_sta_tbf_fct_apl_down.Vxx_rdn_xxx
			fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tbf_fct_apl_down.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tbf_fct_apl_down.Vxx_dtc_stt_xxx
			fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tbf_fct_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tbf_fct_apl_up.Vxx_dfctr_xxx
			fm_sta_tbf_fct_apl_up.Vxx_rdn_xxx
			fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tbf_fct_apl_up.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tbf_fct_apl_up.Vxx_dtc_stt_xxx
			fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tbt_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tbt_chr.Vxx_dfctr_xxx
			fm_sta_tbt_chr.Vxx_rdn_xxx
			fm_sta_tbt_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tbt_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tbt_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tbt_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tbt_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tbt_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tbt_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tbt_h.Vxx_dfctr_xxx
			fm_sta_tbt_h.Vxx_rdn_xxx
			fm_sta_tbt_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tbt_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tbt_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tbt_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tbt_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tbt_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tbt_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tbt_l.Vxx_dfctr_xxx
			fm_sta_tbt_l.Vxx_rdn_xxx
			fm_sta_tbt_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tbt_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tbt_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tbt_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tbt_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tbt_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tbt_reg_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tbt_reg_apl_up.Vxx_dfctr_xxx
			fm_sta_tbt_reg_apl_up.Vxx_rdn_xxx
			fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tbt_reg_apl_up.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tbt_reg_apl_up.Vxx_dtc_stt_xxx
			fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tbt_reg_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tbt_reg_neg_err.Vxx_dfctr_xxx
			fm_sta_tbt_reg_neg_err.Vxx_rdn_xxx
			fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tbt_reg_neg_err.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tbt_reg_neg_err.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd1_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd1_oc.Vxx_dfctr_xxx
			fm_sta_thpl_cmd1_oc.Vxx_rdn_xxx
			fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd1_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd1_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd1_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd1_scg.Vxx_dfctr_xxx
			fm_sta_thpl_cmd1_scg.Vxx_rdn_xxx
			fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd1_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd1_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd1_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd1_scw.Vxx_dfctr_xxx
			fm_sta_thpl_cmd1_scw.Vxx_rdn_xxx
			fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd1_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd1_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd2_oc.Vxx_dfctr_xxx
			fm_sta_thpl_cmd2_oc.Vxx_rdn_xxx
			fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd2_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd2_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd2_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd2_scg.Vxx_dfctr_xxx
			fm_sta_thpl_cmd2_scg.Vxx_rdn_xxx
			fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd2_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd2_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd2_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd2_scw.Vxx_dfctr_xxx
			fm_sta_thpl_cmd2_scw.Vxx_rdn_xxx
			fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd2_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd2_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd3_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd3_oc.Vxx_dfctr_xxx
			fm_sta_thpl_cmd3_oc.Vxx_rdn_xxx
			fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd3_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd3_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd3_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd3_scg.Vxx_dfctr_xxx
			fm_sta_thpl_cmd3_scg.Vxx_rdn_xxx
			fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd3_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd3_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_thpl_cmd3_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_thpl_cmd3_scw.Vxx_dfctr_xxx
			fm_sta_thpl_cmd3_scw.Vxx_rdn_xxx
			fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_thpl_cmd3_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_thpl_cmd3_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_tqi_cor_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_tqi_cor_chr.Vxx_dfctr_xxx
			fm_sta_tqi_cor_chr.Vxx_rdn_xxx
			fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_tqi_cor_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_tqi_cor_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_unk_thpl1_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_unk_thpl1_chr.Vxx_dfctr_xxx
			fm_sta_unk_thpl1_chr.Vxx_rdn_xxx
			fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_unk_thpl1_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_unk_thpl1_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_unk_thpl2_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_unk_thpl2_chr.Vxx_dfctr_xxx
			fm_sta_unk_thpl2_chr.Vxx_rdn_xxx
			fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_unk_thpl2_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_unk_thpl2_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_unk_thpl3_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_unk_thpl3_chr.Vxx_dfctr_xxx
			fm_sta_unk_thpl3_chr.Vxx_rdn_xxx
			fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_unk_thpl3_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_unk_thpl3_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_unk_thpl4_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_unk_thpl4_chr.Vxx_dfctr_xxx
			fm_sta_unk_thpl4_chr.Vxx_rdn_xxx
			fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_unk_thpl4_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_unk_thpl4_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_unk_thpl_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_unk_thpl_chr.Vxx_dfctr_xxx
			fm_sta_unk_thpl_chr.Vxx_rdn_xxx
			fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_unk_thpl_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_unk_thpl_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ups_ecu_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ups_ecu_chr.Vxx_dfctr_xxx
			fm_sta_ups_ecu_chr.Vxx_rdn_xxx
			fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ups_ecu_chr.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ups_ecu_chr.Vxx_dtc_stt_xxx
			fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ups_ecu_itl.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ups_ecu_itl.Vxx_dfctr_xxx
			fm_sta_ups_ecu_itl.Vxx_rdn_xxx
			fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ups_ecu_itl.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ups_ecu_itl.Vxx_dtc_stt_xxx
			fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ups_ecu_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ups_ecu_oor.Vxx_dfctr_xxx
			fm_sta_ups_ecu_oor.Vxx_rdn_xxx
			fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ups_ecu_oor.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ups_ecu_oor.Vxx_dtc_stt_xxx
			fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ups_ro2_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ups_ro2_oor.Vxx_dfctr_xxx
			fm_sta_ups_ro2_oor.Vxx_rdn_xxx
			fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ups_ro2_oor.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ups_ro2_oor.Vxx_dtc_stt_xxx
			fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ups_ro2_slow_trs.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ups_ro2_slow_trs.Vxx_dfctr_xxx
			fm_sta_ups_ro2_slow_trs.Vxx_rdn_xxx
			fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ups_ro2_slow_trs.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ups_ro2_slow_trs.Vxx_dtc_stt_xxx
			fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ups_tip_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ups_tip_oor.Vxx_dfctr_xxx
			fm_sta_ups_tip_oor.Vxx_rdn_xxx
			fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ups_tip_oor.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ups_tip_oor.Vxx_dtc_stt_xxx
			fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_ups_uo2_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_ups_uo2_oor.Vxx_dfctr_xxx
			fm_sta_ups_uo2_oor.Vxx_rdn_xxx
			fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_ups_uo2_oor.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_ups_uo2_oor.Vxx_dtc_stt_xxx
			fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_vb_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_vb_h.Vxx_dfctr_xxx
			fm_sta_vb_h.Vxx_rdn_xxx
			fm_sta_vb_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_vb_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_vb_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_vb_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_vb_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_vb_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_vb_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_vb_l.Vxx_dfctr_xxx
			fm_sta_vb_l.Vxx_rdn_xxx
			fm_sta_vb_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_vb_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_vb_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_vb_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_vb_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_vb_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_vb_rly_oc_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_vb_rly_oc_scg.Vxx_dfctr_xxx
			fm_sta_vb_rly_oc_scg.Vxx_rdn_xxx
			fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_vb_rly_oc_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_vb_rly_oc_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_vb_rly_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_vb_rly_scw.Vxx_dfctr_xxx
			fm_sta_vb_rly_scw.Vxx_rdn_xxx
			fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_vb_rly_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_vb_rly_scw.Vxx_dtc_stt_xxx
			fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_vnt_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_vnt_h.Vxx_dfctr_xxx
			fm_sta_vnt_h.Vxx_rdn_xxx
			fm_sta_vnt_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_vnt_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_vnt_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_vnt_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_vnt_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_vnt_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_vnt_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_vnt_l.Vxx_dfctr_xxx
			fm_sta_vnt_l.Vxx_rdn_xxx
			fm_sta_vnt_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_vnt_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_vnt_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_vnt_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_vnt_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_vnt_l.Vxx_dtc_stt_xxx
			fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_wpmp_tcr_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_wpmp_tcr_blk.Vxx_dfctr_xxx
			fm_sta_wpmp_tcr_blk.Vxx_rdn_xxx
			fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_wpmp_tcr_blk.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_wpmp_tcr_blk.Vxx_dtc_stt_xxx
			fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_wpmp_tcr_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_wpmp_tcr_oc.Vxx_dfctr_xxx
			fm_sta_wpmp_tcr_oc.Vxx_rdn_xxx
			fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_wpmp_tcr_oc.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_wpmp_tcr_oc.Vxx_dtc_stt_xxx
			fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_wpmp_tcr_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_wpmp_tcr_scg.Vxx_dfctr_xxx
			fm_sta_wpmp_tcr_scg.Vxx_rdn_xxx
			fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_wpmp_tcr_scg.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_wpmp_tcr_scg.Vxx_dtc_stt_xxx
			fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_wpmp_tcr_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_wpmp_tcr_scw.Vxx_dfctr_xxx
			fm_sta_wpmp_tcr_scw.Vxx_rdn_xxx
			fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_wpmp_tcr_scw.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_wpmp_tcr_scw.Vxx_dtc_stt_xxx
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'DgDftMng_Rdnheat' */
	/* ASAP2::Database : delete 'DgDftMng_Rdnevap' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin SUB_FUNCTION
			DgDftMng_Failmgt
			DgDftMng_Svcecom
			DgDftMng_Obdfram
			DgDftMng_Rdnmgtx
			DgDftMng_Rdncata
			DgDftMng_Rdnpftx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin FUNCTION
		DgDftMng_Failmgt
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dyn_thd
			Cxx_obd_dc_off
			Cxx_obd_wup_thd
			Cxx_wup_dif_thd_tco
			Cxx_wup_thd_tco
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			fm_dyn_eprm[0].Stx_dist_fail_dyn
			fm_dyn_eprm[0].Stx_tmp_dist_dyn
			fm_dyn_eprm[0].Stx_km_cf_dyn
			fm_dyn_eprm[0].Stx_km_mf_dyn
			fm_dyn_eprm[0].Stx_km_pass_dyn
			fm_dyn_eprm[0].Stx_ind_dyn
			fm_dyn_eprm[0].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[0].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[0].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[0].Stx_ffm_n_dyn
			fm_dyn_eprm[0].Stx_ffm_n_min_dyn
			fm_dyn_eprm[0].Stx_ffm_n_max_dyn
			fm_dyn_eprm[0].Stx_ffm_tco_dyn
			fm_dyn_eprm[0].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[0].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[0].Stx_ffm_vb_dyn
			fm_dyn_eprm[0].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[0].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[0].Stx_ffm_vs_dyn
			fm_dyn_eprm[0].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[0].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[0].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[0].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[0].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[0].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[0].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[0].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[0].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[0].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[0].Stx_obd_wctr_dyn
			fm_dyn_eprm[0].Stx_frq_dyn
			fm_dyn_eprm[0].Stx_obd_clfctr_dyn
			fm_dyn_eprm[0].Stx_esd_siz_dyn
			fm_dyn_eprm[0].Stx_pri_dyn
			fm_dyn_eprm[1].Stx_dist_fail_dyn
			fm_dyn_eprm[1].Stx_tmp_dist_dyn
			fm_dyn_eprm[1].Stx_km_cf_dyn
			fm_dyn_eprm[1].Stx_km_mf_dyn
			fm_dyn_eprm[1].Stx_km_pass_dyn
			fm_dyn_eprm[1].Stx_ind_dyn
			fm_dyn_eprm[1].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[1].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[1].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[1].Stx_ffm_n_dyn
			fm_dyn_eprm[1].Stx_ffm_n_min_dyn
			fm_dyn_eprm[1].Stx_ffm_n_max_dyn
			fm_dyn_eprm[1].Stx_ffm_tco_dyn
			fm_dyn_eprm[1].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[1].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[1].Stx_ffm_vb_dyn
			fm_dyn_eprm[1].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[1].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[1].Stx_ffm_vs_dyn
			fm_dyn_eprm[1].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[1].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[1].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[1].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[1].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[1].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[1].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[1].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[1].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[1].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[1].Stx_obd_wctr_dyn
			fm_dyn_eprm[1].Stx_frq_dyn
			fm_dyn_eprm[1].Stx_obd_clfctr_dyn
			fm_dyn_eprm[1].Stx_esd_siz_dyn
			fm_dyn_eprm[1].Stx_pri_dyn
			fm_dyn_eprm[2].Stx_dist_fail_dyn
			fm_dyn_eprm[2].Stx_tmp_dist_dyn
			fm_dyn_eprm[2].Stx_km_cf_dyn
			fm_dyn_eprm[2].Stx_km_mf_dyn
			fm_dyn_eprm[2].Stx_km_pass_dyn
			fm_dyn_eprm[2].Stx_ind_dyn
			fm_dyn_eprm[2].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[2].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[2].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[2].Stx_ffm_n_dyn
			fm_dyn_eprm[2].Stx_ffm_n_min_dyn
			fm_dyn_eprm[2].Stx_ffm_n_max_dyn
			fm_dyn_eprm[2].Stx_ffm_tco_dyn
			fm_dyn_eprm[2].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[2].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[2].Stx_ffm_vb_dyn
			fm_dyn_eprm[2].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[2].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[2].Stx_ffm_vs_dyn
			fm_dyn_eprm[2].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[2].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[2].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[2].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[2].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[2].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[2].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[2].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[2].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[2].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[2].Stx_obd_wctr_dyn
			fm_dyn_eprm[2].Stx_frq_dyn
			fm_dyn_eprm[2].Stx_obd_clfctr_dyn
			fm_dyn_eprm[2].Stx_esd_siz_dyn
			fm_dyn_eprm[2].Stx_pri_dyn
			fm_dyn_eprm[3].Stx_dist_fail_dyn
			fm_dyn_eprm[3].Stx_tmp_dist_dyn
			fm_dyn_eprm[3].Stx_km_cf_dyn
			fm_dyn_eprm[3].Stx_km_mf_dyn
			fm_dyn_eprm[3].Stx_km_pass_dyn
			fm_dyn_eprm[3].Stx_ind_dyn
			fm_dyn_eprm[3].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[3].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[3].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[3].Stx_ffm_n_dyn
			fm_dyn_eprm[3].Stx_ffm_n_min_dyn
			fm_dyn_eprm[3].Stx_ffm_n_max_dyn
			fm_dyn_eprm[3].Stx_ffm_tco_dyn
			fm_dyn_eprm[3].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[3].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[3].Stx_ffm_vb_dyn
			fm_dyn_eprm[3].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[3].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[3].Stx_ffm_vs_dyn
			fm_dyn_eprm[3].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[3].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[3].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[3].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[3].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[3].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[3].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[3].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[3].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[3].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[3].Stx_obd_wctr_dyn
			fm_dyn_eprm[3].Stx_frq_dyn
			fm_dyn_eprm[3].Stx_obd_clfctr_dyn
			fm_dyn_eprm[3].Stx_esd_siz_dyn
			fm_dyn_eprm[3].Stx_pri_dyn
			fm_dyn_eprm[4].Stx_dist_fail_dyn
			fm_dyn_eprm[4].Stx_tmp_dist_dyn
			fm_dyn_eprm[4].Stx_km_cf_dyn
			fm_dyn_eprm[4].Stx_km_mf_dyn
			fm_dyn_eprm[4].Stx_km_pass_dyn
			fm_dyn_eprm[4].Stx_ind_dyn
			fm_dyn_eprm[4].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[4].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[4].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[4].Stx_ffm_n_dyn
			fm_dyn_eprm[4].Stx_ffm_n_min_dyn
			fm_dyn_eprm[4].Stx_ffm_n_max_dyn
			fm_dyn_eprm[4].Stx_ffm_tco_dyn
			fm_dyn_eprm[4].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[4].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[4].Stx_ffm_vb_dyn
			fm_dyn_eprm[4].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[4].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[4].Stx_ffm_vs_dyn
			fm_dyn_eprm[4].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[4].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[4].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[4].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[4].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[4].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[4].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[4].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[4].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[4].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[4].Stx_obd_wctr_dyn
			fm_dyn_eprm[4].Stx_frq_dyn
			fm_dyn_eprm[4].Stx_obd_clfctr_dyn
			fm_dyn_eprm[4].Stx_esd_siz_dyn
			fm_dyn_eprm[4].Stx_pri_dyn
			fm_dyn_eprm[5].Stx_dist_fail_dyn
			fm_dyn_eprm[5].Stx_tmp_dist_dyn
			fm_dyn_eprm[5].Stx_km_cf_dyn
			fm_dyn_eprm[5].Stx_km_mf_dyn
			fm_dyn_eprm[5].Stx_km_pass_dyn
			fm_dyn_eprm[5].Stx_ind_dyn
			fm_dyn_eprm[5].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[5].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[5].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[5].Stx_ffm_n_dyn
			fm_dyn_eprm[5].Stx_ffm_n_min_dyn
			fm_dyn_eprm[5].Stx_ffm_n_max_dyn
			fm_dyn_eprm[5].Stx_ffm_tco_dyn
			fm_dyn_eprm[5].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[5].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[5].Stx_ffm_vb_dyn
			fm_dyn_eprm[5].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[5].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[5].Stx_ffm_vs_dyn
			fm_dyn_eprm[5].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[5].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[5].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[5].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[5].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[5].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[5].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[5].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[5].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[5].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[5].Stx_obd_wctr_dyn
			fm_dyn_eprm[5].Stx_frq_dyn
			fm_dyn_eprm[5].Stx_obd_clfctr_dyn
			fm_dyn_eprm[5].Stx_esd_siz_dyn
			fm_dyn_eprm[5].Stx_pri_dyn
			fm_dyn_eprm[6].Stx_dist_fail_dyn
			fm_dyn_eprm[6].Stx_tmp_dist_dyn
			fm_dyn_eprm[6].Stx_km_cf_dyn
			fm_dyn_eprm[6].Stx_km_mf_dyn
			fm_dyn_eprm[6].Stx_km_pass_dyn
			fm_dyn_eprm[6].Stx_ind_dyn
			fm_dyn_eprm[6].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[6].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[6].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[6].Stx_ffm_n_dyn
			fm_dyn_eprm[6].Stx_ffm_n_min_dyn
			fm_dyn_eprm[6].Stx_ffm_n_max_dyn
			fm_dyn_eprm[6].Stx_ffm_tco_dyn
			fm_dyn_eprm[6].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[6].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[6].Stx_ffm_vb_dyn
			fm_dyn_eprm[6].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[6].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[6].Stx_ffm_vs_dyn
			fm_dyn_eprm[6].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[6].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[6].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[6].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[6].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[6].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[6].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[6].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[6].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[6].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[6].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[6].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[6].Stx_obd_wctr_dyn
			fm_dyn_eprm[6].Stx_frq_dyn
			fm_dyn_eprm[6].Stx_obd_clfctr_dyn
			fm_dyn_eprm[6].Stx_esd_siz_dyn
			fm_dyn_eprm[6].Stx_pri_dyn
			fm_dyn_eprm[7].Stx_dist_fail_dyn
			fm_dyn_eprm[7].Stx_tmp_dist_dyn
			fm_dyn_eprm[7].Stx_km_cf_dyn
			fm_dyn_eprm[7].Stx_km_mf_dyn
			fm_dyn_eprm[7].Stx_km_pass_dyn
			fm_dyn_eprm[7].Stx_ind_dyn
			fm_dyn_eprm[7].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[7].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[7].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[7].Stx_ffm_n_dyn
			fm_dyn_eprm[7].Stx_ffm_n_min_dyn
			fm_dyn_eprm[7].Stx_ffm_n_max_dyn
			fm_dyn_eprm[7].Stx_ffm_tco_dyn
			fm_dyn_eprm[7].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[7].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[7].Stx_ffm_vb_dyn
			fm_dyn_eprm[7].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[7].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[7].Stx_ffm_vs_dyn
			fm_dyn_eprm[7].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[7].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[7].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[7].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[7].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[7].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[7].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[7].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[7].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[7].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[7].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[7].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[7].Stx_obd_wctr_dyn
			fm_dyn_eprm[7].Stx_frq_dyn
			fm_dyn_eprm[7].Stx_obd_clfctr_dyn
			fm_dyn_eprm[7].Stx_esd_siz_dyn
			fm_dyn_eprm[7].Stx_pri_dyn
			fm_dyn_eprm[8].Stx_dist_fail_dyn
			fm_dyn_eprm[8].Stx_tmp_dist_dyn
			fm_dyn_eprm[8].Stx_km_cf_dyn
			fm_dyn_eprm[8].Stx_km_mf_dyn
			fm_dyn_eprm[8].Stx_km_pass_dyn
			fm_dyn_eprm[8].Stx_ind_dyn
			fm_dyn_eprm[8].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[8].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[8].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[8].Stx_ffm_n_dyn
			fm_dyn_eprm[8].Stx_ffm_n_min_dyn
			fm_dyn_eprm[8].Stx_ffm_n_max_dyn
			fm_dyn_eprm[8].Stx_ffm_tco_dyn
			fm_dyn_eprm[8].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[8].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[8].Stx_ffm_vb_dyn
			fm_dyn_eprm[8].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[8].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[8].Stx_ffm_vs_dyn
			fm_dyn_eprm[8].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[8].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[8].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[8].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[8].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[8].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[8].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[8].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[8].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[8].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[8].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[8].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[8].Stx_obd_wctr_dyn
			fm_dyn_eprm[8].Stx_frq_dyn
			fm_dyn_eprm[8].Stx_obd_clfctr_dyn
			fm_dyn_eprm[8].Stx_esd_siz_dyn
			fm_dyn_eprm[8].Stx_pri_dyn
			fm_dyn_eprm[9].Stx_dist_fail_dyn
			fm_dyn_eprm[9].Stx_tmp_dist_dyn
			fm_dyn_eprm[9].Stx_km_cf_dyn
			fm_dyn_eprm[9].Stx_km_mf_dyn
			fm_dyn_eprm[9].Stx_km_pass_dyn
			fm_dyn_eprm[9].Stx_ind_dyn
			fm_dyn_eprm[9].Stx_ffm_esti_tqe_dyn
			fm_dyn_eprm[9].Stx_ffm_esti_tqe_min_dyn
			fm_dyn_eprm[9].Stx_ffm_esti_tqe_max_dyn
			fm_dyn_eprm[9].Stx_ffm_n_dyn
			fm_dyn_eprm[9].Stx_ffm_n_min_dyn
			fm_dyn_eprm[9].Stx_ffm_n_max_dyn
			fm_dyn_eprm[9].Stx_ffm_tco_dyn
			fm_dyn_eprm[9].Stx_ffm_tco_min_dyn
			fm_dyn_eprm[9].Stx_ffm_tco_max_dyn
			fm_dyn_eprm[9].Stx_ffm_vb_dyn
			fm_dyn_eprm[9].Stx_ffm_vb_min_dyn
			fm_dyn_eprm[9].Stx_ffm_vb_max_dyn
			fm_dyn_eprm[9].Stx_ffm_vs_dyn
			fm_dyn_eprm[9].Stx_ffm_vs_min_dyn
			fm_dyn_eprm[9].Stx_ffm_vs_max_dyn
			fm_dyn_eprm[9].Stx_ffm_did_X_dyn[0]
			fm_dyn_eprm[9].Stx_ffm_did_X_dyn[1]
			fm_dyn_eprm[9].Stx_ffm_did_X_dyn[2]
			fm_dyn_eprm[9].Stx_ffm_did_X_dyn[3]
			fm_dyn_eprm[9].Stx_ffm_did_X_dyn[4]
			fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[0]
			fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[1]
			fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[2]
			fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[3]
			fm_dyn_eprm[9].Stx_ffm_did_X_max_dyn[4]
			fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[0]
			fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[1]
			fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[2]
			fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[3]
			fm_dyn_eprm[9].Stx_ffm_did_X_min_dyn[4]
			fm_dyn_eprm[9].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
			fm_dyn_eprm[9].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
			fm_dyn_eprm[9].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
			fm_dyn_eprm[9].Stx_obd_wctr_dyn
			fm_dyn_eprm[9].Stx_frq_dyn
			fm_dyn_eprm[9].Stx_obd_clfctr_dyn
			fm_dyn_eprm[9].Stx_esd_siz_dyn
			fm_dyn_eprm[9].Stx_pri_dyn
			fm_dyn[0].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[0].Vtx_ind_dyn
			fm_dyn[1].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[1].Vtx_ind_dyn
			fm_dyn[2].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[2].Vtx_ind_dyn
			fm_dyn[3].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[3].Vtx_ind_dyn
			fm_dyn[4].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[4].Vtx_ind_dyn
			fm_dyn[5].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[5].Vtx_ind_dyn
			fm_dyn[6].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[6].Vtx_ind_dyn
			fm_dyn[7].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[7].Vtx_ind_dyn
			fm_dyn[8].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[8].Vtx_ind_dyn
			fm_dyn[9].fm_dynamic_bitfield.Vtx_fail_dc_dyn
			fm_dyn[9].Vtx_ind_dyn
			Stx_esd[0]
			Stx_esd[1]
			Stx_esd[2]
			Stx_esd[3]
			Stx_esd[4]
			Stx_esd[5]
			Stx_esd[6]
			Stx_esd[7]
			Stx_esd[8]
			Stx_esd[9]
			Stx_esd[10]
			Stx_esd[11]
			Stx_esd[12]
			Stx_esd[13]
			Stx_esd[14]
			Stx_esd[15]
			Stx_esd[16]
			Stx_esd[17]
			Stx_esd[18]
			Stx_esd[19]
			Stx_esd[20]
			Stx_esd[21]
			Stx_esd[22]
			Stx_esd[23]
			Stx_esd[24]
			Stx_esd[25]
			Stx_esd[26]
			Stx_esd[27]
			Stx_esd[28]
			Stx_esd[29]
			Stx_esd[30]
			Stx_esd[31]
			Stx_esd[32]
			Stx_esd[33]
			Stx_esd[34]
			Stx_esd[35]
			Stx_esd[36]
			Stx_esd[37]
			Stx_esd[38]
			Stx_esd[39]
			Stx_esd[40]
			Stx_esd[41]
			Stx_esd[42]
			Stx_esd[43]
			Stx_esd[44]
			Stx_esd[45]
			Stx_esd[46]
			Stx_esd[47]
			Stx_esd[48]
			Stx_esd[49]
			Stx_esd[50]
			Stx_esd[51]
			Stx_esd[52]
			Stx_esd[53]
			Stx_esd[54]
			Stx_esd[55]
			Stx_esd[56]
			Stx_esd[57]
			Stx_esd[58]
			Stx_esd[59]
			Stx_esd[60]
			Stx_esd[61]
			Stx_esd[62]
			Stx_esd[63]
			Stx_esd[64]
			Stx_esd[65]
			Stx_esd[66]
			Stx_esd[67]
			Stx_esd[68]
			Stx_esd[69]
			Stx_esd[70]
			Stx_esd[71]
			Stx_esd[72]
			Stx_esd[73]
			Stx_esd[74]
			Stx_esd[75]
			Stx_esd[76]
			Stx_esd[77]
			Stx_esd[78]
			Stx_esd[79]
			Stx_esd[80]
			Stx_esd[81]
			Stx_esd[82]
			Stx_esd[83]
			Stx_esd[84]
			Stx_esd[85]
			Stx_esd[86]
			Stx_esd[87]
			Stx_esd[88]
			Stx_esd[89]
			Stx_esd[90]
			Stx_esd[91]
			Stx_esd[92]
			Stx_esd[93]
			Stx_esd[94]
			Stx_esd[95]
			Stx_esd[96]
			Stx_esd[97]
			Stx_esd[98]
			Stx_esd[99]
			Stx_esd[100]
			Stx_esd[101]
			Stx_esd[102]
			Stx_esd[103]
			Stx_esd[104]
			Stx_esd[105]
			Stx_esd[106]
			Stx_esd[107]
			Stx_esd[108]
			Stx_esd[109]
			Stx_esd[110]
			Stx_esd[111]
			Stx_esd[112]
			Stx_esd[113]
			Stx_esd[114]
			Stx_esd[115]
			Stx_esd[116]
			Stx_esd[117]
			Stx_esd[118]
			Stx_esd[119]
			Stx_esd[120]
			Stx_esd[121]
			Stx_esd[122]
			Stx_esd[123]
			Stx_esd[124]
			Stx_esd[125]
			Stx_esd[126]
			Stx_esd[127]
			Stx_esd[128]
			Stx_esd[129]
			Stx_esd[130]
			Stx_esd[131]
			Stx_esd[132]
			Stx_esd[133]
			Stx_esd[134]
			Stx_esd[135]
			Stx_esd[136]
			Stx_esd[137]
			Stx_esd[138]
			Stx_esd[139]
			Stx_esd[140]
			Stx_esd[141]
			Stx_esd[142]
			Stx_esd[143]
			Stx_esd[144]
			Stx_esd[145]
			Stx_esd[146]
			Stx_esd[147]
			Stx_esd[148]
			Stx_esd[149]
			Stx_esd[150]
			Stx_esd[151]
			Stx_esd[152]
			Stx_esd[153]
			Stx_esd[154]
			Stx_esd[155]
			Stx_esd[156]
			Stx_esd[157]
			Stx_esd[158]
			Stx_esd[159]
			Stx_esd[160]
			Stx_esd[161]
			Stx_esd[162]
			Stx_esd[163]
			Stx_esd[164]
			Stx_esd[165]
			Stx_esd[166]
			Stx_esd[167]
			Stx_esd[168]
			Stx_esd[169]
			Stx_esd[170]
			Stx_esd[171]
			Stx_esd[172]
			Stx_esd[173]
			Stx_esd[174]
			Stx_esd[175]
			Stx_esd[176]
			Stx_esd[177]
			Stx_esd[178]
			Stx_esd[179]
			Stx_esd[180]
			Stx_esd[181]
			Stx_esd[182]
			Stx_esd[183]
			Stx_esd[184]
			Stx_esd[185]
			Stx_esd[186]
			Stx_esd[187]
			Stx_esd[188]
			Stx_esd[189]
			Stx_esd[190]
			Stx_esd[191]
			Stx_esd[192]
			Stx_esd[193]
			Stx_esd[194]
			Stx_esd[195]
			Stx_esd[196]
			Stx_esd[197]
			Stx_esd[198]
			Stx_esd[199]
			Stx_esd[200]
			Stx_esd[201]
			Stx_esd[202]
			Stx_esd[203]
			Stx_esd[204]
			Stx_esd[205]
			Stx_esd[206]
			Stx_esd[207]
			Stx_esd[208]
			Stx_esd[209]
			Stx_esd[210]
			Stx_esd[211]
			Stx_esd[212]
			Stx_esd[213]
			Stx_esd[214]
			Stx_esd[215]
			Stx_esd[216]
			Stx_esd[217]
			Stx_esd[218]
			Stx_esd[219]
			Stx_esd[220]
			Stx_esd[221]
			Stx_esd[222]
			Stx_esd[223]
			Stx_esd[224]
			Stx_esd[225]
			Stx_esd[226]
			Stx_esd[227]
			Stx_esd[228]
			Stx_esd[229]
			Stx_esd[230]
			Stx_esd[231]
			Stx_esd[232]
			Stx_esd[233]
			Stx_esd[234]
			Stx_esd[235]
			Stx_esd[236]
			Stx_esd[237]
			Stx_esd[238]
			Stx_esd[239]
			Stx_esd[240]
			Stx_esd[241]
			Stx_esd[242]
			Stx_esd[243]
			Stx_esd[244]
			Stx_esd[245]
			Stx_esd[246]
			Stx_esd[247]
			Stx_esd[248]
			Stx_esd[249]
			Stx_esd[250]
			Stx_esd[251]
			Stx_esd[252]
			Stx_esd[253]
			Stx_esd[254]
			Stx_esd[255]
			Sxx_clr_dist
			Sxx_clr_wup
			Sxx_dyn_ctr
			Sxx_max_ind
			Sxx_mil_on_km
			Sxx_tmp_dist_1
			Sxx_tmp_dist_2
			Vbx_eng_aut_fm
			Vbx_eng_stop
			Vbx_igk_on_sta_pws
			Vbx_mil_ecu_req
			Vbx_mil_prmt_req
			Vbx_obd_dc
			Vbx_obd_wup
			Vbx_wal_1_req
			Vbx_wal_2_req
			Vbx_wup
			Vxx_dtc_hmb_cf_redg_edic
			Vxx_dtc_lb_cf_redg_edic
			Vxx_esd_did_nr
			Vxx_esd_ind
			Vxx_esd_ind_ini
			Vxx_esd_ind_max
			Vxx_esd_siz
			Vxx_ind_fail_redg
			Vxx_ind_mfo_redg
			Vxx_ind_obd_clf_redg
			Vxx_ind_obd_fedg
			Vxx_ind_pfo_redg
			Vxx_tco_ini
			Vxx_tmp_pri
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin FUNCTION
		DgDftMng_Obdfram
		""
	/begin DEF_CHARACTERISTIC
			Cbx_obd_off_cfm
			Cxx_dtc_lb_cata
			Cxx_dtc_lb_fsys
			Cxx_dtc_msb_fsys
			Cxx_dtc_obd_mis_cata_lpg
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Stx_frm_pool[0].Vxx_rtn_n01
			Stx_frm_pool[0].Vxx_obd_fail_code
			Stx_frm_pool[0].Vxx_rtn_eal
			Stx_frm_pool[0].Vxx_rtn_vs
			Stx_frm_pool[0].Vxx_rtn_map
			Stx_frm_pool[0].Vxx_rtn_frm_tco
			Stx_frm_pool[0].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[0].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[0].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[0].Vxx_rtn_mat
			Stx_frm_pool[0].Vxx_rtn_clr_dist
			Stx_frm_pool[0].Vxx_ind_xxx
			Stx_frm_pool[0].Vxx_rtn_maf
			Stx_frm_pool[0].Vxx_rtn_rail_prs
			Stx_frm_pool[0].Vxx_rtn_tia
			Stx_frm_pool[0].Vxx_dgdftmng_priority
			Stx_frm_pool[0].Vxx_rtn_rvac
			Stx_frm_pool[1].Vxx_rtn_n01
			Stx_frm_pool[1].Vxx_obd_fail_code
			Stx_frm_pool[1].Vxx_rtn_eal
			Stx_frm_pool[1].Vxx_rtn_vs
			Stx_frm_pool[1].Vxx_rtn_map
			Stx_frm_pool[1].Vxx_rtn_frm_tco
			Stx_frm_pool[1].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[1].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[1].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[1].Vxx_rtn_mat
			Stx_frm_pool[1].Vxx_rtn_clr_dist
			Stx_frm_pool[1].Vxx_ind_xxx
			Stx_frm_pool[1].Vxx_rtn_maf
			Stx_frm_pool[1].Vxx_rtn_rail_prs
			Stx_frm_pool[1].Vxx_rtn_tia
			Stx_frm_pool[1].Vxx_dgdftmng_priority
			Stx_frm_pool[1].Vxx_rtn_rvac
			Stx_frm_pool[2].Vxx_rtn_n01
			Stx_frm_pool[2].Vxx_obd_fail_code
			Stx_frm_pool[2].Vxx_rtn_eal
			Stx_frm_pool[2].Vxx_rtn_vs
			Stx_frm_pool[2].Vxx_rtn_map
			Stx_frm_pool[2].Vxx_rtn_frm_tco
			Stx_frm_pool[2].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[2].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[2].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[2].Vxx_rtn_mat
			Stx_frm_pool[2].Vxx_rtn_clr_dist
			Stx_frm_pool[2].Vxx_ind_xxx
			Stx_frm_pool[2].Vxx_rtn_maf
			Stx_frm_pool[2].Vxx_rtn_rail_prs
			Stx_frm_pool[2].Vxx_rtn_tia
			Stx_frm_pool[2].Vxx_dgdftmng_priority
			Stx_frm_pool[2].Vxx_rtn_rvac
			Stx_frm_pool[3].Vxx_rtn_n01
			Stx_frm_pool[3].Vxx_obd_fail_code
			Stx_frm_pool[3].Vxx_rtn_eal
			Stx_frm_pool[3].Vxx_rtn_vs
			Stx_frm_pool[3].Vxx_rtn_map
			Stx_frm_pool[3].Vxx_rtn_frm_tco
			Stx_frm_pool[3].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[3].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[3].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[3].Vxx_rtn_mat
			Stx_frm_pool[3].Vxx_rtn_clr_dist
			Stx_frm_pool[3].Vxx_ind_xxx
			Stx_frm_pool[3].Vxx_rtn_maf
			Stx_frm_pool[3].Vxx_rtn_rail_prs
			Stx_frm_pool[3].Vxx_rtn_tia
			Stx_frm_pool[3].Vxx_dgdftmng_priority
			Stx_frm_pool[3].Vxx_rtn_rvac
			Stx_frm_pool[4].Vxx_rtn_n01
			Stx_frm_pool[4].Vxx_obd_fail_code
			Stx_frm_pool[4].Vxx_rtn_eal
			Stx_frm_pool[4].Vxx_rtn_vs
			Stx_frm_pool[4].Vxx_rtn_map
			Stx_frm_pool[4].Vxx_rtn_frm_tco
			Stx_frm_pool[4].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[4].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[4].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[4].Vxx_rtn_mat
			Stx_frm_pool[4].Vxx_rtn_clr_dist
			Stx_frm_pool[4].Vxx_ind_xxx
			Stx_frm_pool[4].Vxx_rtn_maf
			Stx_frm_pool[4].Vxx_rtn_rail_prs
			Stx_frm_pool[4].Vxx_rtn_tia
			Stx_frm_pool[4].Vxx_dgdftmng_priority
			Stx_frm_pool[4].Vxx_rtn_rvac
			Stx_frm_pool[5].Vxx_rtn_n01
			Stx_frm_pool[5].Vxx_obd_fail_code
			Stx_frm_pool[5].Vxx_rtn_eal
			Stx_frm_pool[5].Vxx_rtn_vs
			Stx_frm_pool[5].Vxx_rtn_map
			Stx_frm_pool[5].Vxx_rtn_frm_tco
			Stx_frm_pool[5].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[5].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[5].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[5].Vxx_rtn_mat
			Stx_frm_pool[5].Vxx_rtn_clr_dist
			Stx_frm_pool[5].Vxx_ind_xxx
			Stx_frm_pool[5].Vxx_rtn_maf
			Stx_frm_pool[5].Vxx_rtn_rail_prs
			Stx_frm_pool[5].Vxx_rtn_tia
			Stx_frm_pool[5].Vxx_dgdftmng_priority
			Stx_frm_pool[5].Vxx_rtn_rvac
			Stx_frm_pool[6].Vxx_rtn_n01
			Stx_frm_pool[6].Vxx_obd_fail_code
			Stx_frm_pool[6].Vxx_rtn_eal
			Stx_frm_pool[6].Vxx_rtn_vs
			Stx_frm_pool[6].Vxx_rtn_map
			Stx_frm_pool[6].Vxx_rtn_frm_tco
			Stx_frm_pool[6].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[6].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[6].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[6].Vxx_rtn_mat
			Stx_frm_pool[6].Vxx_rtn_clr_dist
			Stx_frm_pool[6].Vxx_ind_xxx
			Stx_frm_pool[6].Vxx_rtn_maf
			Stx_frm_pool[6].Vxx_rtn_rail_prs
			Stx_frm_pool[6].Vxx_rtn_tia
			Stx_frm_pool[6].Vxx_dgdftmng_priority
			Stx_frm_pool[6].Vxx_rtn_rvac
			Stx_frm_pool[7].Vxx_rtn_n01
			Stx_frm_pool[7].Vxx_obd_fail_code
			Stx_frm_pool[7].Vxx_rtn_eal
			Stx_frm_pool[7].Vxx_rtn_vs
			Stx_frm_pool[7].Vxx_rtn_map
			Stx_frm_pool[7].Vxx_rtn_frm_tco
			Stx_frm_pool[7].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[7].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[7].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[7].Vxx_rtn_mat
			Stx_frm_pool[7].Vxx_rtn_clr_dist
			Stx_frm_pool[7].Vxx_ind_xxx
			Stx_frm_pool[7].Vxx_rtn_maf
			Stx_frm_pool[7].Vxx_rtn_rail_prs
			Stx_frm_pool[7].Vxx_rtn_tia
			Stx_frm_pool[7].Vxx_dgdftmng_priority
			Stx_frm_pool[7].Vxx_rtn_rvac
			Stx_frm_pool[8].Vxx_rtn_n01
			Stx_frm_pool[8].Vxx_obd_fail_code
			Stx_frm_pool[8].Vxx_rtn_eal
			Stx_frm_pool[8].Vxx_rtn_vs
			Stx_frm_pool[8].Vxx_rtn_map
			Stx_frm_pool[8].Vxx_rtn_frm_tco
			Stx_frm_pool[8].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[8].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[8].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[8].Vxx_rtn_mat
			Stx_frm_pool[8].Vxx_rtn_clr_dist
			Stx_frm_pool[8].Vxx_ind_xxx
			Stx_frm_pool[8].Vxx_rtn_maf
			Stx_frm_pool[8].Vxx_rtn_rail_prs
			Stx_frm_pool[8].Vxx_rtn_tia
			Stx_frm_pool[8].Vxx_dgdftmng_priority
			Stx_frm_pool[8].Vxx_rtn_rvac
			Stx_frm_pool[9].Vxx_rtn_n01
			Stx_frm_pool[9].Vxx_obd_fail_code
			Stx_frm_pool[9].Vxx_rtn_eal
			Stx_frm_pool[9].Vxx_rtn_vs
			Stx_frm_pool[9].Vxx_rtn_map
			Stx_frm_pool[9].Vxx_rtn_frm_tco
			Stx_frm_pool[9].Vxx_rtn_mv_ad_fac
			Stx_frm_pool[9].Vxx_rtn_rich_loop_ti_fac
			Stx_frm_pool[9].Vbx_rtn_clos_o2_phs
			Stx_frm_pool[9].Vxx_rtn_mat
			Stx_frm_pool[9].Vxx_rtn_clr_dist
			Stx_frm_pool[9].Vxx_ind_xxx
			Stx_frm_pool[9].Vxx_rtn_maf
			Stx_frm_pool[9].Vxx_rtn_rail_prs
			Stx_frm_pool[9].Vxx_rtn_tia
			Stx_frm_pool[9].Vxx_dgdftmng_priority
			Stx_frm_pool[9].Vxx_rtn_rvac
			Vtx_frm[0].Vxx_rtn_n01
			Vtx_frm[0].Vxx_obd_fail_code
			Vtx_frm[0].Vxx_rtn_eal
			Vtx_frm[0].Vxx_rtn_vs
			Vtx_frm[0].Vxx_rtn_map
			Vtx_frm[0].Vxx_rtn_frm_tco
			Vtx_frm[0].Vxx_rtn_mv_ad_fac
			Vtx_frm[0].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[0].Vbx_rtn_clos_o2_phs
			Vtx_frm[0].Vxx_rtn_mat
			Vtx_frm[0].Vxx_rtn_clr_dist
			Vtx_frm[0].Vxx_ind_xxx
			Vtx_frm[0].Vxx_rtn_maf
			Vtx_frm[0].Vxx_rtn_rail_prs
			Vtx_frm[0].Vxx_rtn_tia
			Vtx_frm[0].Vxx_dgdftmng_priority
			Vtx_frm[0].Vxx_rtn_rvac
			Vtx_frm[1].Vxx_rtn_n01
			Vtx_frm[1].Vxx_obd_fail_code
			Vtx_frm[1].Vxx_rtn_eal
			Vtx_frm[1].Vxx_rtn_vs
			Vtx_frm[1].Vxx_rtn_map
			Vtx_frm[1].Vxx_rtn_frm_tco
			Vtx_frm[1].Vxx_rtn_mv_ad_fac
			Vtx_frm[1].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[1].Vbx_rtn_clos_o2_phs
			Vtx_frm[1].Vxx_rtn_mat
			Vtx_frm[1].Vxx_rtn_clr_dist
			Vtx_frm[1].Vxx_ind_xxx
			Vtx_frm[1].Vxx_rtn_maf
			Vtx_frm[1].Vxx_rtn_rail_prs
			Vtx_frm[1].Vxx_rtn_tia
			Vtx_frm[1].Vxx_dgdftmng_priority
			Vtx_frm[1].Vxx_rtn_rvac
			Vtx_frm[2].Vxx_rtn_n01
			Vtx_frm[2].Vxx_obd_fail_code
			Vtx_frm[2].Vxx_rtn_eal
			Vtx_frm[2].Vxx_rtn_vs
			Vtx_frm[2].Vxx_rtn_map
			Vtx_frm[2].Vxx_rtn_frm_tco
			Vtx_frm[2].Vxx_rtn_mv_ad_fac
			Vtx_frm[2].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[2].Vbx_rtn_clos_o2_phs
			Vtx_frm[2].Vxx_rtn_mat
			Vtx_frm[2].Vxx_rtn_clr_dist
			Vtx_frm[2].Vxx_ind_xxx
			Vtx_frm[2].Vxx_rtn_maf
			Vtx_frm[2].Vxx_rtn_rail_prs
			Vtx_frm[2].Vxx_rtn_tia
			Vtx_frm[2].Vxx_dgdftmng_priority
			Vtx_frm[2].Vxx_rtn_rvac
			Vtx_frm[3].Vxx_rtn_n01
			Vtx_frm[3].Vxx_obd_fail_code
			Vtx_frm[3].Vxx_rtn_eal
			Vtx_frm[3].Vxx_rtn_vs
			Vtx_frm[3].Vxx_rtn_map
			Vtx_frm[3].Vxx_rtn_frm_tco
			Vtx_frm[3].Vxx_rtn_mv_ad_fac
			Vtx_frm[3].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[3].Vbx_rtn_clos_o2_phs
			Vtx_frm[3].Vxx_rtn_mat
			Vtx_frm[3].Vxx_rtn_clr_dist
			Vtx_frm[3].Vxx_ind_xxx
			Vtx_frm[3].Vxx_rtn_maf
			Vtx_frm[3].Vxx_rtn_rail_prs
			Vtx_frm[3].Vxx_rtn_tia
			Vtx_frm[3].Vxx_dgdftmng_priority
			Vtx_frm[3].Vxx_rtn_rvac
			Vtx_frm[4].Vxx_rtn_n01
			Vtx_frm[4].Vxx_obd_fail_code
			Vtx_frm[4].Vxx_rtn_eal
			Vtx_frm[4].Vxx_rtn_vs
			Vtx_frm[4].Vxx_rtn_map
			Vtx_frm[4].Vxx_rtn_frm_tco
			Vtx_frm[4].Vxx_rtn_mv_ad_fac
			Vtx_frm[4].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[4].Vbx_rtn_clos_o2_phs
			Vtx_frm[4].Vxx_rtn_mat
			Vtx_frm[4].Vxx_rtn_clr_dist
			Vtx_frm[4].Vxx_ind_xxx
			Vtx_frm[4].Vxx_rtn_maf
			Vtx_frm[4].Vxx_rtn_rail_prs
			Vtx_frm[4].Vxx_rtn_tia
			Vtx_frm[4].Vxx_dgdftmng_priority
			Vtx_frm[4].Vxx_rtn_rvac
			Vtx_frm[5].Vxx_rtn_n01
			Vtx_frm[5].Vxx_obd_fail_code
			Vtx_frm[5].Vxx_rtn_eal
			Vtx_frm[5].Vxx_rtn_vs
			Vtx_frm[5].Vxx_rtn_map
			Vtx_frm[5].Vxx_rtn_frm_tco
			Vtx_frm[5].Vxx_rtn_mv_ad_fac
			Vtx_frm[5].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[5].Vbx_rtn_clos_o2_phs
			Vtx_frm[5].Vxx_rtn_mat
			Vtx_frm[5].Vxx_rtn_clr_dist
			Vtx_frm[5].Vxx_ind_xxx
			Vtx_frm[5].Vxx_rtn_maf
			Vtx_frm[5].Vxx_rtn_rail_prs
			Vtx_frm[5].Vxx_rtn_tia
			Vtx_frm[5].Vxx_dgdftmng_priority
			Vtx_frm[5].Vxx_rtn_rvac
			Vtx_frm[6].Vxx_rtn_n01
			Vtx_frm[6].Vxx_obd_fail_code
			Vtx_frm[6].Vxx_rtn_eal
			Vtx_frm[6].Vxx_rtn_vs
			Vtx_frm[6].Vxx_rtn_map
			Vtx_frm[6].Vxx_rtn_frm_tco
			Vtx_frm[6].Vxx_rtn_mv_ad_fac
			Vtx_frm[6].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[6].Vbx_rtn_clos_o2_phs
			Vtx_frm[6].Vxx_rtn_mat
			Vtx_frm[6].Vxx_rtn_clr_dist
			Vtx_frm[6].Vxx_ind_xxx
			Vtx_frm[6].Vxx_rtn_maf
			Vtx_frm[6].Vxx_rtn_rail_prs
			Vtx_frm[6].Vxx_rtn_tia
			Vtx_frm[6].Vxx_dgdftmng_priority
			Vtx_frm[6].Vxx_rtn_rvac
			Vtx_frm[7].Vxx_rtn_n01
			Vtx_frm[7].Vxx_obd_fail_code
			Vtx_frm[7].Vxx_rtn_eal
			Vtx_frm[7].Vxx_rtn_vs
			Vtx_frm[7].Vxx_rtn_map
			Vtx_frm[7].Vxx_rtn_frm_tco
			Vtx_frm[7].Vxx_rtn_mv_ad_fac
			Vtx_frm[7].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[7].Vbx_rtn_clos_o2_phs
			Vtx_frm[7].Vxx_rtn_mat
			Vtx_frm[7].Vxx_rtn_clr_dist
			Vtx_frm[7].Vxx_ind_xxx
			Vtx_frm[7].Vxx_rtn_maf
			Vtx_frm[7].Vxx_rtn_rail_prs
			Vtx_frm[7].Vxx_rtn_tia
			Vtx_frm[7].Vxx_dgdftmng_priority
			Vtx_frm[7].Vxx_rtn_rvac
			Vtx_frm[8].Vxx_rtn_n01
			Vtx_frm[8].Vxx_obd_fail_code
			Vtx_frm[8].Vxx_rtn_eal
			Vtx_frm[8].Vxx_rtn_vs
			Vtx_frm[8].Vxx_rtn_map
			Vtx_frm[8].Vxx_rtn_frm_tco
			Vtx_frm[8].Vxx_rtn_mv_ad_fac
			Vtx_frm[8].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[8].Vbx_rtn_clos_o2_phs
			Vtx_frm[8].Vxx_rtn_mat
			Vtx_frm[8].Vxx_rtn_clr_dist
			Vtx_frm[8].Vxx_ind_xxx
			Vtx_frm[8].Vxx_rtn_maf
			Vtx_frm[8].Vxx_rtn_rail_prs
			Vtx_frm[8].Vxx_rtn_tia
			Vtx_frm[8].Vxx_dgdftmng_priority
			Vtx_frm[8].Vxx_rtn_rvac
			Vtx_frm[9].Vxx_rtn_n01
			Vtx_frm[9].Vxx_obd_fail_code
			Vtx_frm[9].Vxx_rtn_eal
			Vtx_frm[9].Vxx_rtn_vs
			Vtx_frm[9].Vxx_rtn_map
			Vtx_frm[9].Vxx_rtn_frm_tco
			Vtx_frm[9].Vxx_rtn_mv_ad_fac
			Vtx_frm[9].Vxx_rtn_rich_loop_ti_fac
			Vtx_frm[9].Vbx_rtn_clos_o2_phs
			Vtx_frm[9].Vxx_rtn_mat
			Vtx_frm[9].Vxx_rtn_clr_dist
			Vtx_frm[9].Vxx_ind_xxx
			Vtx_frm[9].Vxx_rtn_maf
			Vtx_frm[9].Vxx_rtn_rail_prs
			Vtx_frm[9].Vxx_rtn_tia
			Vtx_frm[9].Vxx_dgdftmng_priority
			Vtx_frm[9].Vxx_rtn_rvac
			Sxx_sel_frm
			Vbx_rtn_clos_o2_phs
			Vxx_obd_fail_code
			Vxx_rtn_clr_dist
			Vxx_rtn_eal
			Vxx_rtn_frm_tco
			Vxx_rtn_maf
			Vxx_rtn_map
			Vxx_rtn_mat
			Vxx_rtn_mv_ad_fac
			Vxx_rtn_n01
			Vxx_rtn_rail_prs
			Vxx_rtn_rich_loop_ti_fac
			Vxx_rtn_rvac
			Vxx_rtn_tia
			Vxx_rtn_vs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin FUNCTION
		DgDftMng_Rdncata
		""
	/begin OUT_MEASUREMENT
			Vbx_int_mfo_cata_nok_cge
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin FUNCTION
		DgDftMng_Rdnmgtx
		""
	/* ASAP2::Database : delete 'Vbx_int_mfo_cata_cpt' */
	/* ASAP2::Database : delete 'Vbx_int_mfo_lbup_cpt' */
	/* ASAP2::Database : delete 'Vbx_obd_rdn_cata_cpt' */
	/* ASAP2::Database : delete 'Vbx_obd_rdn_lbup_cpt' */
	/* ASAP2::Database : 4 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_int_mfo_egr
			Vbx_obd_rdn_cpt
			Vbx_obd_rdn_fsys
			Vbx_obd_rdn_full
			Vbx_obd_rdn_mis
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin FUNCTION
		DgDftMng_Rdnpftx
		""
	/begin OUT_MEASUREMENT
			Vbx_int_mfo_pft
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin FUNCTION
		DgDftMng_Svcecom
		""
	/begin DEF_CHARACTERISTIC
			Ntx_data_avl_list[0]
			Ntx_data_avl_list[1]
			Ntx_data_avl_list[2]
			Ntx_data_avl_list[3]
			Ntx_data_avl_list[4]
			Ntx_frm_avl_list[0]
			Ntx_frm_avl_list[1]
			Ntx_frm_avl_list[2]
			Ntx_frm_avl_list[3]
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_get_ind_pres_iter
			Vxx_capture_all_pres_iter
			Vxx_capture_obd_pres_iter
			Vxx_capture_all_nr
			Vxx_capture_obd_nr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin FUNCTION
		DgDgtDat
		""
	/begin SUB_FUNCTION
			DgDgtDat_Msgdiag_xxxxxx
			DgDgtDat_Cchkclc_xxxxxx
			DgDgtDat_Loadval_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin FUNCTION
		DgDgtDat_Cchkclc_xxxxxx
		""
	/begin OUT_MEASUREMENT
			Vxx_chks_c_sw_1
			Vxx_chks_c_sw_2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin FUNCTION
		DgDgtDat_Loadval_xxxxxx
		""
	/begin OUT_MEASUREMENT
			Vxx_obd_eal
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin FUNCTION
		DgDgtDat_Msgdiag_xxxxxx
		""
	/* ASAP2::Database : delete 'Cxx_did_2141_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2141_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_2143_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_2143_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2147_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_2147_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2156_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2156_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_2181_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_2181_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2457_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2457_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_2458_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2458_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_2459_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_2459_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_245A_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_245A_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_245B_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_245C_writ_min' */
	/* ASAP2::Database : delete 'Cxx_did_245B_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_245C_writ_max' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[0]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[1]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[2]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[3]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[4]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[5]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[6]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[7]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[8]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[9]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[10]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[11]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[12]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[13]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[14]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[15]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[16]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[17]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[18]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[19]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[20]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[21]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[22]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[23]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[24]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[25]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[26]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[27]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[28]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[29]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[30]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_max[31]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[0]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[1]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[2]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[3]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[4]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[5]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[6]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[7]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[8]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[9]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[10]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[11]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[12]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[13]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[14]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[15]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[16]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[17]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[18]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[19]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[20]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[21]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[22]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[23]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[24]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[25]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[26]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[27]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[28]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[29]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[30]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_max[31]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[0]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[1]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[2]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[3]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[4]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[5]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[6]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[7]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[8]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[9]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[10]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[11]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[12]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[13]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[14]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[15]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[16]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[17]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[18]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[19]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[20]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[21]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[22]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[23]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[24]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[25]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[26]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[27]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[28]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[29]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[30]' */
	/* ASAP2::Database : delete 'Ctx_did_2876_writ_min[31]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[0]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[1]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[2]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[3]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[4]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[5]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[6]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[7]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[8]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[9]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[10]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[11]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[12]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[13]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[14]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[15]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[16]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[17]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[18]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[19]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[20]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[21]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[22]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[23]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[24]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[25]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[26]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[27]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[28]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[29]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[30]' */
	/* ASAP2::Database : delete 'Ctx_did_2877_writ_min[31]' */
	/* ASAP2::Database : delete 'Cxx_did_287F_writ_max' */
	/* ASAP2::Database : delete 'Cxx_did_287F_writ_min' */
	/* ASAP2::Database : 152 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_c_id10
			Cxx_c_id11
			Cxx_c_id12
			Cxx_c_id13
			Cxx_c_id14
			Cxx_c_id15
			Cxx_c_id16
			Cxx_c_id1
			Cxx_c_id2
			Cxx_c_id3
			Cxx_c_id4
			Cxx_c_id5
			Cxx_c_id6
			Cxx_c_id7
			Cxx_c_id8
			Cxx_c_id9
			Cxx_obd_conf_obd
			Cxx_obd_conf_diag_schd
			Cxx_obd_conf_diag_prmt
			Cxx_obd_conf_lamb
			Cxx_did_210E_writ_min
			Cxx_did_210E_writ_max
			Cxx_did_2113_writ_min
			Cxx_did_210D_writ_min
			Cxx_did_211C_writ_min
			Cxx_did_210D_writ_max
			Cxx_did_211C_writ_max
			Cxx_did_212A_writ_max
			Cxx_did_212A_writ_min
			Cxx_did_2426_writ_max
			Cxx_did_2426_writ_min
			Cxx_did_2427_writ_min
			Cxx_did_2427_writ_max
			Cxx_did_2428_writ_min
			Cxx_did_2428_writ_max
			Cxx_did_2429_writ_max
			Cxx_did_242A_writ_max
			Cxx_did_2429_writ_min
			Cxx_did_242A_writ_min
			Cxx_did_2113_writ_max
			Cxx_did_24C2_writ_max
			Cxx_did_24C2_writ_min
			Cxx_did_2425_writ_max
			Cxx_did_2425_writ_min
			Cxx_did_2868_writ_max
			Cxx_did_24DC_writ_min
			Cxx_did_24DC_writ_max
			Cxx_did_205F_writ_max
			Cxx_did_205F_writ_min
			Ctx_did_2468_writ_min[0]
			Ctx_did_2468_writ_min[1]
			Ctx_did_2468_writ_min[2]
			Ctx_did_2468_writ_min[3]
			Ctx_did_2468_writ_min[4]
			Ctx_did_2468_writ_min[5]
			Ctx_did_2468_writ_min[6]
			Ctx_did_2468_writ_min[7]
			Ctx_did_2468_writ_min[8]
			Ctx_did_2468_writ_min[9]
			Ctx_did_2469_writ_max[0]
			Ctx_did_2469_writ_max[1]
			Ctx_did_2469_writ_max[2]
			Ctx_did_2469_writ_max[3]
			Ctx_did_2469_writ_max[4]
			Ctx_did_2469_writ_max[5]
			Ctx_did_2469_writ_max[6]
			Ctx_did_2469_writ_max[7]
			Ctx_did_2469_writ_max[8]
			Ctx_did_2469_writ_max[9]
			Ctx_did_2469_writ_min[0]
			Ctx_did_2469_writ_min[1]
			Ctx_did_2469_writ_min[2]
			Ctx_did_2469_writ_min[3]
			Ctx_did_2469_writ_min[4]
			Ctx_did_2469_writ_min[5]
			Ctx_did_2469_writ_min[6]
			Ctx_did_2469_writ_min[7]
			Ctx_did_2469_writ_min[8]
			Ctx_did_2469_writ_min[9]
			Ctx_did_2468_writ_max[0]
			Ctx_did_2468_writ_max[1]
			Ctx_did_2468_writ_max[2]
			Ctx_did_2468_writ_max[3]
			Ctx_did_2468_writ_max[4]
			Ctx_did_2468_writ_max[5]
			Ctx_did_2468_writ_max[6]
			Ctx_did_2468_writ_max[7]
			Ctx_did_2468_writ_max[8]
			Ctx_did_2468_writ_max[9]
			Cxx_did_2105_writ_max
			Cxx_did_2105_writ_min
			Cxx_did_24EA_writ_min
			Cxx_did_24EA_writ_max
			Cxx_did_2868_writ_min
			Ctx_did_24EF_writ_max[0]
			Ctx_did_24EF_writ_max[1]
			Ctx_did_24EF_writ_max[2]
			Ctx_did_24EF_writ_max[3]
			Ctx_did_24EF_writ_max[4]
			Ctx_did_24EF_writ_max[5]
			Ctx_did_24EF_writ_max[6]
			Ctx_did_24EF_writ_max[7]
			Ctx_did_24EF_writ_max[8]
			Ctx_did_24EF_writ_max[9]
			Ctx_did_24EF_writ_min[0]
			Ctx_did_24EF_writ_min[1]
			Ctx_did_24EF_writ_min[2]
			Ctx_did_24EF_writ_min[3]
			Ctx_did_24EF_writ_min[4]
			Ctx_did_24EF_writ_min[5]
			Ctx_did_24EF_writ_min[6]
			Ctx_did_24EF_writ_min[7]
			Ctx_did_24EF_writ_min[8]
			Ctx_did_24EF_writ_min[9]
			Cxx_obd_cert_nr1
			Cxx_obd_cert_nr2
			Cxx_obd_cert_nr3
			Cxx_obd_cert_nr4
			Cxx_obd_cert_nr5
			Cxx_obd_cert_nr6
			Cxx_obd_cert_nr7
			Cxx_obd_cert_nr8
			Cxx_obd_cert_nr9
			Cxx_obd_cert_nr10
			Ctx_did_246A_writ_min[0]
			Ctx_did_246A_writ_min[1]
			Ctx_did_246A_writ_min[2]
			Ctx_did_246A_writ_min[3]
			Ctx_did_246A_writ_min[4]
			Ctx_did_246A_writ_min[5]
			Ctx_did_246A_writ_min[6]
			Ctx_did_246A_writ_min[7]
			Ctx_did_246A_writ_min[8]
			Ctx_did_246A_writ_min[9]
			Ctx_did_246A_writ_max[0]
			Ctx_did_246A_writ_max[1]
			Ctx_did_246A_writ_max[2]
			Ctx_did_246A_writ_max[3]
			Ctx_did_246A_writ_max[4]
			Ctx_did_246A_writ_max[5]
			Ctx_did_246A_writ_max[6]
			Ctx_did_246A_writ_max[7]
			Ctx_did_246A_writ_max[8]
			Ctx_did_246A_writ_max[9]
			Cxx_did_24EC_writ_min
			Cxx_did_24EC_writ_max
			Cbx_s06_fsys_cpt_old
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_diag_ena_comb_bas_req
			Vbx_owe_tool_ini_req
			Vsx_owe_tool_zon_req
			Vxx_diag_comb_bas
			Vbx_htg_dsb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon
		""
	/begin SUB_FUNCTION
			DgDgtMon_Bypmngx
			DgDgtMon_Engsftx
			DgDgtMon_Evntmgr
			DgDgtMon_Monisft
			DgDgtMon_Monispv
			DgDgtMon_Routmng
			DgDgtMon_Tacmngx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon_Bypmngx
		""
	/* ASAP2::Database : delete 'Cxx_moni_id_19_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_19_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_1c_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_1c_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_2b_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_2b_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_2c_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_2c_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_2d_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_2d_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_44_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_44_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_51_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_51_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_52_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_52_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_60_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_60_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_61_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_61_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_62_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_62_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_63_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_63_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_64_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_64_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_65_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_65_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_66_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_66_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_67_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_67_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_68_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_68_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_69_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_69_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6a_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6a_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6b_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6b_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6c_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6c_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6d_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6d_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6e_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6e_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_25_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_25_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_26_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_26_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6f_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_79_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_6f_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_79_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_48_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_48_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_49_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_4a_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_49_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_4a_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_4b_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_4c_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_4b_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_4c_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_70_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_70_min' */
	/* ASAP2::Database : delete 'Cxx_moni_id_71_max' */
	/* ASAP2::Database : delete 'Cxx_moni_id_71_min' */
	/* ASAP2::Database : 68 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_moni_id_01_max
			Cxx_moni_id_01_min
			Cxx_moni_id_03_max
			Cxx_moni_id_03_min
			Cxx_moni_id_06_max
			Cxx_moni_id_06_min
			Cxx_moni_id_0a_max
			Cxx_moni_id_0a_min
			Cxx_moni_id_10_max
			Cxx_moni_id_10_min
			Cxx_moni_id_11_max
			Cxx_moni_id_11_min
			Cxx_moni_id_13_max
			Cxx_moni_id_13_min
			Cxx_moni_id_14_max
			Cxx_moni_id_14_min
			Cxx_moni_id_18_max
			Cxx_moni_id_18_min
			Cxx_moni_id_1a_max
			Cxx_moni_id_1a_min
			Cxx_moni_id_1b_max
			Cxx_moni_id_1b_min
			Cxx_moni_id_1d_max
			Cxx_moni_id_1d_min
			Cxx_moni_id_1e_max
			Cxx_moni_id_1e_min
			Cxx_moni_id_1f_max
			Cxx_moni_id_1f_min
			Cxx_moni_id_20_max
			Cxx_moni_id_20_min
			Cxx_moni_id_30_max
			Cxx_moni_id_30_min
			Cxx_moni_id_31_max
			Cxx_moni_id_31_min
			Cxx_moni_id_32_max
			Cxx_moni_id_32_min
			Cxx_moni_id_33_max
			Cxx_moni_id_33_min
			Cxx_moni_id_34_max
			Cxx_moni_id_34_min
			Cxx_moni_id_35_max
			Cxx_moni_id_35_min
			Cxx_moni_id_36_max
			Cxx_moni_id_36_min
			Cxx_moni_id_37_max
			Cxx_moni_id_37_min
			Cxx_moni_id_38_max
			Cxx_moni_id_38_min
			Cxx_moni_id_39_max
			Cxx_moni_id_39_min
			Cxx_moni_id_3a_max
			Cxx_moni_id_3a_min
			Cxx_moni_id_3b_max
			Cxx_moni_id_3b_min
			Cxx_moni_id_3c_max
			Cxx_moni_id_3c_min
			Cxx_moni_id_3d_max
			Cxx_moni_id_3d_min
			Cxx_moni_id_40_max
			Cxx_moni_id_40_min
			Cxx_moni_id_46_max
			Cxx_moni_id_46_min
			Cxx_moni_id_47_max
			Cxx_moni_id_47_min
			Cxx_moni_id_21_max
			Cxx_moni_id_21_min
			Cxx_moni_id_29_max
			Cxx_moni_id_29_min
			Cxx_moni_id_3e_max
			Cxx_moni_id_3f_max
			Cxx_moni_id_3e_min
			Cxx_moni_id_3f_min
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vxx_byp_19_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_1c_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_2b_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_2c_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_2d_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_51_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_52_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_25_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_26_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_44_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_60_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_61_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_62_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_63_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_64_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_65_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_66_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_67_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_68_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_69_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_6a_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_6b_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_6c_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_6d_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_6e_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_6f_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_79_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_48_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_49_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_4a_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_4b_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_4c_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_70_sub_val' */
	/* ASAP2::Database : delete 'Vxx_byp_71_sub_val' */
	/* ASAP2::Database : 34 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_moni_id_01_sub_val
			Vxx_byp_06_sub_val
			Vxx_moni_id_10_sub_val
			Vxx_moni_id_11_sub_val
			Vxx_moni_id_13_sub_val
			Vxx_moni_id_14_sub_val
			Vxx_moni_id_18_sub_val
			Vxx_moni_id_1a_sub_val
			Vxx_moni_id_1b_sub_val
			Vxx_moni_id_20_sub_val
			Vxx_moni_id_21_sub_val
			Vxx_moni_id_30_sub_val
			Vxx_moni_id_31_sub_val
			Vxx_moni_id_32_sub_val
			Vxx_moni_id_33_sub_val
			Vxx_moni_id_34_sub_val
			Vxx_moni_id_35_sub_val
			Vxx_moni_id_36_sub_val
			Vxx_moni_id_37_sub_val
			Vxx_moni_id_38_sub_val
			Vxx_moni_id_39_sub_val
			Vxx_moni_id_3a_sub_val
			Vxx_moni_id_3b_sub_val
			Vxx_moni_id_3c_sub_val
			Vbx_moni_xx_req[1]
			Vbx_moni_xx_req[3]
			Vbx_moni_xx_req[6]
			Vbx_moni_xx_req[10]
			Vbx_moni_xx_req[16]
			Vbx_moni_xx_req[17]
			Vbx_moni_xx_req[19]
			Vbx_moni_xx_req[20]
			Vbx_moni_xx_req[24]
			Vbx_moni_xx_req[25]
			Vbx_moni_xx_req[26]
			Vbx_moni_xx_req[27]
			Vbx_moni_xx_req[28]
			Vbx_moni_xx_req[29]
			Vbx_moni_xx_req[30]
			Vbx_moni_xx_req[31]
			Vbx_moni_xx_req[32]
			Vbx_moni_xx_req[33]
			Vbx_moni_xx_req[37]
			Vbx_moni_xx_req[38]
			Vbx_moni_xx_req[41]
			Vbx_moni_xx_req[43]
			Vbx_moni_xx_req[44]
			Vbx_moni_xx_req[45]
			Vbx_moni_xx_req[48]
			Vbx_moni_xx_req[49]
			Vbx_moni_xx_req[50]
			Vbx_moni_xx_req[51]
			Vbx_moni_xx_req[52]
			Vbx_moni_xx_req[53]
			Vbx_moni_xx_req[54]
			Vbx_moni_xx_req[55]
			Vbx_moni_xx_req[56]
			Vbx_moni_xx_req[57]
			Vbx_moni_xx_req[58]
			Vbx_moni_xx_req[59]
			Vbx_moni_xx_req[60]
			Vbx_moni_xx_req[61]
			Vbx_moni_xx_req[62]
			Vbx_moni_xx_req[64]
			Vbx_moni_xx_req[67]
			Vbx_moni_xx_req[68]
			Vbx_moni_xx_req[70]
			Vbx_moni_xx_req[71]
			Vbx_moni_xx_req[72]
			Vbx_moni_xx_req[73]
			Vbx_moni_xx_req[74]
			Vbx_moni_xx_req[75]
			Vbx_moni_xx_req[76]
			Vbx_moni_xx_req[81]
			Vbx_moni_xx_req[82]
			Vbx_moni_xx_req[96]
			Vbx_moni_xx_req[97]
			Vbx_moni_xx_req[98]
			Vbx_moni_xx_req[99]
			Vbx_moni_xx_req[100]
			Vbx_moni_xx_req[101]
			Vbx_moni_xx_req[102]
			Vbx_moni_xx_req[103]
			Vbx_moni_xx_req[104]
			Vbx_moni_xx_req[105]
			Vbx_moni_xx_req[106]
			Vbx_moni_xx_req[107]
			Vbx_moni_xx_req[108]
			Vbx_moni_xx_req[109]
			Vbx_moni_xx_req[110]
			Vbx_moni_xx_req[111]
			Vbx_moni_xx_req[112]
			Vbx_moni_xx_req[113]
			Vbx_moni_xx_req[121]
			Vxx_byp_1f_sub_val
			Vxx_byp_29_sub_val
			Vxx_byp_1e_sub_val
			Vxx_byp_03_sub_val
			Vxx_byp_0a_sub_val
			Vxx_byp_3d_sub_val
			Vxx_byp_40_sub_val
			Vxx_byp_46_sub_val
			Vxx_byp_47_sub_val
			Vxx_byp_1d_sub_val
			Vxx_byp_3e_sub_val
			Vxx_byp_3f_sub_val
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon_Engsftx
		""
	/* ASAP2::Database : delete 'Cbx_ext_ctrl_sens_spg_dsb' */
	/* ASAP2::Database : delete 'Cxx_ext_ctrl_sens_spg_max_t' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_ext_ctrl_max_n
			Cxx_ext_ctrl_rps_max
			Cxx_ext_ctrl_sens_map_max
			Cxx_ext_ctrl_sens_spg_map_max_t
			Cxx_ext_ctrl_sens_spg_max
			Cxx_ext_ctrl_sens_tco_max
			Cxx_ext_ctrl_tbt_max
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ext_ctrl_eng_test_sf
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon_Evntmgr
		""
	/begin OUT_MEASUREMENT
			Vbx_ext_ctrl_test_act
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon_Monisft
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ext_ctrl_hot_test_vh_cdn_dsb
			Cbx_ext_ctrl_pdl_cdn_ena
			Cxx_ext_ctrl_acel_pdl_rat_thd
			Cxx_ext_ctrl_vs_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ext_ctrl_ena
			Vxx_ext_ctrl_test_sf
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon_Monispv
		""
	/begin DEF_CHARACTERISTIC
			Cxx_moni_stop_diag_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_clock
			Vbx_com_err
			Vbx_diag_sta_moni_ena
			Vbx_moni_appl_err
			Vbx_moni_dbl_nok
			Vbx_moni_id_nok
			Vbx_moni_nr_tot_id_nok
			Vbx_moni_oor
			Vbx_moni_read_req_done
			Vbx_moni_req_analyse
			Vbx_moni_req_data_changed
			Vsx_diag_sta_moni_stt
			Vxx_clock_ecu
			Vxx_clock_init_timeout
			Vxx_moni_nr_tot_id
			Vxx_timeout
			Vbx_moni_stop_diag
			Vxx_moni_sf_spv
			Vbx_diag_sta_moni_end
			Vbx_diag_sta_moni_abrt
			Vxx_init_timeout
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon_Routmng
		""
	/begin DEF_CHARACTERISTIC
			Cbx_diag_in_vvtc_ena_cam_crk_df
			Cxx_diag_ffig_it_psn_min
			Cxx_diag_in_vvtc_tco_max
			Cxx_diag_in_vvtc_tco_min
			Cxx_diag_in_vvtc_toil_max
			Cxx_diag_in_vvtc_toil_min
			Cxx_diag_in_vvtc_vb_min
			Cxx_diag_in_vvtc_vb_max
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_rout_run_stt
			Vbx_start_cdn
			Vbx_stop_cdn
			Vbx_valid_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin FUNCTION
		DgDgtMon_Tacmngx
		""
	/* ASAP2::Database : delete 'Csx_tac_02' */
	/* ASAP2::Database : delete 'Csx_tac_06' */
	/* ASAP2::Database : delete 'Csx_tac_07' */
	/* ASAP2::Database : delete 'Csx_tac_08' */
	/* ASAP2::Database : delete 'Csx_tac_09' */
	/* ASAP2::Database : delete 'Csx_tac_10' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_von_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_voff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_von_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_voff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_01.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_02.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_02.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_02.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_02.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_02.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_02.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_02.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_06.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_06.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_06.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_06.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_06.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_06.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_06.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_von_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_voff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_von_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_voff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_07.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_von_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_voff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_von_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_voff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_08.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_von_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_voff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_von_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_voff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_09.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_von_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_voff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_von_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_voff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_10.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Csx_tac_01' */
	/* ASAP2::Database : delete 'Csx_tac_20' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_von_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_voff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_von_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_voff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_20.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Csx_tac_27' */
	/* ASAP2::Database : delete 'Tac_cal_set_27.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_27.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_27.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_27.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_27.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_27.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_27.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_28.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_28.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_28.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_28.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_28.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_28.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_28.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Csx_tac_28' */
	/* ASAP2::Database : delete 'Csx_tac_44' */
	/* ASAP2::Database : delete 'Csx_tac_45' */
	/* ASAP2::Database : delete 'Csx_tac_46' */
	/* ASAP2::Database : delete 'Tac_cal_set_44.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_44.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_44.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_44.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_44.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_44.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_44.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_45.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_45.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_45.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_45.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_45.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_45.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_45.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_46.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_46.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_46.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_46.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_46.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_46.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_46.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_47.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_47.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_47.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_47.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_47.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_47.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_47.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_48.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_48.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_48.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_48.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_48.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_48.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_48.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Csx_tac_47' */
	/* ASAP2::Database : delete 'Csx_tac_48' */
	/* ASAP2::Database : delete 'Tac_cal_set_49.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_49.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_49.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_49.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_49.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_49.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_49.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_tini_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_ton_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_toff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_tini_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_ton_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_toff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_von_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_voff_io_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_von_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_voff_stac_xx' */
	/* ASAP2::Database : delete 'Tac_cal_set_50.Cxx_tac_nc_io_xx' */
	/* ASAP2::Database : delete 'Csx_tac_49' */
	/* ASAP2::Database : delete 'Csx_tac_50' */
	/* ASAP2::Database : 164 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cbx_it_ofs_clos_frst_dsb
			Cbx_it_ofs_open_frst_dsb
			Csx_tac_03
			Csx_tac_04
			Csx_tac_05
			Csx_tac_11
			Csx_tac_12
			Csx_tac_13
			Csx_tac_14
			Csx_tac_17
			Cxx_tac_tout_timer_io
			Cxx_tac_tout_timer_stac
			Cxx_tac_vb_min
			Cxx_tac_vb_max
			Tac_cal_set_03.Cxx_tac_tini_io_xx
			Tac_cal_set_03.Cxx_tac_ton_io_xx
			Tac_cal_set_03.Cxx_tac_toff_io_xx
			Tac_cal_set_03.Cxx_tac_tini_stac_xx
			Tac_cal_set_03.Cxx_tac_ton_stac_xx
			Tac_cal_set_03.Cxx_tac_toff_stac_xx
			Tac_cal_set_03.Cxx_tac_nc_io_xx
			Tac_cal_set_04.Cxx_tac_tini_io_xx
			Tac_cal_set_04.Cxx_tac_ton_io_xx
			Tac_cal_set_04.Cxx_tac_toff_io_xx
			Tac_cal_set_04.Cxx_tac_tini_stac_xx
			Tac_cal_set_04.Cxx_tac_ton_stac_xx
			Tac_cal_set_04.Cxx_tac_toff_stac_xx
			Tac_cal_set_04.Cxx_tac_nc_io_xx
			Tac_cal_set_05.Cxx_tac_tini_io_xx
			Tac_cal_set_05.Cxx_tac_ton_io_xx
			Tac_cal_set_05.Cxx_tac_toff_io_xx
			Tac_cal_set_05.Cxx_tac_tini_stac_xx
			Tac_cal_set_05.Cxx_tac_ton_stac_xx
			Tac_cal_set_05.Cxx_tac_toff_stac_xx
			Tac_cal_set_05.Cxx_tac_nc_io_xx
			Tac_cal_set_11.Cxx_tac_tini_io_xx
			Tac_cal_set_11.Cxx_tac_ton_io_xx
			Tac_cal_set_11.Cxx_tac_toff_io_xx
			Tac_cal_set_11.Cxx_tac_tini_stac_xx
			Tac_cal_set_11.Cxx_tac_ton_stac_xx
			Tac_cal_set_11.Cxx_tac_toff_stac_xx
			Tac_cal_set_11.Cxx_tac_von_io_xx
			Tac_cal_set_11.Cxx_tac_voff_io_xx
			Tac_cal_set_11.Cxx_tac_von_stac_xx
			Tac_cal_set_11.Cxx_tac_voff_stac_xx
			Tac_cal_set_11.Cxx_tac_nc_io_xx
			Tac_cal_set_12.Cxx_tac_tini_io_xx
			Tac_cal_set_12.Cxx_tac_ton_io_xx
			Tac_cal_set_12.Cxx_tac_toff_io_xx
			Tac_cal_set_12.Cxx_tac_tini_stac_xx
			Tac_cal_set_12.Cxx_tac_ton_stac_xx
			Tac_cal_set_12.Cxx_tac_toff_stac_xx
			Tac_cal_set_12.Cxx_tac_von_io_xx
			Tac_cal_set_12.Cxx_tac_voff_io_xx
			Tac_cal_set_12.Cxx_tac_von_stac_xx
			Tac_cal_set_12.Cxx_tac_voff_stac_xx
			Tac_cal_set_12.Cxx_tac_nc_io_xx
			Tac_cal_set_13.Cxx_tac_tini_io_xx
			Tac_cal_set_13.Cxx_tac_ton_io_xx
			Tac_cal_set_13.Cxx_tac_toff_io_xx
			Tac_cal_set_13.Cxx_tac_tini_stac_xx
			Tac_cal_set_13.Cxx_tac_ton_stac_xx
			Tac_cal_set_13.Cxx_tac_toff_stac_xx
			Tac_cal_set_13.Cxx_tac_von_io_xx
			Tac_cal_set_13.Cxx_tac_voff_io_xx
			Tac_cal_set_13.Cxx_tac_von_stac_xx
			Tac_cal_set_13.Cxx_tac_voff_stac_xx
			Tac_cal_set_13.Cxx_tac_nc_io_xx
			Tac_cal_set_14.Cxx_tac_tini_io_xx
			Tac_cal_set_14.Cxx_tac_ton_io_xx
			Tac_cal_set_14.Cxx_tac_toff_io_xx
			Tac_cal_set_14.Cxx_tac_tini_stac_xx
			Tac_cal_set_14.Cxx_tac_ton_stac_xx
			Tac_cal_set_14.Cxx_tac_toff_stac_xx
			Tac_cal_set_14.Cxx_tac_von_io_xx
			Tac_cal_set_14.Cxx_tac_voff_io_xx
			Tac_cal_set_14.Cxx_tac_von_stac_xx
			Tac_cal_set_14.Cxx_tac_voff_stac_xx
			Tac_cal_set_14.Cxx_tac_nc_io_xx
			Tac_cal_set_17.Cxx_tac_tini_io_xx
			Tac_cal_set_17.Cxx_tac_ton_io_xx
			Tac_cal_set_17.Cxx_tac_toff_io_xx
			Tac_cal_set_17.Cxx_tac_tini_stac_xx
			Tac_cal_set_17.Cxx_tac_ton_stac_xx
			Tac_cal_set_17.Cxx_tac_toff_stac_xx
			Tac_cal_set_17.Cxx_tac_nc_io_xx
			Csx_tac_18
			Tac_cal_set_18.Cxx_tac_tini_io_xx
			Tac_cal_set_18.Cxx_tac_ton_io_xx
			Tac_cal_set_18.Cxx_tac_toff_io_xx
			Tac_cal_set_18.Cxx_tac_tini_stac_xx
			Tac_cal_set_18.Cxx_tac_ton_stac_xx
			Tac_cal_set_18.Cxx_tac_toff_stac_xx
			Tac_cal_set_18.Cxx_tac_von_io_xx
			Tac_cal_set_18.Cxx_tac_voff_io_xx
			Tac_cal_set_18.Cxx_tac_von_stac_xx
			Tac_cal_set_18.Cxx_tac_voff_stac_xx
			Tac_cal_set_18.Cxx_tac_nc_io_xx
			Tac_cal_set_26.Cxx_tac_tini_io_xx
			Tac_cal_set_26.Cxx_tac_ton_io_xx
			Tac_cal_set_26.Cxx_tac_toff_io_xx
			Tac_cal_set_26.Cxx_tac_tini_stac_xx
			Tac_cal_set_26.Cxx_tac_ton_stac_xx
			Tac_cal_set_26.Cxx_tac_toff_stac_xx
			Tac_cal_set_26.Cxx_tac_von_io_xx
			Tac_cal_set_26.Cxx_tac_voff_io_xx
			Tac_cal_set_26.Cxx_tac_von_stac_xx
			Tac_cal_set_26.Cxx_tac_voff_stac_xx
			Tac_cal_set_26.Cxx_tac_nc_io_xx
			Csx_tac_26
			Csx_tac_41
			Csx_tac_42
			Csx_tac_43
			Tac_cal_set_41.Cxx_tac_tini_io_xx
			Tac_cal_set_41.Cxx_tac_ton_io_xx
			Tac_cal_set_41.Cxx_tac_toff_io_xx
			Tac_cal_set_41.Cxx_tac_tini_stac_xx
			Tac_cal_set_41.Cxx_tac_ton_stac_xx
			Tac_cal_set_41.Cxx_tac_toff_stac_xx
			Tac_cal_set_41.Cxx_tac_von_io_xx
			Tac_cal_set_41.Cxx_tac_voff_io_xx
			Tac_cal_set_41.Cxx_tac_von_stac_xx
			Tac_cal_set_41.Cxx_tac_voff_stac_xx
			Tac_cal_set_41.Cxx_tac_nc_io_xx
			Tac_cal_set_42.Cxx_tac_tini_io_xx
			Tac_cal_set_42.Cxx_tac_ton_io_xx
			Tac_cal_set_42.Cxx_tac_toff_io_xx
			Tac_cal_set_42.Cxx_tac_tini_stac_xx
			Tac_cal_set_42.Cxx_tac_ton_stac_xx
			Tac_cal_set_42.Cxx_tac_toff_stac_xx
			Tac_cal_set_42.Cxx_tac_von_io_xx
			Tac_cal_set_42.Cxx_tac_voff_io_xx
			Tac_cal_set_42.Cxx_tac_von_stac_xx
			Tac_cal_set_42.Cxx_tac_voff_stac_xx
			Tac_cal_set_42.Cxx_tac_nc_io_xx
			Tac_cal_set_43.Cxx_tac_tini_io_xx
			Tac_cal_set_43.Cxx_tac_ton_io_xx
			Tac_cal_set_43.Cxx_tac_toff_io_xx
			Tac_cal_set_43.Cxx_tac_tini_stac_xx
			Tac_cal_set_43.Cxx_tac_ton_stac_xx
			Tac_cal_set_43.Cxx_tac_toff_stac_xx
			Tac_cal_set_43.Cxx_tac_von_io_xx
			Tac_cal_set_43.Cxx_tac_voff_io_xx
			Tac_cal_set_43.Cxx_tac_von_stac_xx
			Tac_cal_set_43.Cxx_tac_voff_stac_xx
			Tac_cal_set_43.Cxx_tac_nc_io_xx
			Csx_tac_22
			Csx_tac_23
			Csx_tac_24
			Csx_tac_25
			Csx_tac_29
			Csx_tac_30
			Csx_tac_31
			Csx_tac_32
			Csx_tac_35
			Csx_tac_36
			Csx_tac_37
			Csx_tac_38
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Tac_data_set_20.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_20.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_01.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_01.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_01.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_01.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_01.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_10.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_10.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_10.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_10.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_10.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_09.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_09.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_09.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_09.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_09.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_08.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_08.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_08.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_08.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_08.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_07.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_07.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_07.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_07.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_07.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_06.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_06.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_06.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_06.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_06.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_02.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_02.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_02.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_02.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_02.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_20.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_20.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_20.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_27.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_27.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_27.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_27.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_27.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_28.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_28.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_28.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_28.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_28.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_44.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_44.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_44.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_45.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_45.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_45.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_46.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_46.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_46.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_44.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_44.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_45.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_45.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_46.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_46.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_47.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_47.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_48.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_48.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_47.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_47.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_47.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_48.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_48.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_48.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_49.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_49.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_50.Vsx_tac_xx_cdn' */
	/* ASAP2::Database : delete 'Tac_data_set_50.Vbx_tac_xx_req' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_49.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_49.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_49.Vxx_tac_xx_nc' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_50.Vxx_tmp_dly_xx' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_50.Vxx_tac_xx_subval' */
	/* ASAP2::Database : delete 'Tac_data_set_rsa_50.Vxx_tac_xx_nc' */
	/* ASAP2::Database : 85 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_diag_sta_stac_abrt
			Vbx_diag_sta_stac_ena
			Vbx_diag_sta_stac_end
			Vsx_tac_22_stt
			Vsx_tac_23_stt
			Vsx_tac_24_stt
			Vsx_tac_25_stt
			Vbx_tac_cdn
			Vbx_tac_ena
			Vbx_tac_tout
			Vsx_opt
			Vsx_tac_stt
			Vxx_LID
			Vxx_tac_tout_timer
			Tac_data_set_22.Vsx_tac_xx_cdn
			Tac_data_set_22.Vbx_tac_xx_req
			Tac_data_set_23.Vsx_tac_xx_cdn
			Tac_data_set_23.Vbx_tac_xx_req
			Tac_data_set_24.Vsx_tac_xx_cdn
			Tac_data_set_24.Vbx_tac_xx_req
			Tac_data_set_25.Vsx_tac_xx_cdn
			Tac_data_set_25.Vbx_tac_xx_req
			Tac_data_set_rsa_26.Vxx_tmp_dly_xx
			Tac_data_set_rsa_26.Vxx_tac_xx_subval
			Tac_data_set_rsa_26.Vxx_tac_xx_nc
			Tac_data_set_18.Vsx_tac_xx_cdn
			Tac_data_set_18.Vbx_tac_xx_req
			Tac_data_set_17.Vsx_tac_xx_cdn
			Tac_data_set_17.Vbx_tac_xx_req
			Tac_data_set_rsa_17.Vxx_tmp_dly_xx
			Tac_data_set_rsa_17.Vxx_tac_xx_subval
			Tac_data_set_rsa_17.Vxx_tac_xx_nc
			Tac_data_set_14.Vsx_tac_xx_cdn
			Tac_data_set_14.Vbx_tac_xx_req
			Tac_data_set_rsa_14.Vxx_tmp_dly_xx
			Tac_data_set_rsa_14.Vxx_tac_xx_subval
			Tac_data_set_rsa_14.Vxx_tac_xx_nc
			Tac_data_set_13.Vsx_tac_xx_cdn
			Tac_data_set_13.Vbx_tac_xx_req
			Tac_data_set_rsa_13.Vxx_tmp_dly_xx
			Tac_data_set_rsa_13.Vxx_tac_xx_subval
			Tac_data_set_rsa_13.Vxx_tac_xx_nc
			Tac_data_set_12.Vsx_tac_xx_cdn
			Tac_data_set_12.Vbx_tac_xx_req
			Tac_data_set_rsa_12.Vxx_tmp_dly_xx
			Tac_data_set_rsa_12.Vxx_tac_xx_subval
			Tac_data_set_rsa_12.Vxx_tac_xx_nc
			Tac_data_set_11.Vsx_tac_xx_cdn
			Tac_data_set_11.Vbx_tac_xx_req
			Tac_data_set_rsa_11.Vxx_tmp_dly_xx
			Tac_data_set_rsa_11.Vxx_tac_xx_subval
			Tac_data_set_rsa_11.Vxx_tac_xx_nc
			Tac_data_set_05.Vsx_tac_xx_cdn
			Tac_data_set_05.Vbx_tac_xx_req
			Tac_data_set_rsa_05.Vxx_tmp_dly_xx
			Tac_data_set_rsa_05.Vxx_tac_xx_subval
			Tac_data_set_rsa_05.Vxx_tac_xx_nc
			Tac_data_set_04.Vsx_tac_xx_cdn
			Tac_data_set_04.Vbx_tac_xx_req
			Tac_data_set_rsa_04.Vxx_tmp_dly_xx
			Tac_data_set_rsa_04.Vxx_tac_xx_subval
			Tac_data_set_rsa_04.Vxx_tac_xx_nc
			Tac_data_set_03.Vsx_tac_xx_cdn
			Tac_data_set_03.Vbx_tac_xx_req
			Tac_data_set_rsa_03.Vxx_tmp_dly_xx
			Tac_data_set_rsa_03.Vxx_tac_xx_subval
			Tac_data_set_rsa_03.Vxx_tac_xx_nc
			Tac_data_set_29.Vsx_tac_xx_cdn
			Tac_data_set_29.Vbx_tac_xx_req
			Tac_data_set_30.Vsx_tac_xx_cdn
			Tac_data_set_30.Vbx_tac_xx_req
			Tac_data_set_31.Vsx_tac_xx_cdn
			Tac_data_set_31.Vbx_tac_xx_req
			Tac_data_set_32.Vsx_tac_xx_cdn
			Tac_data_set_32.Vbx_tac_xx_req
			Tac_data_set_35.Vsx_tac_xx_cdn
			Tac_data_set_35.Vbx_tac_xx_req
			Tac_data_set_36.Vsx_tac_xx_cdn
			Tac_data_set_36.Vbx_tac_xx_req
			Tac_data_set_37.Vsx_tac_xx_cdn
			Tac_data_set_37.Vbx_tac_xx_req
			Tac_data_set_38.Vsx_tac_xx_cdn
			Tac_data_set_38.Vbx_tac_xx_req
			Vsx_tac_29_stt
			Vsx_tac_30_stt
			Vsx_tac_31_stt
			Vsx_tac_32_stt
			Vsx_tac_35_stt
			Vsx_tac_36_stt
			Vsx_tac_37_stt
			Vsx_tac_38_stt
			Tac_data_set_rsa_18.Vxx_tmp_dly_xx
			Tac_data_set_rsa_18.Vxx_tac_xx_subval
			Tac_data_set_rsa_18.Vxx_tac_xx_nc
			Tac_data_set_26.Vsx_tac_xx_cdn
			Tac_data_set_26.Vbx_tac_xx_req
			Tac_data_set_rsa_41.Vxx_tmp_dly_xx
			Tac_data_set_rsa_41.Vxx_tac_xx_subval
			Tac_data_set_rsa_41.Vxx_tac_xx_nc
			Tac_data_set_rsa_42.Vxx_tmp_dly_xx
			Tac_data_set_rsa_42.Vxx_tac_xx_subval
			Tac_data_set_rsa_42.Vxx_tac_xx_nc
			Tac_data_set_rsa_43.Vxx_tmp_dly_xx
			Tac_data_set_rsa_43.Vxx_tac_xx_subval
			Tac_data_set_rsa_43.Vxx_tac_xx_nc
			Tac_data_set_41.Vsx_tac_xx_cdn
			Tac_data_set_41.Vbx_tac_xx_req
			Tac_data_set_42.Vsx_tac_xx_cdn
			Tac_data_set_42.Vbx_tac_xx_req
			Tac_data_set_43.Vsx_tac_xx_cdn
			Tac_data_set_43.Vbx_tac_xx_req
			Vsx_diag_sta_stac_stt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/begin FUNCTION
		DgDgtSer
		""
	/begin SUB_FUNCTION
			DgDgtSer_docserx
			DgDgtSer_obdserx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/begin FUNCTION
		DgDgtSer_docserx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fail_dft_ini_req
			Ctx_vin_crc_ini_data[0]
			Ctx_vin_crc_ini_data[1]
			Ctx_vin_crc_ini_data[2]
			Ctx_vin_crc_ini_data[3]
			Ctx_vin_crc_ini_data[4]
			Ctx_vin_crc_ini_data[5]
			Ctx_vin_crc_ini_data[6]
			Ctx_vin_crc_ini_data[7]
			Ctx_vin_crc_ini_data[8]
			Ctx_vin_crc_ini_data[9]
			Ctx_vin_crc_ini_data[10]
			Ctx_vin_crc_ini_data[11]
			Ctx_vin_crc_ini_data[12]
			Ctx_vin_crc_ini_data[13]
			Ctx_vin_crc_ini_data[14]
			Ctx_vin_crc_ini_data[15]
			Ctx_vin_crc_ini_data[16]
			Ctx_vin_crc_ini_data[17]
			Ctx_vin_crc_ini_data[18]
			Cxx_c_nr1
			Cxx_c_nr2
			Cxx_cert_id
			Cxx_diag_nr
			Cxx_ecu_nr1
			Cxx_ecu_nr2
			Cxx_ecu_nr3
			Cxx_ecu_nr4
			Cxx_ecu_nr5
			Cxx_etun_nr
			Cxx_oem_id
			Cxx_prog_nr1
			Cxx_prog_nr2
			Cxx_rsa_did_lim_val_cfm
			Cxx_supl_nr1
			Cxx_supl_nr2
			Cxx_supl_nr3
			Cxx_sys_c_nr
			Cxx_vers_nr1
			Cxx_vers_nr2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[0]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[1]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[2]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[3]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[4]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[5]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[6]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[7]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[8]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[9]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[10]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[11]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[12]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[13]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[14]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[15]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[16]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[17]
			DgDgtSer_0_NVM.Vtx_vin_crc_data_NVM[18]
			Vsx_diag_sess
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/begin FUNCTION
		DgDgtSer_obdserx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_obd_fail_dft_ini_req
	/end DEF_CHARACTERISTIC
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/begin FUNCTION
		InAsiEgr
		""
	/begin SUB_FUNCTION
			InAsiEgr_Evpossr
			InAsiEgr_Dectxsr
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InAsiEgr_Dectxsr
		""
	/* ASAP2::Database : delete 'Vbx_sens_egr_temp_diag_cdn' */
	/* ASAP2::Database : delete 'Vbx_down_egr_cool_temp_swi_pup' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_down_egr_cool_temp_vld
			Vxx_down_egr_cool_temp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/begin FUNCTION
		InAsiEgr_Evpossr
		""
	/begin DEF_CHARACTERISTIC
			Cbx_emtv_sens_typ_cfm
			Cxx_emtv_dft_psn_1
			Cxx_emtv_sens_pws
			Cxx_emtv_stab_dly_2
			Cxx_emtv_psn_v_lim_up
			Cxx_emtv_psn_v_lim_down
			Cxx_emtv_psn_stab_thd_2
			Cxx_dfinc_sens_emtv_nok
			Cxx_dfdec_sens_emtv_nok
			Ctb_emtv_sens_cor
			Ctp_emtv_sens_cor
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_emtv_psn_vld
			Vbx_emtv_sens_pws_nok
			Vxx_emtv_abs_psn
			Vxx_emtv_psn_raw_mv_tot
			Vbx_df_sens_emtv_nok
			Vbx_emtv_psn_stab_det
			Vxx_emtv_psn_chr
			Vxx_emtv_psn_raw_stab
			Vxx_emtv_abs_psn_1
			Vbx_emtv_psn_stab
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin FUNCTION
		InAsiIaf
		""
	/begin SUB_FUNCTION
			InAsiIaf_Mafxxcs
			InAsiIaf_Mafxxsr
			InAsiIaf_Icmafmd
			InAsiIaf_Mafdymd
			InAsiIaf_Fmafmdx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InAsiIaf_Fmafmdx
		""
	/* ASAP2::Database : delete 'Vxx_egr_valve_sec_mafe' */
	/* ASAP2::Database : delete 'Vxx_evp_mafe_fresh_corr' */
	/* ASAP2::Database : delete 'Vxx_f2f3_result' */
	/* ASAP2::Database : delete 'Vxx_f3_result' */
	/* ASAP2::Database : delete 'Vxx_f4f3_result' */
	/* ASAP2::Database : delete 'Vxx_n_avg' */
	/* ASAP2::Database : delete 'Vxx_prs_ratio' */
	/* ASAP2::Database : delete 'Vxx_temp_cor_egr_fat' */
	/* ASAP2::Database : 8 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_mdl_maf_vld
			Vxx_mdl_maf
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin FUNCTION
		InAsiIaf_Icmafmd
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_tco_cor_egrless
			Ctp_tco_cor_egrless
			Cbx_ic_maf_maf_mdl_cfm
			Ctb_x_eng_vol_efy_in
			Ctb_y_eng_vol_efy_ex
			Ctb_y_eng_vol_efy_in
			Cmp_eng_vol_efy_in
			Ctb_x_eng_vol_efy_ex
			Ctb_x_tia_cor_egrless
			Ctp_tia_cor_egrless
			Cxx_eng_vol_efy_ex_max_lim
			Cxx_eng_vol_efy_in_max_lim
			Cxx_eng_vol_efy_ex_min_lim
			Cxx_eng_vol_efy_in_min_lim
			Cbx_ic_maf_ex_cor_fail_cfm
			Cbx_ic_maf_mdl_cfm
			Cmp_eng_vol_efy_ex
			Cxx_cyl_vol
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_mdl_maf_ic_vld
			Vxx_mdl_maf_ic
			Vxx_temp_cor_egrless
			Vxx_air_dens_ex
			Vxx_vol_eff_ex
			Vxx_vol_eff_in
			Vxx_air_dens_in
			Vxx_esti_icmaf_kgh
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin FUNCTION
		InAsiIaf_Mafdymd
		""
	/begin DEF_CHARACTERISTIC
			Cbx_maf_dyn_fil_cfm
			Cxx_cool_vol
			Cxx_maf_dyn_1_mdl_ftc
			Cxx_maf_dyn_ftc
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_mdl_maf_dyn_ok
			Vxx_maf_dyn_prt
			Vxx_maf_dyn_prt_drv
			Vsx_mdl_maf_dyn_vld
			Vxx_mdl_maf_dyn
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin FUNCTION
		InAsiIaf_Mafxxcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_maf_fail_2_cfm
			Cbx_mafs_plau_diag_cfm
			Cbx_mafs_pres_cfm
			Cxx_comb_mod_mafs_plau_diag_1
			Cxx_comb_mod_mafs_plau_diag_2
			Cxx_comb_mod_mafs_plau_diag_3
			Cxx_air_temp_inf
			Cxx_amp_sup
			Cxx_diag_esti_tol_h
			Cxx_diag_esti_tol_l
			Cxx_load_inf
			Cxx_load_sup
			Cxx_maf_dyn_fail_swi_neg_slop
			Cxx_maf_dyn_fail_swi_pos_slop
			Cxx_n_mv_inf
			Cxx_n_mv_sup
			Cxx_sens_maf_fail_swi_neg_slop
			Cxx_sens_maf_fail_swi_pos_slop
			Cxx_tco_inf
			Cxx_tco_sup
			Cxx_tia_grd_inf
			Cxx_tia_grd_sup
			Cxx_air_temp_sup
			Cxx_sens_maf_fail_val
			Cbx_maf_dyn_fail_2_cfm
			Cxx_dfdec_mafs_apl_up
			Cxx_dfdec_mafs_apl_down
			Cxx_dfinc_mafs_apl_up
			Cxx_dfinc_mafs_apl_down
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_maf_dyn_kgh_vld
			Vxx_maf_kgh
			Vsx_maf_kgh_vld
			Vsx_air_in_sys_vld
			Vsx_maf_vld
			Vxx_maf
			Vxx_maf_dyn
			Vxx_maf_dyn_kgh
			Vbx_diag_ena_act
			Vbx_diag_ena_amb
			Vbx_diag_ena_zone
			Vsx_mdl_maf_dyn_cs_vld
			Vsx_sens_maf_cs_vld
			Vxx_maf_cs
			Vxx_maf_dyn_cs
			Vsx_maf_dyn_vld
			Vbx_diag_ena_mafs_plau
			Vbx_df_mafs_apl_up
			Vbx_df_mafs_apl_down
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin FUNCTION
		InAsiIaf_Mafxxsr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tqi_maf_cor
			Cmp_puls_maf_cor
			Ctb_n_maf_cor
			Cxx_dfinc_sens_maf_l
			Cxx_dfinc_sens_maf_h
			Cxx_dfdec_sens_maf_l
			Cxx_dfdec_sens_maf_h
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_sens_maf
			Vxx_sens_maf_puls_cor
			Vsx_sens_maf_vld
			Vxx_sens_maf
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/begin FUNCTION
		InAsiIap
		""
	/begin OUT_MEASUREMENT
			InAsiIap_NVM.Vxx_spg_dif_mem_NVM
			InAsiIap_NVM.Vxx_map_dif_mem_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			InAsiIap_Ampxxsr
			InAsiIap_Spgxxsr
			InAsiIap_Spgxxcs
			InAsiIap_Mapxxsr
			InAsiIap_Mapxxcs
			InAsiIap_Mapxxmd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/begin FUNCTION
		InAsiIap_Ampxxsr
		""
	/begin DEF_CHARACTERISTIC
			Cxx_amp_chr_map_spg_dif
			Cxx_amp_map_spg_dif
			Cxx_dfdec_sens_amp_l
			Cxx_dfinc_sens_amp_h
			Cxx_dfinc_sens_amp_l
			Cbx_spg_sens_pres_cfm
			Cxx_dfdec_sens_amp_h
			Cxx_sens_amp_fail_val
			Cxx_dfdec_amp_reg_chr
			Cxx_dfinc_amp_reg_chr
			Cxx_amp_chr_amp_max
			Cxx_amp_chr_amp_min
			Cxx_amp_chr_tco_min
			Cxx_amp_chr_tco_max
			Cxx_amp_chr_tia_max
			Cxx_amp_chr_tia_min
			Cxx_amp_chr_n_max
			Cxx_amp_chr_tqi_max
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_amp_vld
			Vxx_amp
			Vbx_amp_chr_cnd
			Vbx_amp_chr_in_vld
			Vbx_amp_chr_prs_cond
			Vbx_df_amp_reg_chr
			Vbx_diag_ena_amp_reg_chr
			Vbx_df_ena_amp
			Vbx_df_ena_amp_chr
			Vbx_df_ena_amp_h
			Vbx_df_ena_amp_l
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/begin FUNCTION
		InAsiIap_Mapxxcs
		""
	/begin DEF_CHARACTERISTIC
			Ctb_map_fail_amp
			Ctb_map_fail_fim_tot
			Ctb_map_fail_n
			Cmp_map_fail_val
			Ctp_map_fail_val_cor
			Cxx_map_ftc
			Cbx_map_sens_pres_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_raw_map
			Vsx_map_vld
			Vxx_map
			Vxx_map_fail_val
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InAsiIap_Mapxxmd
		""
	/* ASAP2::Database : delete 'Vxx_it_psn_0' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_mdl_map_vld
			Vxx_mdl_map
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/begin FUNCTION
		InAsiIap_Mapxxsr
		""
	/begin DEF_CHARACTERISTIC
			Cbx_mapc_ad_calc
			Cbx_mapc_pres_cfm
			Cxx_dfdec_sens_map_h
			Cxx_dfdec_sens_map_l
			Cxx_dfinc_sens_map_h
			Cxx_dfinc_sens_map_l
			Cxx_mapc_amp_max
			Cxx_mapc_amp_min
			Cxx_mapc_tco_max
			Cxx_mapc_tia_max
			Cxx_mapc_tia_min
			Ctp_damp_map_dif
			Ctb_damp_map_dif
			Cxx_mapc_dly_avg
			Cxx_mapc_ftc_amp
			Cxx_mapc_ftc_map
			Cxx_mapc_dif_max
			Cxx_mapc_dif_min
			Cxx_dfdec_map_nok_apc
			Cxx_dfdec_map_nok_isr
			Cxx_dfinc_map_nok_apc
			Cxx_dfinc_map_nok_isr
			Cxx_mapc_it_psn_min_apc
			Cxx_mapc_it_psn_min_isr
			Cxx_mapc_plau_diag_apc
			Cxx_mapc_plau_diag_isr
			Cxx_mapc_tco_min
			Cxx_mapc_n_max
			Cxx_mapc_tqi_max
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_mapc_cdn_ok
			Vxx_map_dif
			Vxx_map_dif_raw
			Vbx_mapc_ad_ena
			Vbx_mapc_ad_end
			Vbx_mapc_no_fail_apc
			Vbx_mapc_no_fail_isr
			Vxx_mapc_ad_pres
			Vxx_mapc_hpf_amp
			Vxx_mapc_hpf_map
			Vbx_df_ena_map_h
			Vbx_df_ena_map_l
			Vbx_df_ena_map_nok
			Vbx_diag_ena_map_nok_apc
			Vbx_diag_ena_map_nok_isr
			Vxx_map_dif_damp
			Vbx_df_map_nok_apc
			Vbx_df_map_nok_isr
			Vbx_mapc_eng_stop
			Vbx_mapc_it_psn_ok
			Vsx_sens_map_vld
			Vxx_sens_map
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/begin FUNCTION
		InAsiIap_Spgxxcs
		""
	/begin DEF_CHARACTERISTIC
			Ctb_spg_fail_amp
			Ctb_spg_fail_fim_tot
			Ctb_spg_fail_n
			Cxx_spg_fail_max_slop
			Cmp_spg_fail_val
			Ctp_spg_fail_val_cor
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_it_clos_spg_ok
			Vxx_spg
			Vsx_spg_vld
			Vxx_spg_fail_val
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InAsiIap_Spgxxsr
		""
	/* ASAP2::Database : delete 'Vbx_spgc_cdn_ok' */
	/* ASAP2::Database : delete 'Vxx_spg_dif' */
	/* ASAP2::Database : delete 'Vxx_spg_dif_raw' */
	/* ASAP2::Database : delete 'Vbx_df_spg_nok' */
	/* ASAP2::Database : delete 'Vbx_spgc_ad_ena' */
	/* ASAP2::Database : delete 'Vbx_spgc_ad_end' */
	/* ASAP2::Database : delete 'Vbx_spgc_no_fail_apc' */
	/* ASAP2::Database : delete 'Vbx_spgc_no_fail_isr' */
	/* ASAP2::Database : delete 'Vxx_spgc_ad_pres' */
	/* ASAP2::Database : delete 'Vxx_spgc_hpf_amp' */
	/* ASAP2::Database : delete 'Vxx_spgc_hpf_spg' */
	/* ASAP2::Database : delete 'Vbx_df_ena_spg_h' */
	/* ASAP2::Database : delete 'Vbx_df_ena_spg_l' */
	/* ASAP2::Database : delete 'Vbx_df_ena_spg_nok' */
	/* ASAP2::Database : delete 'Vbx_diag_ena_spg_nok' */
	/* ASAP2::Database : delete 'Vbx_diag_ena_spg_nok_apc' */
	/* ASAP2::Database : delete 'Vbx_diag_ena_spg_nok_isr' */
	/* ASAP2::Database : delete 'Vxx_spg_dif_damp' */
	/* ASAP2::Database : 18 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_sens_spg_vld
			Vxx_sens_spg
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin FUNCTION
		InAsiIat
		""
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : 36 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_tia.Cxx_dtc_hmb_xxx
			fm_cal_sens_tia_h.Cxx_dtc_obd_xxx
			fm_cal_sens_tia_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_tia_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_tia_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_tia_h.Cxx_dtc_lb_xxx
			fm_cal_sens_tia_h.Cxx_obd_dc_xxx
			fm_cal_sens_tia_l.Cxx_dtc_obd_xxx
			fm_cal_sens_tia_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_tia_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_tia_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_tia_l.Cxx_dtc_lb_xxx
			fm_cal_sens_tia_l.Cxx_obd_dc_xxx
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_mat_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_mat_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_h.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_h.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_sens_up_it_temp_l.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_sens_up_it_temp_l.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : 48 referenced entries deleted */
	/begin OUT_MEASUREMENT
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_tia_h.Vxx_dfctr_xxx
			fm_sta_sens_tia_h.Vxx_rdn_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_tia_h.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_tia_h.Vxx_dtc_stt_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_mf_xxx
			fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_cf_xxx
			fm_sta_sens_tia_l.Vxx_dfctr_xxx
			fm_sta_sens_tia_l.Vxx_rdn_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_cf_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_clf_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_df_old_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_dfctr_sat_xxx
			fm_sta_sens_tia_l.fm_static_bitfield.Vbx_rdn_xxx
			fm_sta_sens_tia_l.Vxx_dtc_stt_xxx
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			InAsiIat_Tiaxxsr
			InAsiIat_Tenvxcs
			InAsiIat_Uitxxsr
			InAsiIat_Uitxxcs
			InAsiIat_Uitxxmd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin FUNCTION
		InAsiIat_Tenvxcs
		""
	/begin OUT_MEASUREMENT
			Vsx_tenv_vld
			Vxx_tenv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin FUNCTION
		InAsiIat_Tiaxxsr
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tenv_sens_pres_cfm
			Cxx_dfdec_sens_tia_h
			Cxx_dfdec_sens_tia_l
			Cxx_dfinc_sens_tia_h
			Cxx_dfinc_sens_tia_l
			Cxx_tia_fail_val
			Cxx_vs_thd_h
			Cxx_vs_thd_l
			Cxx_vs_thd_med
			Cxx_vs_thd_t
			Cxx_t_acq_tenv
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_tia_vld
			Vxx_tia
			Vsx_sens_tia_vld
			Vxx_temp_init
			Vxx_tia_cor
			Vxx_tia_cor_1
			Vxx_tia_cor_ctl
			Vxx_tia_cor_ctr
			Vxx_vs_thd_t
			Vbx_df_sens_tia
			Vxx_t_acq_tenv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin FUNCTION
		InAsiIat_Uitxxcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_up_it_temp_sens_pres_cfm
			Cxx_up_it_temp_fail_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_up_it_temp_vld
			Vxx_up_it_temp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin FUNCTION
		InAsiIat_Uitxxmd
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tco_cor
			Ctb_tqi_fil
			Ctb_x_efy_cpr
			Ctb_y_efy_cpr
			Ctb_y_efy_spg_cool
			Cxx_down_air_fil_prs_max
			Cxx_down_air_fil_prs_min
			Cxx_efy_spg_cool_max
			Cxx_efy_spg_cool_min
			Cxx_fac_prs_loss
			Cxx_spg_cool_fil
			Cxx_vs_max
			Cxx_vs_min
			Cmp_efy_cpr
			Cmp_efy_spg_cool
			Ctp_tco_cor
			Ctp_tqi_fil
			Ctb_x_efy_spg_cool
			Cxx_air_fil_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_mdl_up_it_temp_vld
			Vxx_cpr_prs_rat
			Vxx_down_air_fil_prs
			Vxx_down_air_fil_prs_sat
			Vxx_down_cpr_prs
			Vxx_down_cpr_prs_bfr
			Vxx_down_cpr_temp
			Vxx_down_cpr_temp_bfr
			Vxx_efy_spg_cool
			Vxx_efy_spg_cool_sat
			Vxx_mdl_up_it_temp
			Vxx_mdl_up_it_temp_raw
			Vxx_up_cool_spg_prs
			Vxx_up_cpr_prs
			Vxx_vs_sat
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin FUNCTION
		InAsiIat_Uitxxsr
		""
	/begin OUT_MEASUREMENT
			Vsx_sens_up_it_temp_vld
			Vxx_sens_up_it_temp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/begin FUNCTION
		InAsiIti
		""
	/begin SUB_FUNCTION
			InAsiIti_Itpossr_xxxxxd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/begin FUNCTION
		InAsiIti_Itpossr_xxxxxd
		""
	/begin DEF_CHARACTERISTIC
			Ctb_it_sens_cor
			Ctp_it_sens_cor
			Cbx_it_sens_typ
			Cxx_dfdec_sens_it_nok
			Cxx_dfinc_sens_it_nok
			Cxx_it_dft_psn_1
			Cxx_it_psn_stab_thd
			Cxx_it_psn_v_lim_down
			Cxx_it_psn_v_lim_up
			Cxx_it_sens_pws
			Cxx_it_stab_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_sens_it_nok
			Vbx_it_psn_stab
			Vbx_it_psn_stab_det
			Vbx_it_sens_pws_nok
			Vsx_it_psn_vld
			Vxx_it_abs_psn
			Vxx_it_abs_psn_1
			Vxx_it_chr_psn
			Vxx_it_psn_raw_mv_tot
			Vxx_it_psn_raw_stab
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/begin FUNCTION
		InAsiPbt
		""
	/begin SUB_FUNCTION
			InAsiPbt_Pbtxxsr
			InAsiPbt_Patxxmd
			InAsiPbt_Pbtxxcs
			InAsiPbt_Pbtxxmd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/begin FUNCTION
		InAsiPbt_Patxxmd
		""
	/begin DEF_CHARACTERISTIC
			Ctb_egaf_cor_pat
			Ctb_pft_utp_pat
			Ctp_cata_dp_pat
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pat_vld
			Vxx_pat
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/begin FUNCTION
		InAsiPbt_Pbtxxcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ex_prs_sens_pres_cfm
			Cxx_ex_prs_fail_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_ex_prs_vld
			Vxx_ex_prs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/begin FUNCTION
		InAsiPbt_Pbtxxmd
		""
	/begin DEF_CHARACTERISTIC
			Cbx_mdl_ex_prs_fail_cfm
			Cxx_mdl_ex_prs_ofs
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_mdl_ex_prs_vld
			Vxx_mdl_ex_prs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/begin FUNCTION
		InAsiPbt_Pbtxxsr
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_ex_prs_no_lk
			Cxx_dfdec_sens_ex_prs_h
			Cxx_dfdec_sens_ex_prs_l
			Cxx_dfinc_sens_ex_prs_h
			Cxx_dfinc_sens_ex_prs_l
			Cxx_ex_prs_no_lk_n_thd
			Cxx_pbt_amp_dif_thd
			Cxx_dfinc_ex_prs_no_lk
			Cbx_pft_pres_cfm
			Cxx_ex_prs_nok_apc_dif
			Cxx_ex_prs_nok_isr_dif
			Cxx_sens_ex_prs_apc_dfdec
			Cxx_sens_ex_prs_apc_dfinc
			Cxx_sens_ex_prs_isr_dfdec
			Cxx_sens_ex_prs_isr_dfinc
			Cbx_ex_prs_cold_cut_no_lk_cfm
			Cbx_ex_prs_cold_cut_nok_cfm
			Cbx_ex_prs_cold_cut_sens_h_cfm
			Cbx_ex_prs_cold_cut_sens_l_cfm
			Cbx_ex_prs_nok_amp
			Cxx_ex_prs_no_lk_tqi_thd
			Cxx_ex_prs_nok_n_thd
			Cxx_ex_prs_nok_tqi_thd
			Cxx_ex_prs_tia_cold_cut_dly
			Cxx_ex_prs_tia_cold_cut_h
			Cxx_ex_prs_tia_cold_cut_l
			Cbx_ex_prs_no_lk_it_open_dsb
			Cxx_ex_prs_no_lk_spg_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_ena_ex_prs_nok
			Vbx_df_ex_prs_nok
			Vbx_df_sens_ex_prs
			Vbx_df_sens_ex_prs_elec
			Vbx_diag_ena_ex_prs_no_lk
			Vbx_diag_ena_ex_prs_nok
			Vbx_sens_ex_prs_elec_fail
			Vbx_df_ena_ex_prs_no_lk
			Vxx_dfdec_ex_prs_nok
			Vxx_dfinc_ex_prs_nok
			Vbx_pbt_fmc_tia_cold_cut
			Vxx_sens_ex_prs
			Vsx_sens_ex_prs_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/begin FUNCTION
		InAtiEaf
		""
	/begin SUB_FUNCTION
			InAtiEaf_Egafxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/begin FUNCTION
		InAtiEaf_Egafxxx
		""
	/begin DEF_CHARACTERISTIC
			Csx_pft_egaf_clc_cfm
			Ctb_amp_sot_esti
			Cxx_pft_egaf_clc_fac
			Cxx_pft_egaf_fil_t_fil
			Cxx_pft_ms_clc_t_fil
			Ctp_pft_fac_egaf_sot_esti
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_egaf_cor_vld
			Vsx_pft_egaf_vld
			Vsx_pft_sys_egaf_vld
			Vxx_pft_egaf
			Vxx_pft_egaf_cor
			Vxx_pft_egaf_load_fil
			Vxx_pft_sys_egaf
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi
		""
	/begin OUT_MEASUREMENT
			InAtiPfi_NVM.Vxx_pft_vh_dist_ofs_NVM
			InAtiPfi_NVM.Vxx_pft_vh_dist_rgn_tia_mv_eprm_NVM
			InAtiPfi_NVM.Vxx_pft_tia_cor_mv_eprm_NVM
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			InAtiPfi_NVM.Vxx_rup_dif_mem_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			InAtiPfi_Ctlcsmx
			InAtiPfi_Ctlvsxx
			InAtiPfi_Dprscsx
			InAtiPfi_Exprsmd
			InAtiPfi_Msdpxxx
			InAtiPfi_O2facxx
			InAtiPfi_Pftdist
			InAtiPfi_Pftdpsr
			InAtiPfi_Pftefyx
			InAtiPfi_Ppsdgxx
			InAtiPfi_Rupxxsr
			InAtiPfi_Tiamvxx
			InAtiPfi_Uprsabv
			InAtiPfi_Uprscsx
			InAtiPfi_Dppsdgx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Ctlcsmx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_fil_1_t
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_csm_sum_sta
			Vxx_csm_sum_sta_drv_fil
			Vsx_csm_sum_sta_vld
			Vxx_csm_sum_sta_drv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Ctlvsxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_vs_fil_t
			Cxx_pft_vs_ini
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_pft_vs_fil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* ASAP2::Database : delete OUT_MEASUREMENT, since it is empty */
/begin FUNCTION
		InAtiPfi_Dppsdgx
		""
	/* ASAP2::Database : delete 'Cxx_dfdec_pft_dp_dirt_lkg' */
	/* ASAP2::Database : delete 'Cxx_dpp_lkg_dpp_ftc' */
	/* ASAP2::Database : delete 'Cxx_dpp_lkg_fac_tol_thd' */
	/* ASAP2::Database : delete 'Cxx_dpp_lkg_neg_thd' */
	/* ASAP2::Database : delete 'Cxx_dpp_lkg_pos_thd' */
	/* ASAP2::Database : delete 'Cxx_dpp_lkg_sys_egaf_ftc' */
	/* ASAP2::Database : 6 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_dfinc_pft_dp_dirt_lkg
	/end DEF_CHARACTERISTIC
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Dprscsx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_dp_dft_val
			Cxx_pft_egaf_clc_t_fil
			Cxx_pft_amp_dft_val
			Cbx_pft_up_prs_sens_cfm
			Cbx_pft_dp_sens_prs_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_dp_vld
			Vxx_pft_dp_load_fil
			Vxx_pft_dp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Exprsmd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_fac_up_prs_0
			Cxx_pft_fac_up_prs_1
			Cxx_pft_fac_up_prs_2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_mdl_pft_down_prs_vld
			Vxx_mdl_pft_rel_down_prs
			Vxx_mdl_pft_abv_down_prs
			Vxx_pft_down_prs_esti
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Msdpxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ms_dp_amp
			Ctb_ms_dp_dp
			Ctb_ms_dp_egaf
			Cmp_dp_egaf_ms_dp
			Ctp_pft_amp_egaf_cor
			Cbx_pft_ms_sim_ms_dp_cfm
			Cxx_pft_ms_dp_dft
			Cxx_pft_ms_dp_prs_t_fil
			Cxx_pft_ms_dp_t_fil
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_pft_ms_dp_dp_fil
			Vxx_pft_ms_dp_egaf_cor
			Vxx_pft_ms_dp_ini
			Vxx_pft_ms_dp_raw
			Vsx_pft_ms_dp_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_O2facxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_o2_esti_fuel_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_o2_fac_sot_esti_vld
			Vxx_pft_o2_fac_sot_esti
			Vxx_pft_rich_esti
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Pftdist
		""
	/begin OUT_MEASUREMENT
			Vxx_pft_vh_dist
			Vxx_pft_vh_dist_l_res
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Pftdpsr
		""
	/* ASAP2::Database : delete 'Cxx_dfdec_sens_pft_dp_h' */
	/* ASAP2::Database : delete 'Cxx_dfdec_sens_pft_dp_l' */
	/* ASAP2::Database : delete 'Cxx_dfdec_sens_pft_dp_oor' */
	/* ASAP2::Database : delete 'Cxx_dfinc_sens_pft_dp_h' */
	/* ASAP2::Database : delete 'Cxx_dfinc_sens_pft_dp_l' */
	/* ASAP2::Database : delete 'Cxx_sens_pft_dp_oor_ff_min_thd' */
	/* ASAP2::Database : delete 'Cxx_sens_pft_dp_oor_max_thd' */
	/* ASAP2::Database : delete 'Cxx_sens_pft_dp_oor_n_min_thd' */
	/* ASAP2::Database : 8 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_dfinc_sens_pft_dp_oor
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vbx_df_ena_sens_pft_dp' */
	/* ASAP2::Database : delete 'Vbx_df_sens_pft_dp_oor' */
	/* ASAP2::Database : delete 'Vbx_diag_ena_sens_pft_dp_oor' */
	/* ASAP2::Database : 3 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_pft_dp_dirt_vld
			Vsx_sens_pft_dp_vld
			Vxx_sens_pft_dp
			Vsx_pft_dp_chr_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Pftefyx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_clc_mod_efy
			Ctb_vh_dist_efy_driv
			Cxx_oil_ash_prct
			Cxx_pft_pwpf_max
			Ctp_pft_efy_driv_dist_prct
			Cxx_pft_oil_efy_prct_max
			Cxx_pft_oil_efy_prct_min
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_efy_prct_vld
			Vxx_pft_dist_efy_prct
			Vxx_pft_efy_prct
			Vxx_pft_oil_ash_wht
			Vxx_pft_oil_efy_prct
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* ASAP2::Database : delete OUT_MEASUREMENT, since it is empty */
/begin FUNCTION
		InAtiPfi_Ppsdgxx
		""
	/* ASAP2::Database : delete 'Cxx_dfdec_pft_dp_chr' */
	/* ASAP2::Database : delete 'Cxx_pft_diag_dp_tol_max' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_dfinc_pft_dp_chr
	/end DEF_CHARACTERISTIC
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Rupxxsr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_sens_rup_acc
			Ctp_sens_rup_acc
			Cbx_rupc_pres_cfm
			Cxx_dfdec_rup_dirt_lkg
			Cxx_dfdec_rup_nok
			Cxx_dfdec_sens_rup_h
			Cxx_dfdec_sens_rup_l
			Cxx_dfinc_rup_dirt_lkg
			Cxx_dfinc_rup_nok
			Cxx_dfinc_sens_rup_h
			Cxx_dfinc_sens_rup_l
			Cxx_rup_lkg_fac_tol_thd
			Cxx_rup_lkg_neg_thd
			Cxx_rup_lkg_pos_thd
			Cxx_rup_lkg_rup_ftc
			Cxx_rup_lkg_sys_egaf_ftc
			Cxx_rupc_amp_max
			Cxx_rupc_amp_min
			Cxx_rupc_dif_max
			Cxx_rupc_dif_min
			Cxx_rupc_dly_avg
			Cxx_rupc_dly_eng_stal
			Cxx_rupc_ftc_rup
			Cxx_rupc_plau_diag
			Cxx_rupc_tco_max
			Cxx_rupc_tco_min
			Cxx_rupc_tia_max
			Cxx_rupc_tia_min
			Cxx_sens_rup_fail_val
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vxx_rup_dif_mem' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_df_ena_rup
			Vbx_df_ena_rup_dirt_lkg
			Vbx_df_ena_rup_h
			Vbx_df_ena_rup_l
			Vbx_df_ena_rup_nok
			Vbx_df_rup_dirt_lkg
			Vbx_df_rup_nok
			Vbx_diag_ena_rup_dirt_lkg
			Vbx_diag_ena_rup_nok
			Vbx_rup_lkg_rup_neg
			Vbx_rup_lkg_rup_pos
			Vbx_rup_lkg_sys_egaf_neg
			Vbx_rup_lkg_sys_egaf_pos
			Vbx_rupc_ad_ena
			Vbx_rupc_ad_end
			Vbx_rupc_cdn_ok
			Vbx_rupc_sens_ena
			Vxx_raw_sens_pft_rel_up_prs_cor
			Vxx_rup_dif
			Vxx_rup_dif_raw
			Vxx_rup_lkg_pft_sys_egaf_fil
			Vxx_rup_lkg_raw_sens_rup_fil
			Vxx_rupc_hpf_rup
			Vsx_sens_pft_rel_up_prs_vld
			Vxx_sens_pft_rel_up_prs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Tiamvxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_tia_cor_swi
			Cxx_pft_eng_drvn_t_tia_cor_cnd
			Cxx_pft_tair_cor_mv_max
			Cxx_pft_tia_cor_vs_thd
			Cxx_pft_tia_cor_vs_thd_t
			Cbx_pft_tia_mv_tenv_cfm
			Cxx_pft_tair_cor_mv_min
			Cxx_pft_tia_mv_tia_dft
			Cxx_pft_tia_cor_mem
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_tia_mv_vld
			Vxx_pft_tia_mv
			Vxx_pft_tia_cor_mv_str
			Vxx_pft_tia_cor_sta
			Vxx_pft_tia_cor_mv_clc
			Vxx_pft_vh_dist_m_acry_sta
			Vxx_pft_vh_dist_rgn_tia_mv
			Vbx_pft_tia_cor_str_cnd
			Vbx_pft_tia_cor_sta_ok
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Uprsabv
		""
	/begin DEF_CHARACTERISTIC
			Cxx_sens_pft_abv_up_prs
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_sens_pft_abv_up_prs_vld
			Vxx_sens_pft_abv_up_prs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin FUNCTION
		InAtiPfi_Uprscsx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_sens_prs_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_up_prs_vld
			Vxx_pft_up_prs
			Vxx_pft_up_prs_fil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin FUNCTION
		InAtiTbo
		""
	/* ASAP2::Database : delete 'InAtiTbo_Td2diag' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			InAtiTbo_Tdoc1cs
			InAtiTbo_Tdoc2cs
			InAtiTbo_Td1diag
			InAtiTbo_Tefiarx
			InAtiTbo_Ttcfmxx
			InAtiTbo_Tdoc1md
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin FUNCTION
		InAtiTbo_Td1diag
		""
	/begin DEF_CHARACTERISTIC
			Cbx_doc1_utp_pull_up
			Cxx_dfdec_doc1_utp_chr
			Cxx_dfdec_doc1_utp_h
			Cxx_dfdec_doc1_utp_l
			Cxx_dfinc_doc1_utp_chr
			Cxx_dfinc_doc1_utp_h
			Cxx_doc1_utp_diag_dev_min
			Cxx_doc1_utp_diag_h
			Cxx_doc1_utp_diag_n_min
			Cxx_doc1_utp_diag_n_min_pup
			Cxx_doc1_utp_diag_no_dev_cdn
			Cxx_doc1_utp_diag_tco_min
			Cxx_doc1_utp_diag_tco_min_pup
			Cxx_doc1_utp_diag_temp_min
			Cxx_doc1_utp_diag_tqi_min
			Cxx_doc1_utp_diag_tqi_min_pup
			Cxx_dfinc_doc1_utp_pup_l
			Cxx_dfinc_doc1_utp_wio_pup_l
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_doc1_utp_diag_swi_pup_stt
			Vbx_df_doc1_utp_chr
			Vbx_df_doc1_utp_h
			Vbx_df_doc1_utp_l
			Vbx_doc1_utp_dev_cdn
			Vbx_doc1_utp_diag_cdn
			Vxx_dfinc_doc1_utp_l
			Vsx_sens_doc1_utp_vld
			Vxx_sens_doc1_utp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin FUNCTION
		InAtiTbo_Tdoc1cs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_sens_doc1_utp_dft
			Cxx_doc1_utp_ftc
			Cbx_tbo1_sens_pres_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_doc1_utp_vld
			Vxx_doc1_utp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin FUNCTION
		InAtiTbo_Tdoc1md
		""
	/begin DEF_CHARACTERISTIC
			Ctb_doc1_cal_cpy_tbn
			Ctb_doc1_cal_cpy_gaz
			Ctb_doc1_dyn_visc_gaz
			Ctb_doc1_ext_cnvt_cur
			Ctb_doc1_itl_cnvt_cur
			Ctb_doc1_tbn_vol_th_loss
			Ctb_doc1_th_trsm_gaz
			Ctp_doc1_cal_cpy_gaz_doc
			Ctp_doc1_cal_cpy_gaz
			Ctp_doc1_cal_cpy_tbn
			Ctp_doc1_dyn_visc_gaz
			Ctp_doc1_ext_cnvt_cur
			Ctp_doc1_itl_cnvt_cur
			Ctp_doc1_tbn_vol_th_loss
			Ctp_doc1_th_trsm_gaz
			Cxx_doc1_amp_lh_val
			Cxx_doc1_cor_fac_temp_bfr_tbn
			Cxx_doc1_cor_th_loss
			Cxx_doc1_cor_wht_gaz
			Cxx_doc1_th_loss_rd
			Cxx_doc1_wht_tbn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_doc1_mdl_utp_vld
			Vxx_doc1_mdl_utp
			Vxx_amp_conv
			Vxx_doc1_dif_prs_cpr
			Vxx_doc1_egy_gaz
			Vxx_doc1_cor_egy_drv_in_temp
			Vxx_doc1_egy_loss_tbn
			Vxx_doc1_esti_meca_pow_cpr
			Vxx_doc1_esti_meca_pow_vnt
			Vxx_doc1_fac_ext_cnvt
			Vxx_doc1_fac_itl_cnvt
			Vxx_doc1_gaz_temp_bfr_doc1_conv
			Vxx_doc1_gaz_temp_mem
			Vxx_doc1_in_th_egy_ex_gaz
			Vxx_doc1_in_th_egy_ext_cnvt
			Vxx_doc1_in_th_egy_itl_cnvt
			Vxx_doc1_inv_vnt_psn_th_loss
			Vxx_doc1_itl_cnvt_cur
			Vxx_doc1_nr_itl_cnvt
			Vxx_doc1_out_th_egy_ex_gaz
			Vxx_doc1_out_th_egy_ext_cnvt
			Vxx_doc1_out_th_egy_itl_cnvt
			Vxx_doc1_out_th_egy_rd_tbn
			Vxx_doc1_temp_esti
			Vxx_doc1_temp_esti_dly
			Vxx_doc1_th_egy_bfr_doc1
			Vxx_doc1_th_egy_gaz
			Vxx_doc1_th_egy_itl_cnvt
			Vxx_doc1_th_egy_tbn
			Vxx_doc1_vol_air_flow
			Vxx_tbt_conv
			Vxx_tia_conv
			Vxx_vnt_pwm_conv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InAtiTbo_Tdoc2cs
		""
	/begin OUT_MEASUREMENT
			Vsx_doc2_utp_vld
			Vxx_doc2_utp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin FUNCTION
		InAtiTbo_Tefiarx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_doc2_pres_cfm
			Ctb_vs_efi_ext_sph
			Ctp_vs_efi_ext_sph
			Cxx_efi_ar_temp_t_fil
			Cxx_efi_ext_ar
			Cxx_efi_itl_ar_temp_ini
			Cxx_tia_efi_ar_temp_dft
			Cxx_efi_rad_temp
			Cxx_efi_int_ar
			Cxx_efi_wht
			Ctp_pft_efi_itl_cp
			Ctb_pft_efi_itl_cp
			Ctb_pft_egaf_tt_efi_int
			Ctb_pft_tt_efi_int
			Ctb_pft_tt_efi_int_sph
			Ctp_pft_egaf_tt_efi_int
			Ctp_pft_tt_efi_int
			Ctp_pft_tt_efi_int_sph
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_efi_itl_ar_temp_vld
			Vxx_efi_ext_sph
			Vxx_efi_int_sph
			Vxx_efi_itl_ar_temp
			Vxx_efi_itl_ar_temp_fil
			Vxx_efi_itl_cp
			Vxx_pft_egaf_tt_efi_int
			Vxx_tt_k
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin FUNCTION
		InAtiTbo_Ttcfmxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tt_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_tt_vld
			Vxx_tt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/begin FUNCTION
		InAtiTdf
		""
	/begin SUB_FUNCTION
			InAtiTdf_Dtempcs
			InAtiTdf_Dtpdiag
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/begin FUNCTION
		InAtiTdf_Dtempcs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_dtp_sens_dft_val
			Cxx_pft_fil_t
			Cxx_pft_temp_ini
			Cbx_pft_dtp_pres_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_dtp_vld
			Vxx_pft_dtp
			Vxx_pft_dtp_fil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InAtiTdf_Dtpdiag
		""
	/* ASAP2::Database : delete 'Vbx_df_pft_dtp_chr' */
	/* ASAP2::Database : delete 'Vbx_df_pft_dtp_h' */
	/* ASAP2::Database : delete 'Vbx_df_pft_dtp_l' */
	/* ASAP2::Database : delete 'Vbx_pft_dtp_dev_cdn' */
	/* ASAP2::Database : delete 'Vbx_pft_dtp_diag_cdn' */
	/* ASAP2::Database : delete 'Vbx_pft_dtp_diag_swi_pup_stt' */
	/* ASAP2::Database : 6 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_sens_pft_dtp_vld
			Vxx_sens_pft_dtp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/begin FUNCTION
		InAtiTuf
		""
	/begin SUB_FUNCTION
			InAtiTuf_Utempcs
			InAtiTuf_Utpdiag
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/begin FUNCTION
		InAtiTuf_Utempcs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_egaf_clc_t_utp_fil
			Cxx_pft_utp_dft
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_utp_vld
			Vxx_pft_utp
			Vxx_pft_utp_fil
			Vxx_pft_utp_load_fil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/begin FUNCTION
		InAtiTuf_Utpdiag
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_utp_pull_up
			Cxx_dfdec_pft_utp_chr
			Cxx_dfinc_pft_utp_chr
			Cxx_pft_utp_diag_dev_min
			Cxx_pft_utp_diag_n_min
			Cxx_pft_utp_diag_n_min_pup
			Cxx_pft_utp_diag_no_dev_cdn
			Cxx_pft_utp_diag_tco_min
			Cxx_pft_utp_diag_tco_min_pup
			Cxx_pft_utp_diag_temp_min
			Cxx_pft_utp_diag_tqi_min
			Cxx_pft_utp_diag_tqi_min_pup
			Cxx_dfdec_pft_utp_h
			Cxx_dfdec_pft_utp_l
			Cxx_dfinc_pft_utp_h
			Cxx_pft_utp_diag_h
			Cxx_dfinc_pft_utp_pup_l
			Cxx_dfinc_pft_utp_wio_pup_l
			Cxx_dfinc_pft_utp_fast_dev_l
			Cxx_pft_utp_diag_fast_dev
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_pft_utp_chr
			Vbx_pft_utp_dev_cdn
			Vbx_pft_utp_diag_cdn
			Vbx_pft_utp_diag_swi_pup_stt
			Vsx_sens_pft_utp_vld
			Vxx_sens_pft_utp
			Vbx_df_pft_utp_l
			Vbx_df_pft_utp_h
			Vxx_dfinc_pft_utp_l
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/begin FUNCTION
		InCbiTbt
		""
	/begin SUB_FUNCTION
			InCbiTbt_Tbtdiag
			InCbiTbt_Tbtcsxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/begin FUNCTION
		InCbiTbt_Tbtcsxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_sens_tbt
			Cxx_tbt_ftc
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tbt
			Vsx_tbt_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/begin FUNCTION
		InCbiTbt_Tbtdiag
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_tbt_chr
			Cxx_dfdec_tbt_h
			Cxx_dfdec_tbt_l
			Cxx_dfinc_tbt_chr
			Cxx_dfinc_tbt_h
			Cxx_tbt_diag_dev_min
			Cxx_tbt_diag_h
			Cxx_tbt_diag_n_min
			Cxx_tbt_diag_n_min_pup
			Cxx_tbt_diag_no_dev_cdn
			Cxx_tbt_diag_tco_min
			Cxx_tbt_diag_tco_min_pup
			Cxx_tbt_diag_temp_min
			Cxx_tbt_diag_tqi_min
			Cxx_tbt_diag_tqi_min_pup
			Cbx_tbt_pull_up
			Cxx_dfinc_tbt_pup_l
			Cxx_dfinc_tbt_wio_pup_l
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_tbt_chr
			Vbx_df_tbt_h
			Vbx_df_tbt_l
			Vbx_tbt_dev_cdn
			Vbx_tbt_diag_cdn
			Vbx_tbt_diag_swi_pup_stt
			Vsx_sens_tbt_vld
			Vxx_sens_tbt
			Vxx_dfinc_tbt_l
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/begin FUNCTION
		InCbiUeg
		""
	/begin SUB_FUNCTION
			InCbiUeg_Upsdgxx
			InCbiUeg_Upscsxx
			InCbiUeg_Upssrxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/begin FUNCTION
		InCbiUeg_Upscsxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ups_sens_pres_cfm
			Ctb_maf_dyn_hpf_fac
			Cxx_ups_rich_fail_val
			Ctp_hpf_fac_rich_clc
			Cxx_hpf_fac_ups_rich
			Cxx_hpf_fac_ups_lamb
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_ups_rich_clc_vld
			Vsx_ups_rich_vld
			Vxx_ups_rich
			Vxx_ups_rich_clc
			Vxx_raw_ups_rich
			Vxx_raw_ups_rich_clc
			Vxx_rfar_rich_calc
			Vbx_ups_rich_clc_stt
			Vbx_ups_rich_stt
			Vxx_ups_lamb
			Vxx_ups_lamb_clc
			Vxx_raw_ups_lamb
			Vxx_raw_ups_lamb_clc
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/begin FUNCTION
		InCbiUeg_Upsdgxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_ups_ro2_oor
			Cxx_dfdec_ups_ro2_slow_trs
			Cxx_dfdec_ups_uo2_oor
			Cxx_dfinc_ups_ro2_oor
			Cxx_dfinc_ups_ro2_slow_trs
			Cxx_dfinc_ups_uo2_oor
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_ups_uo2_ro2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/begin FUNCTION
		InCbiUeg_Upssrxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_sens_ups_lamb_oc
			Cxx_dfdec_sens_ups_pump_oc
			Cxx_dfdec_sens_ups_virt_oc
			Cxx_dfdec_sens_ups_wire_scg
			Cxx_dfdec_sens_ups_wire_scw
			Cxx_dfdec_ups_ecu_chr
			Cxx_dfdec_ups_ecu_itl
			Cxx_dfdec_ups_ecu_oor
			Cxx_dfinc_sens_ups_lamb_oc
			Cxx_dfinc_sens_ups_pump_oc
			Cxx_dfinc_sens_ups_virt_oc
			Cxx_dfinc_sens_ups_wire_scg
			Cxx_dfinc_sens_ups_wire_scw
			Cxx_dfinc_ups_ecu_chr
			Cxx_dfinc_ups_ecu_itl
			Cxx_dfinc_ups_ecu_oor
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_sens_ups
			Vbx_df_sens_ups_lamb
			Vbx_df_sens_ups_pump
			Vbx_df_sens_ups_virt
			Vbx_df_sens_ups_wire
			Vbx_df_ups_ecu
			Vbx_sens_ups_rich_valid
			Vsx_sens_ups_rich_vld
			Vxx_sens_ups_lamb
			Vxx_sens_ups_rich
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/begin FUNCTION
		InCliCoi
		""
	/begin SUB_FUNCTION
			InCliCoi_Tcoxxcs
			InCliCoi_Tcoxxsr
			InCliCoi_Tcoxxmd
			InCliCoi_Tcomcsr
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/begin FUNCTION
		InCliCoi_Tcomcsr
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfinc_sens_tco_sig_mcut
			Cxx_dfdec_sens_tco_sig_mcut
			Cxx_tco_sig_mcut_max_slop
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_sens_tco_sig_mcut
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/begin FUNCTION
		InCliCoi_Tcoxxcs
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tco
			Cxx_tco_inc
			Ctb_sta_tco
			Ctb_tco2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tco
			Vsx_tco_vld
			Vsx_sta_tco_vld
			Vxx_sta_tco
			Vxb_tco.factor
			Vxb_tco.index
			Vxb_tco.num_dp
			Vxb_tco2.factor
			Vxb_tco2.index
			Vxb_tco2.num_dp
			Vxb_sta_tco.factor
			Vxb_sta_tco.index
			Vxb_sta_tco.num_dp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/begin FUNCTION
		InCliCoi_Tcoxxmd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_mdl_tco_inc
			Cxx_mdl_tco_max
			Cxx_tdc_mdl_fail_tdc_cnt
			Cxx_tdc_mdl_tdc_cnt
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_mdl_tco
			Vbx_tco_mdl_cnt
			Vsx_mdl_tco
			Vsx_mdl_tco_vld
			Vsx_mdl_tco_vld_2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/begin FUNCTION
		InCliCoi_Tcoxxsr
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_sens_tco
			Cxx_dfinc_sens_tco
			Cxx_raw_sens_tco_ini
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_sens_tco_vld
			Vxx_sens_tco
			Vbx_df_sens_tco
			Vxx_sens_tco_frz
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui
		""
	/begin OUT_MEASUREMENT
			InCliLui_NVM.Vxx_pft_oil_csm_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'InCliLui_Toilxsr' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			InCliLui_Toilxcs
			InCliLui_Toilxmd
			InCliLui_Toilubc
			InCliLui_Oilcsmx
			InCliLui_Owpdlrx
			InCliLui_Owrstcs
			InCliLui_Schxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui_Oilcsmx
		""
	/begin DEF_CHARACTERISTIC
			Cmp_pft_oil_csm
			Ctb_pft_n_oil_csm
			Ctb_pft_tqi_oil_csm
			Ctb_pft_vh_dist_oil_csm
			Ctp_pft_oil_csm_cor
			Cxx_oil_csm_vh_dist
			Cxx_pft_oil_csm_max
			Cxx_pft_oil_csm_min
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_oil_csm_vld
			Vxx_pft_n_tqi_oil_csm
			Vxx_pft_vh_dist_oil_csm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui_Owpdlrx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_owe_ctr4
			Cxx_owe_ctr5
			Cxx_owe_n
			Cxx_owe_pdl_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_brk
			Vbx_owe_igk_on_igk_off
			Sxx_owe_st3
			Sxx_owe_st4
			Vxx_owe_ctr5
			Vxx_owe_ctr4
			Vbx_owe_mnl_ini_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui_Owrstcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_owe_mnl_ini_req_ena
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_owe_mnl_ini_req_ok
			Vbx_owe_ini_req_ok
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui_Schxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_owe_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_owe_cfm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui_Toilubc
		""
	/begin OUT_MEASUREMENT
			Vsx_sens_toil_vld
			Vxx_sens_toil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui_Toilxcs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_mdl_toil_fail
			Ctb_toil
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_toil_vld
			Vxx_toil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin FUNCTION
		InCliLui_Toilxmd
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tco_dif
			Cxx_stop_toil_fil
			Cxx_toil_tco_cnt
			Cxx_tqi_rat_cut_thd
			Ctp_toil_fil
			Ctb_tqi_rat
			Cmp_n_toil
			Cxx_tco_toil_thd
			Cxx_toil_pws_max_dly
			Ctb_n4
			Ctp_tco_toil_ofs
			Cxx_tco_toil_fil
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_toil_pws
			Vsx_mdl_toil_vld
			Vxx_mdl_toil
			Vxx_stab_toil
			Vxx_tco_dif
			Vxx_tco_fil
			Vxx_toil_pws_max_dly
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciacc.xml' */
/begin FUNCTION
		InPciAcc
		""
	/begin SUB_FUNCTION
			InPciAcc_Noaccxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciacc.xml' */
/begin FUNCTION
		InPciAcc_Noaccxx
		""
	/begin OUT_MEASUREMENT
			Vsx_acc_sdl_ctl_typ
			Vxx_acc_forc_sp
			Vxx_sdl_forc_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin FUNCTION
		InPciAgb
		""
	/* ASAP2::Database : delete 'InPciAgb_Attqxco' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			InPciAgb_Atsipxx
			InPciAgb_Attqxcs
			InPciAgb_Sdftaxx
			InPciAgb_Spcxxcs
			InPciAgb_Antxxcs
			InPciAgb_Tbspdcs
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin FUNCTION
		InPciAgb_Antxxcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ant_crt_slc_pres_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_ant_crt_slc
			Vsx_ant_crt_slc_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin FUNCTION
		InPciAgb_Atsipxx
		""
	/begin OUT_MEASUREMENT
			Vbx_agb_tq_req_full_ctl
			Vbx_agb_tq_req_h_lim
			Vbx_agb_tq_req_l_lim
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin FUNCTION
		InPciAgb_Attqxcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_agb_csm_tq_temp_cfm
			Ctb_agb_csm_tq_is_n_sp_dif
			Cxx_agb_csm_tq_vs_thd
			Cbx_agb_csm_ofs_cfm
			Cbx_agb_csm_slop_cfm
			Cxx_agb_csm_ofs_slop_neg
			Cxx_agb_csm_ofs_slop_neg_dft
			Cxx_agb_csm_ofs_slop_pos
			Cxx_agb_csm_ofs_slop_pos_dft
			Cxx_agb_csm_tq_ftc_fast
			Cxx_agb_csm_tq_ftc_slow
			Cxx_agb_csm_tq_is_n_hys
			Cxx_agb_csm_tq_is_n_thd
			Cxx_agb_csm_tq_slop_neg
			Cxx_agb_csm_tq_slop_neg_1
			Cxx_agb_csm_tq_slop_neg_1_rvr
			Cxx_agb_csm_tq_slop_neg_2
			Cxx_agb_csm_tq_slop_neg_rvr
			Cxx_agb_csm_tq_slop_pos
			Cxx_agb_csm_tq_slop_pos_1
			Cxx_agb_csm_tq_slop_pos_1_rvr
			Cxx_agb_csm_tq_slop_pos_2
			Cxx_agb_csm_tq_slop_pos_rvr
			Cxx_agb_tq_slop_drag_red_neg
			Cxx_agb_tq_slop_drag_red_pos
			Ctp_agb_csm_tq_drag_red_ofs
			Ctp_agb_csm_tq_dri_ofs
			Ctp_agb_csm_tq_dri_ofs_dft
			Ctp_agb_csm_tq_neut_ofs
			Ctp_agb_csm_tq_neut_ofs_dft
			Ctp_egb_dri_drag_red_dly_temp
			Ctp_egb_dri_neut_dly_temp
			Ctb_agb_tq_dif_n_is_n_sp
			Ctb_agb_tq_vs
			Ctp_agb_csm_tq_n_fac
			Ctp_agb_csm_tq_vs_fac
			Cxx_agb_tq_slop_dsb_neg
			Cxx_agb_tq_slop_dsb_pos
			Ctp_agb_csm_tq_is_n_sp_fac
			Cxx_agb_csm_tq_ftc_vs_thd
			Ctp_agb_csm_tq_ftc_temp_fast
			Ctp_agb_csm_tq_ftc_temp_slow
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_agb_csm_tq
			Vbx_stat_drag_red_agb
			Vbx_stat_egb_neut
			Vsx_agb_csm_tq_vld
			Vxx_agb_csm_tq_dft
			Vxx_agb_csm_tq_fil
			Vxx_agb_csm_tq_is_n_fac
			Vxx_agb_csm_tq_ofs
			Vxx_agb_csm_tq_slop
			Vxx_is_n_sp_dif
			Vxx_agb_tq_dif_n_is_n_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin FUNCTION
		InPciAgb_Sdftaxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_max_gear_cge_dly_ena_cfm
			Cbx_tq_cmd_typ_cfm
			Cxx_agb_ctr_max_thd
			Cxx_agb_int_rst_t
			Cxx_agb_max_tqe
			Cxx_agb_slwr_neg
			Cxx_agb_slwr_pos
			Cxx_agb_abst_dly
			Cxx_dfdec_agb_data
			Cxx_dfdec_agb_no_frm
			Cxx_dfinc_agb_data
			Cxx_dfinc_agb_no_frm
			Cxx_dft_agb_tq_sp_lim
			Cxx_i_agb_driv_tq_thd
			Cxx_max_gear_cge_dly
			Cxx_mux_agb_tqe_nok_raw
			Cxx_agb_clck_max_step
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_agb_ack
			Vbx_agb_gear_mod_ok
			Vxx_agb_lim_tqe
			Vxx_agb_max_tqe_sp
			Vxx_agb_max_tqe_tgt
			Vxx_agb_min_tqe_tgt
			Vbx_agb_clck_fail
			Vbx_agb_cmd
			Vbx_agb_dft
			Vbx_agb_tq_int_rst
			Vbx_agb_tq_lim_dft
			Vbx_agb_tq_req
			Vbx_agb_tq_req_full_ctl_vld
			Vbx_agb_tq_req_l_lim_vld
			Vbx_agb_tq_req_h_lim_vld
			Vbx_egb_conf_ena
			Vbx_i_dsb
			Vxx_agb_int_t
			Vxx_agb_min_tqe_sp
			Vbx_df_agb_data_chr
			Vbx_df_agb_data_seq_ctr
			Vbx_df_agb_data_tout
			Vbx_df_agb_no_frm
			Vxx_agb_10ms_t
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin FUNCTION
		InPciAgb_Spcxxcs
		""
	/begin OUT_MEASUREMENT
			Vxx_agb_driv_spt_fac
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin FUNCTION
		InPciAgb_Tbspdcs
		""
	/begin OUT_MEASUREMENT
			Vsx_prim_sha_spd_vld
			Vxx_prim_sha_spd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin FUNCTION
		InPciApi
		""
	/begin SUB_FUNCTION
			InPciApi_Pedxxsr
			InPciApi_Pedinxx
			InPciApi_Sftpdxx
			InPciApi_Pedxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin FUNCTION
		InPciApi_Pedinxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_acel_pdl_kd_in_thd_nok
			Cxx_acel_pdl_kd_in_thd_ok
			Cxx_acel_pdl_0_rat_v_nok
			Cxx_acel_pdl_0_rat_v_ok
			Cxx_acel_pdl_100_rat_v_nok
			Cxx_acel_pdl_100_rat_v_hys
			Cxx_acel_pdl_100_rat_v_max_nok
			Cxx_acel_pdl_100_rat_v_max_ok
			Cxx_acel_pdl_100_rat_v_ok
			Cxx_acel_pdl_kd_hys
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_acel_pdl_kd_in_thd
			Vxx_acel_pdl_0_rat_v
			Vxx_acel_pdl_rat
			Vsx_acel_pdl_rat_vld
			Vbx_acel_pdl_kd
			Vbx_acel_pdl_100_rat
			Vxx_acel_pdl_100_rat_v
			Vxx_acel_pdl_100_rat_v_max
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin FUNCTION
		InPciApi_Pedxxsr
		""
	/begin DEF_CHARACTERISTIC
			Cxx_acel_pdl_sens_pws
			Cxx_acel_pdl_stab_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_acel_pdl_fil_sens_v2
			Vbx_acel_pdl_fil_sens_v1
			Vbx_acel_pdl_fil_sens_v2
			Vxx_acel_pdl_fil_sens_v1
			Vxx_acel_pdl_sens_rat1
			Vxx_acel_pdl_sens_rat2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin FUNCTION
		InPciApi_Pedxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_acel_pdl_v1_max_thd
			Cxx_acel_pdl_v2_max_thd
			Cxx_acel_pdl_v1_min_thd
			Cxx_acel_pdl_v2_min_thd
			Cxx_dfdec_acel_pdl_v2
			Cxx_dfdec_acel_pdl_chr
			Cxx_dfinc_acel_pdl_chr
			Cxx_dfdec_acel_pdl_tot
			Cxx_dfinc_acel_pdl_tot
			Cxx_dfdec_acel_pdl_v1
			Cxx_dfinc_acel_pdl_v1
			Cxx_dfinc_acel_pdl_v2
			Ctb_acel_pdl_v_max_dif
			Ctp_acel_pdl_v_max_dif
			Cxx_acel_pdl_lih_sub_v
			Cxx_acel_pdl_v1_v2_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_acel_pdl_sens_v
			Vxx_acel_pdl_v
			Vbx_df_acel_pdl_chr
			Vbx_df_acel_pdl_v2_h
			Vbx_df_acel_pdl_v1_l
			Vbx_df_acel_pdl_v2_l
			Vbx_df_acel_pdl_v1_h
			Vbx_df_acel_pdl_tot
			Vbx_det_acel_pdl_rdcy_loss
			Vbx_diag_ena_acel_pdl_chr
			Vbx_loss_acel_pdl_v1
			Vsx_acel_pdl_v_vld
			Vsx_acel_pdl_sens_v1_vld
			Vbx_acel_pdl_sens1_ok
			Vbx_fail_pws_acel_pdl_v1
			Vbx_fail_pws_acel_pdl_v2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin FUNCTION
		InPciApi_Sftpdxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_acel_pdl_secu_dly1
			Cxx_acel_pdl_secu_dly2
			Cxx_acel_pdl_secu_n_thd
			Cxx_acel_pdl_secu_flu_thd
			Cxx_acel_pdl_secu_thd
			Cxx_acel_pdl_secu_vs_thd
			Cxx_dfdec_acel_pdl_secu_2
			Cbx_acel_pdl_secu_2_cfm
			Cbx_acel_pdl_secu_acc_cfm
			Cbx_acel_pdl_secu_esp_cfm
			Cxx_acel_pdl_secu_2_inc_1
			Cxx_acel_pdl_secu_2_inc_2
			Cxx_acel_pdl_secu_2_thd
			Cxx_acel_pdl_secu_2_vs_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			InPciApi_NVM.Vxx_acel_pdl_secu_ctr_NVM
			Vbx_acel_pdl_secu_cdn_2
			Vbx_acel_pdl_secu_det
			Vbx_df_acel_pdl_secu_1
			Vbx_df_acel_pdl_secu_2
			Vbx_acel_pdl_secu_cdn_1
			Vbx_diag_ena_acel_pdl_secu_2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/begin FUNCTION
		InPciBki
		""
	/begin OUT_MEASUREMENT
			INPCIBKI_NVM.Vxx_brk_pdl_clos_blk_off_dly_NVM
			INPCIBKI_NVM.Vxx_brk_pdl_clos_blk_on_dly_NVM
			INPCIBKI_NVM.Vxx_brk_pdl_open_blk_off_dly_NVM
			INPCIBKI_NVM.Vxx_brk_pdl_open_blk_on_dly_NVM
			INPCIBKI_NVM.Vbx_sens_brk_pdl_open_lk_stt_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'InPciBki_Brkdg1x' */
	/* ASAP2::Database : delete 'InPciBki_Brkdg2x' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin SUB_FUNCTION
			InPciBki_Absxxcs
			InPciBki_Brk1xcs
			InPciBki_Cnbkccs
			InPciBki_Cnbkocs
			InPciBki_Bpkxxcs
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/begin FUNCTION
		InPciBki_Absxxcs
		""
	/begin OUT_MEASUREMENT
			Vbx_abs_reg
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/begin FUNCTION
		InPciBki_Bpkxxcs
		""
	/begin OUT_MEASUREMENT
			Vbx_bpk
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/begin FUNCTION
		InPciBki_Brk1xcs
		""
	/begin OUT_MEASUREMENT
			Vsx_brk_pdl
			Vsx_brk_pdl_vld
			Vsx_brk_pdl_cru_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/begin FUNCTION
		InPciBki_Cnbkccs
		""
	/* ASAP2::Database : delete 'Vsx_brk_pdl_clos_vld' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_brk_pdl_clos
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/begin FUNCTION
		InPciBki_Cnbkocs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_sens_brk_lk_vb_dly
			Cxx_sens_brk_lk_vb_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_brk_pdl_open
			Vsx_brk_pdl_open_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/begin FUNCTION
		InPciCci
		""
	/begin OUT_MEASUREMENT
			InPciCci_NVM.Vbx_whl_lk_stt_NVM
			InPciCci_NVM.Vxx_cru_sl_resu_blk_dly_max_NVM
			InPciCci_NVM.Vxx_cru_sl_acel_blk_dly_max_NVM
			InPciCci_NVM.Vxx_cru_sl_decl_blk_dly_max_NVM
			InPciCci_NVM.Vxx_cru_sl_susp_blk_dly_max_NVM
			InPciCci_NVM.Vxx_cru_sl_whl_cmd_blk_ctr_max_NVM
			InPciCci_NVM.Vbx_cru_swi_lk_stt_NVM
			InPciCci_NVM.Vbx_cru_lk_stt_NVM
			InPciCci_NVM.Vbx_sl_swi_lk_stt_NVM
			InPciCci_NVM.Vbx_sl_lk_stt_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			InPciCci_Swtchsr
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/begin FUNCTION
		InPciCci_Swtchsr
		""
	/begin DEF_CHARACTERISTIC
			Cbx_cru_sl_lk_rls_ena
			Cbx_cru_sl_swi_chr_prmt
			Cxx_cru_sl_acel_blk_dly
			Cxx_cru_sl_acel_max_thd
			Cxx_cru_sl_acel_min_thd
			Cxx_cru_sl_decl_blk_dly
			Cxx_cru_sl_decl_max_thd
			Cxx_cru_sl_decl_min_thd
			Cxx_cru_sl_lk_ena_dly
			Cxx_cru_sl_lk_vb_thd
			Cxx_cru_sl_open_min_thd
			Cxx_cru_sl_resu_blk_dly
			Cxx_cru_sl_resu_max_thd
			Cxx_cru_sl_resu_min_thd
			Cxx_cru_sl_rls_max_thd
			Cxx_cru_sl_rls_min_thd
			Cxx_cru_sl_susp_blk_dly
			Cxx_cru_sl_susp_max_thd
			Cxx_cru_sl_swi_dly
			Cxx_cru_sl_whl_swi_dly
			Cxx_dfdec_cru_whl_cmd
			Cxx_dfdec_cru_whl_cmd_nok
			Cxx_dfinc_cru_sl_swi_chr
			Cxx_dfinc_cru_whl_cmd_nok
			Cxx_dfdec_cru_sl_swi_chr
			Cxx_cru_sl_whl_cmd_blk_ctr_max
			Cxx_dfinc_cru_whl_cmd
			Cxx_cru_sl_swi_igk_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cru_sl_acel_blk
			Vbx_cru_sl_decl_blk
			Vbx_cru_sl_lk_ena
			Vbx_cru_sl_resu_blk
			Vbx_cru_sl_susp_blk
			Vbx_cru_sl_whl_cmd_blk
			Vbx_df_cru_sl_swi_chr
			Vbx_df_cru_whl_cmd_nok
			Vbx_df_cru_whl_cmd_oc_scw
			Vbx_df_cru_whl_cmd_oor
			Vsx_cru_sl_on_off
			Vsx_cru_sl_on_off_raw
			Vsx_cru_sl_swi_vld
			Vxx_cru_sl_whl_cmd_stt
			Vxx_sta_swi_act_ctr
			Vxx_cru_sl_whl_cmd_raw
			Vbx_cru_sl_new_lk_ena
			Vxx_acc_cmd_stt
			Vxx_acc_swi
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls
		""
	/begin OUT_MEASUREMENT
			InPciDls_NVM.Vbx_sens_bgin_clu_cnt_lk_stt_NVM
			InPciDls_NVM.Vxx_bgin_clu_off_no_chr_ctr_NVM
			InPciDls_NVM.Vxx_bgin_clu_on_no_chr_ctr_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			InPciDls_Clexxcs
			InPciDls_Cnrvncs
			InPciDls_Dlsttxx
			InPciDls_Ratioxx
			InPciDls_Rgearxx
			InPciDls_Seclcxx
			InPciDls_Tmdlsxx
			InPciDls_Attcscs
			InPciDls_Attrecs
			InPciDls_Tadlsxx
			InPciDls_Clb2xcs
			InPciDls_Clbmucs
			InPciDls_Clbsrcs
			InPciDls_Clbxxsr
			InPciDls_Clbdgxx
			InPciDls_Slicoxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Attcscs
		""
	/begin OUT_MEASUREMENT
			Vsx_agb_coup_vld
			Vsx_rgb_coup_vld
			Vsx_agb_coup
			Vsx_rgb_coup
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Attrecs
		""
	/begin OUT_MEASUREMENT
			Vsx_drag_red_agb_vld
			Vsx_egb_neut_vld
			Vsx_raw_egb_ant_gear
			Vsx_raw_egb_ant_gear_vld
			Vsx_raw_egb_gear
			Vsx_raw_egb_gear_vld
			Vbx_egb_neut
			Vsx_agb_vld
			Vbx_drag_red_agb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Clb2xcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_mux_clu_cnt_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_bgin_str_clu_cru
			Vsx_bgin_str_clu_cru_rams
			Vsx_bgin_str_clu_cru_vld
			Vsx_bgin_str_clu_cnt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Clbdgxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_bgin_clu_dg_act_vs_min
			Cxx_bgin_clu_off_no_chr_ctr
			Cxx_bgin_clu_on_no_chr_ctr
			Cxx_dfinc_bgin_clu_nok
			Cxx_dfdec_bgin_clu_nok
			Cbx_bgin_clu_on_dg_cfm
			Cbx_bgin_clu_off_dg_cfm
			Cxx_ant_gear_dif_thd
			Cxx_ant_gear_fil
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_bgin_clu_on_nok
			Vbx_df_bgin_clu_nok
			Vbx_bgin_clu_off_nok
			Vbx_ant_gear_shf
			Vbx_raw_bgin_clu_off_no_chr
			Vxx_ant_gear_2
			Vxx_ant_gear_mem
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Clbmucs
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_bgin_clu_cnt
			Vsx_mux_bgin_clu_cnt_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Clbsrcs
		""
	/begin OUT_MEASUREMENT
			Vsx_sens_bgin_clu_cnt_vld
			Vsx_sens_bgin_clu_cnt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Clbxxsr
		""
	/begin DEF_CHARACTERISTIC
			Cxx_sens_clu_lk_vb_dly
			Cxx_sens_clu_lk_vb_thd
	/end DEF_CHARACTERISTIC
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Clexxcs
		""
	/begin OUT_MEASUREMENT
			Vsx_end_str_clu_cnt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Cnrvncs
		""
	/begin OUT_MEASUREMENT
			Vsx_neut_cnt
			Vsx_rvr_cnt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Dlsttxx
		""
	/begin DEF_CHARACTERISTIC
			Ntb_gear
			Csx_dlin_conf
			Ctb_coup
			Ntb_coup
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_ant_coup_vld
			Vsx_ant_gear
			Vsx_ant_gear_vld
			Vsx_coup_vld
			Vsx_gear
			Vxx_ant_coup
			Vsx_dlin_conf
			Vsx_gear_vld
			Vxx_coup
			Vxx_gear
			Vxx_ant_gear
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Ratioxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_down_bkp_vs_neut
			Cxx_vs_n_rat_dft_max
			Cxx_vs_n_rat_dft_min
			Cxx_vs_n_rat_fil_fac1
			Cxx_vs_n_rat_fil_fac2
			Cxx_vs_n_rat_min_n_bkp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_run_vh_vld
			Vsx_vs_n_rat_fil_vld
			Vxx_vs_n_rat
			Vbx_run_vh
			Vxx_vs_n_rat_fil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Rgearxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_2_gear_rat_tgt
			Cxx_3_gear_rat_tgt
			Cxx_4_gear_rat_tgt
			Cxx_5_gear_rat_tgt
			Cxx_h_gear_win_thd
			Cxx_l_gear_max
			Cxx_l_gear_win_thd
			Cxx_max_vs_n_rat
			Cxx_min_vs_n_rat
			Cxx_neut_gear_rat_tgt
			Cxx_1_gear_rat_tgt
			Cbx_no_ant_gear_fil_cfm
			Cxx_6_gear_rat_tgt
			Cxx_vs_n_rat_ant_gear_ftc1
			Cxx_vs_n_rat_ant_gear_ftc2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_ant_rat_gear
			Vsx_rat_gear
			Vtx_gear_rat_tgt[0]
			Vtx_gear_rat_tgt[1]
			Vtx_gear_rat_tgt[2]
			Vtx_gear_rat_tgt[3]
			Vtx_gear_rat_tgt[4]
			Vtx_gear_rat_tgt[5]
			Vtx_gear_rat_tgt[6]
			Vxx_down_rat_gear_bkp_tgt
			Vxx_mv_1_2_gear_rat_tgt
			Vxx_mv_2_3_gear_rat_tgt
			Vxx_mv_3_4_gear_rat_tgt
			Vxx_mv_4_5_gear_rat_tgt
			Vxx_mv_5_6_gear_rat_tgt
			Vxx_rat_tgt
			Vxx_up_rat_gear_bkp_tgt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Seclcxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_clu_cnt_nok
			Cxx_dfinc_clu_cnt_nok
			Cxx_dly_chr_bgin_end_clu_cnt
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_bgin_clu_cnt_ena
			Vbx_bgin_clu_cnt_on
			Vbx_end_clu_cnt_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Slicoxx
		""
	/begin OUT_MEASUREMENT
			Vxx_prim_sha_n_rat
			Vbx_clc_sli_ena
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Tadlsxx
		""
	/begin DEF_CHARACTERISTIC
			Csx_lih_egb_gear
			Cxx_dly_coup_fail
			Cxx_dly_gear_fail
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_egb_ant_coup
			Vsx_egb_ant_coup_vld
			Vsx_egb_coup
			Vsx_egb_coup_vld
			Vsx_egb_ant_gear
			Vsx_egb_gear
			Vsx_egb_ant_gear_vld
			Vsx_egb_gear_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin FUNCTION
		InPciDls_Tmdlsxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ant_coup_clos_clc_cfm
			Cxx_dly_clu_pdl_use_rtn
			Cxx_dly_neut_gear_act
			Cxx_dly_neut_gear_cnt
			Cxx_dly_pdl_rls
			Cxx_rat_gear_stab_dly
			Cxx_vs_vh_max
			Cxx_vs_vh_min
			Cbx_bgin_clu_fail_cfm
			Cbx_ovn_n_clu_det_cfm
			Cxx_ovn_n_clu_det_dly
			Cxx_ovn_n_clu_det_thd
			Cxx_ovn_n_dif_clu_det_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_bgin_clu_pdl_on
			Vbx_gear_stab
			Vbx_neut_gear_act
			Vbx_pdl_use_rtn
			Vsx_bgin_clu_nok_mgb_ant_coup
			Vsx_bgin_clu_nok_mgb_coup
			Vsx_bgin_clu_nok_mgb_coup_vld
			Vsx_bgin_clu_ok_mgb_ant_coup
			Vsx_bgin_clu_ok_mgb_coup
			Vsx_bgin_clu_ok_mgb_coup_vld
			Vsx_mgb_ant_coup
			Vsx_mgb_ant_gear
			Vsx_mgb_coup
			Vsx_mgb_coup_vld
			Vsx_mgb_gear
			Vsx_mgb_gear_vld
			Vsx_rat_gear_stab
			Vbx_neut_psn
			Vbx_ovn_ant_coup
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/begin FUNCTION
		InPciEsp
		""
	/begin SUB_FUNCTION
			InPciEsp_Absctxx_xxxxxx
			InPciEsp_Espxxcs_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/begin FUNCTION
		InPciEsp_Absctxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_asr_slwr_neg
			Cxx_asr_slwr_pos
			Cxx_asr_tqe_sp_msr_raw
			Cxx_asr_msr_abst_dly
			Cxx_asr_msr_ctr_thd
			Cxx_asr_msr_max_tqe
			Cxx_asr_msr_raw_sum
			Cxx_min_tqe_dsb
			Cxx_mux_asr_msr_tqe_nok_raw
			Cxx_dfdec_esp_data_chr
			Cxx_dfdec_esp_data_seq_ctr
			Cxx_dfdec_esp_no_frm
			Cxx_dfinc_esp_data_chr
			Cxx_dfinc_esp_data_seq_ctr
			Cxx_dfinc_esp_no_frm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_asr_msr_ack
			Vxx_asr_tqe_tgt
			Vxx_msr_tqe_sp
			Vxx_asr_tqe_sp
			Vbx_asr_cdn
			Vbx_asr_msr_cdn
			Vbx_asr_msr_lk
			Vbx_asr_prot_dft
			Vbx_df_esp_data_chr
			Vbx_df_esp_data_seq_ctr
			Vbx_msr_cdn
			Vbx_df_esp_no_frm
			Vbx_asr_tqe_req_ok
			Vbx_msr_tqe_req_ok
			Vbx_asr_msr_frm_abst_tmp
			Vbx_tmp_df_esp_data_chr
			Vbx_tmp_df_esp_data_seq_ctr
			Vxx_asr_msr_20ms_t
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/begin FUNCTION
		InPciEsp_Espxxcs_xxxxxx
		""
	/begin OUT_MEASUREMENT
			Vbx_asr_reg
			Vbx_ayc_reg
			Vsx_asr_msr_typ
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr
		""
	/begin SUB_FUNCTION
			InSmiSsr_Accluxx
			InSmiSsr_Acclucs
			InSmiSsr_Agbspcs
			InSmiSsr_Agbxxcs
			InSmiSsr_Ptcxxcs
			InSmiSsr_Windxcs
			InSmiSsr_Acsiscs
			InSmiSsr_Acclumd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Acclucs
		""
	/begin OUT_MEASUREMENT
			Vxx_ac_acel_is_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Acclumd
		""
	/begin OUT_MEASUREMENT
			Vxx_tair_ext
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Accluxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ac_acel_is
			Ctp_ac_acel_is_swi_off
			Ctp_ac_acel_is_swi_on
			Ctp_ac_acel_is_val_on
			Ctp_ac_acel_is_val_off
			Cxx_ac_req_off_ac_acel_is_sp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_mdl_ac_acel_is_sp_vld
			Vxx_mdl_ac_acel_is_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Acsiscs
		""
	/begin OUT_MEASUREMENT
			Vbx_acs_acel_is_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Agbspcs
		""
	/begin OUT_MEASUREMENT
			Vsx_agb_is_acel_sp_vld
			Vxx_agb_is_acel_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Agbxxcs
		""
	/begin OUT_MEASUREMENT
			Vbx_agb_is_acel_req
			Vsx_agb_is_acel_req_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Ptcxxcs
		""
	/begin OUT_MEASUREMENT
			Vbx_ptc_is_acel_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin FUNCTION
		InSmiSsr_Windxcs
		""
	/begin OUT_MEASUREMENT
			Vbx_el_wind_is_acel
			Vbx_el_bk_wind
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn
		""
	/begin OUT_MEASUREMENT
			InSmiSyn_NVM.Vbx_clu_stal_ctr_NVM
			InSmiSyn_NVM.Vxx_clu_stal_ctr_NVM
			InSmiSyn_NVM.Vxx_cylr_is_vld_ctr_NVM
			InSmiSyn_NVM.Vxx_cylr_ok_aftr_stal_ctr_NVM
			InSmiSyn_NVM.Vxx_cylr_ok_ctr_NVM
			InSmiSyn_NVM.Vxx_err_cylr_ctr_NVM
			InSmiSyn_NVM.Vxx_err_cylr_is_run_ctr_NVM
			InSmiSyn_NVM.Vxx_err_id_is_run_ctr_NVM
			InSmiSyn_NVM.Vxx_is_cylr_ok_ctr_NVM
			InSmiSyn_NVM.Vxx_no_deci_cylr_ctr_NVM
			InSmiSyn_NVM.Vxx_no_deci_id_is_ctr_NVM
			InSmiSyn_NVM.Vxx_run_re_phs_ctr_NVM
			InSmiSyn_NVM.Vxx_crk_syn_loss_ctr_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'InSmiSyn_Tothpac' */
	/* ASAP2::Database : delete 'InSmiSyn_Recocxx' */
	/* ASAP2::Database : delete 'InSmiSyn_Spdmfxx' */
	/* ASAP2::Database : 3 referenced entries deleted */
	/begin SUB_FUNCTION
			InSmiSyn_Crksixx
			InSmiSyn_Derivxx
			InSmiSyn_Filspxx
			InSmiSyn_Speedxx
			InSmiSyn_Synchro
			InSmiSyn_Camsixx
			InSmiSyn_Schedul
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn_Camsixx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_in_cam_chr
			Cxx_dfdec_in_cam_crk_cmp
			Cxx_dfdec_in_cam_no_sig
			Cxx_dfinc_in_cam_chr
			Cxx_dfinc_in_cam_crk_cmp
			Cxx_dfinc_in_cam_no_sig
			Cxx_dfdec_in_cam_cyc
			Cxx_dfdec_in_cam_nok
			Cxx_dfinc_in_cam_cyc
			Cxx_dfinc_in_cam_nok
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pres_df_in_cam_chr
			Vbx_pres_df_in_cam_crk_cmp
			Vbx_pres_df_in_cam_cyc
			Vbx_pres_df_in_cam_no_sig
			Vbx_pres_df_in_cam_nok
			Vxx_in_cam_toth_per
			Vbx_in_cam_lvl
			Vsx_sens_in_cam_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn_Crksixx
		""
	/* ASAP2::Database : delete 'Cxx_h_dif_prs_dsb_sp' */
	/* ASAP2::Database : delete 'Cxx_h_thd_dif_prs_dsb_sp' */
	/* ASAP2::Database : delete 'Cxx_h_thd_prs_sp_fail' */
	/* ASAP2::Database : delete 'Cxx_l_thd_dif_prs_dsb_sp' */
	/* ASAP2::Database : delete 'Cxx_nr_vld_crk_fail1' */
	/* ASAP2::Database : 5 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_crk_chr
			Cxx_dfdec_crk_no_sig
			Cxx_dfinc_crk_chr
			Cxx_dfinc_crk_no_sig
			Cxx_dfdec_crk_cmp
			Cxx_dfdec_crk_cyc
			Cxx_dfdec_crk_oc
			Cxx_dfdec_crk_shp
			Cxx_dfinc_crk_cmp
			Cxx_dfinc_crk_cyc
			Cxx_dfinc_crk_oc
			Cxx_dfinc_crk_shp
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vbx_run_eng_det' */
	/* ASAP2::Database : delete 'Vbx_df_crk_no_sig_wio_cam' */
	/* ASAP2::Database : delete 'Vbx_deb_cdn' */
	/* ASAP2::Database : delete 'Vbx_diag_ena_crk_no_sig_wio_cam' */
	/* ASAP2::Database : delete 'Vbx_main_cdn' */
	/* ASAP2::Database : delete 'Vbx_map_flu_cdn' */
	/* ASAP2::Database : delete 'Vxx_ctr_vld_crk_fail1' */
	/* ASAP2::Database : delete 'Vxx_crk_syn_loss_ctr_ini' */
	/* ASAP2::Database : delete 'Vbx_pres_df_crk_chr' */
	/* ASAP2::Database : delete 'Vbx_pres_df_crk_cmp' */
	/* ASAP2::Database : delete 'Vbx_pres_df_crk_cyc' */
	/* ASAP2::Database : delete 'Vbx_pres_df_crk_no_sig' */
	/* ASAP2::Database : delete 'Vbx_pres_df_crk_oc' */
	/* ASAP2::Database : delete 'Vbx_pres_df_crk_shp' */
	/* ASAP2::Database : 14 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_crk
			Vsx_sens_crk_vld
			Vbx_crk_syn
			Vbx_df_crk_no_sig
			Vbx_diag_ena_crk_no_sig
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn_Derivxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_n_drv_fil_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_n_drv
			Vxx_raw_n_drv
			Vxx_mv_n_drv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn_Filspxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_gear_n_mv_ftc
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_n_mv
			Vxx_n_mv_raw
			Vxb_n2_mv.factor
			Vxb_n2_mv.index
			Vxb_n2_mv.num_dp
			Vxb_n_mv.factor
			Vxb_n_mv.index
			Vxb_n_mv.num_dp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn_Schedul
		""
	/begin DEF_CHARACTERISTIC
			Cbx_in_vvtc_abst_pres_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_in_vvt_cfm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn_Speedxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n2
			Cxx_tdc_rev_nr
			Ctp_tco_n_ini
			Ctb_n
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_n
			Vxx_tdc_per
			Vsx_n_vld
			Vxb_n.factor
			Vxb_n.index
			Vxb_n.num_dp
			Vxb_n2.factor
			Vxb_n2.index
			Vxb_n2.num_dp
			Vbx_n_ini
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin FUNCTION
		InSmiSyn_Synchro
		""
	/begin OUT_MEASUREMENT
			Vxx_tdc_ctr
			Vbx_eng_syn
			Vxx_eng_angl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs
		""
	/* ASAP2::Database : delete 'InTqiAcs_Clmcoxx' */
	/* ASAP2::Database : delete 'InTqiAcs_Paltcox' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin SUB_FUNCTION
			InTqiAcs_Paltxcs
			InTqiAcs_Paltxmd
			InTqiAcs_Clmxxcs
			InTqiAcs_Clmxxmd
			InTqiAcs_Paltxfs
			InTqiAcs_Ptcpocs
			InTqiAcs_Rgbepcs
			InTqiAcs_Ptcxxmd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs_Clmxxcs
		""
	/begin DEF_CHARACTERISTIC
			Ctp_ac_pow_dft_val
			Ctb_ac_pow
			Ctb_ac_pow_cor_n
			Cmp_ac_pow_cor_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_raw_ac_pow
			Vxx_ac_pow
			Vxx_no_cor_raw_ac_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs_Clmxxmd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ac_pow_max
			Cxx_ac_pow_min
			Cxx_ac_pow_n_fac
			Cxx_ac_pow_prs_fac
			Cxx_ac_pow_prs_n_fac
			Cxx_acr_eng_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_mdl_ac_pow_vld
			Vxx_mdl_ac_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs_Paltxcs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_alt_pow_trs_fil_dec
			Cxx_alt_pow_trs_fil_inc
			Cxx_alt_slop_dly
			Cxx_sta_alt_dec
			Cxx_sta_alt_inc
			Ctp_alt_pow_fil_fac
			Ctb_alt_n_fil_fac
			Cxx_alt_pow_dsb_fil_fac
			Cxx_alt_pow_trs_dif_thd
			Ctb_alt_pow
			Ctb_alt_pow_cor_n
			Cmp_alt_pow_cor_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_alt_pow_trs
			Vxx_alt_pow_fil_fac
			Vxx_alt_pow_load
			Vxx_fil_alt_pow_load_trs
			Vsx_alt_pow_vld
			Vxx_fil_alt_pow
			Vxx_alt_pow
			Vsx_fil_alt_pow_vld
			Vxx_no_cor_raw_alt_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs_Paltxfs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_eng_loss_pow_min
			Cxx_mdf1_meca_pow
			Cxx_mdf2_meca_pow
			Cxx_el_wind_meca_pow
			Cxx_el_bk_wind_meca_pow
			Cxx_alt_is_meca_pow
			Cxx_rgb_pump_meca_pow
			Cxx_psh_meca_pow
			Cxx_thpl_meca_pow
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_el_csm_mdl_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs_Paltxmd
		""
	/* ASAP2::Database : delete 'Ctb_alt_n' */
	/* ASAP2::Database : delete 'Ctp_alt_n_fac' */
	/* ASAP2::Database : delete 'Ctp_alt_n_ofs' */
	/* ASAP2::Database : delete 'Ctp_alt_n_lim' */
	/* ASAP2::Database : 4 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_eng_alt_rat
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vxx_alt_n' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_mdl_alt_pow_vld
			Vxx_mdl_alt_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs_Ptcpocs
		""
	/begin OUT_MEASUREMENT
			Vxx_ptc_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InTqiAcs_Ptcxxmd
		""
	/begin OUT_MEASUREMENT
			Vxx_mdl_ptc_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin FUNCTION
		InTqiAcs_Rgbepcs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_rgb_pump_act_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_rgb_pump
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/begin FUNCTION
		InVfiAci
		""
	/begin OUT_MEASUREMENT
			InVfiAci_NVM.Vbx_ac_prs_lk_stt_NVM
			InVfiAci_NVM.Vbx_ac_req_lk_stt_NVM
			InVfiAci_NVM.Vbx_comp_cfa_lk_stt_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'InVfiAci_Blowxcs' */
	/* ASAP2::Database : delete 'InVfiAci_Blowxwf' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin SUB_FUNCTION
			InVfiAci_Mngtxcs
			InVfiAci_Acprssr
			InVfiAci_Acclucs
			InVfiAci_Acwfinx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/begin FUNCTION
		InVfiAci_Acclucs
		""
	/begin OUT_MEASUREMENT
			Vbx_ac_clu_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/begin FUNCTION
		InVfiAci_Acprssr
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ac_prs_fac
			Cxx_ac_lk_stt_dly
			Cxx_ac_prs_lk_stt_dly
			Cxx_ac_prs_ofs
			Cxx_ac_prs_v_max
			Cxx_ac_prs_v_min
			Cxx_dfinc_ac_prs
			Cxx_dfdec_ac_prs
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ac_ext_pres
			Vbx_ac_pres
			Vxx_ac_prs
			Vsx_ac_prs_vld
			Vbx_df_ac_prs_h
			Vbx_df_ac_prs_l
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/begin FUNCTION
		InVfiAci_Acwfinx
		""
	/begin OUT_MEASUREMENT
			Vbx_wf_ac_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/begin FUNCTION
		InVfiAci_Mngtxcs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ac_req_dly
			Cxx_ac_req_dsb_dly
			Cxx_wf_ac_req_dly
			Cxx_wf_ac_req_dsb_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ac_req
			Vbx_ac_mdf2_req_ext
			Vbx_agb_mdf1_req
			Vbx_agb_mdf2_req
			Vbx_ac_mdf1_req_ext
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/begin FUNCTION
		InVfiCri
		""
	/begin SUB_FUNCTION
			InVfiCri_Keyxxxx
			InVfiCri_Mngtxcs
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/begin FUNCTION
		InVfiCri_Keyxxxx
		""
	/begin OUT_MEASUREMENT
			Vbx_igk
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/begin FUNCTION
		InVfiCri_Mngtxcs
		""
	/begin OUT_MEASUREMENT
			Vbx_vh_key
			Vsx_ena_sta_agb
			Vsx_ena_sta_agb_vld
			Vsx_sta_stt_vld
			Vxx_sta_stt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin FUNCTION
		InVfiEmi
		""
	/* ASAP2::Database : delete 'InVfiEmi_Irotxcs' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			InVfiEmi_Batxxxx
			InVfiEmi_Altdfcs
			InVfiEmi_Altdfsr
			InVfiEmi_Bduxxcs
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin FUNCTION
		InVfiEmi_Altdfcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_mux_alt_pwm_cfm
			Cxx_alt_pwm_l
			Cxx_alt_pwm_sub
			Cxx_mux_alt_pwm_fil_t
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_alt_pwm
			Vsx_alt_pwm_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		InVfiEmi_Altdfsr
		""
	/* ASAP2::Database : delete 'Vbx_df_alt_pwm_apl_down' */
	/* ASAP2::Database : delete 'Vbx_ecm_alt_lk_stt' */
	/* ASAP2::Database : delete 'Vbx_ena_nom_trtm' */
	/* ASAP2::Database : delete 'Vxx_alt_esti_temp' */
	/* ASAP2::Database : delete 'Vxx_alt_r' */
	/* ASAP2::Database : delete 'Vxx_alt_v' */
	/* ASAP2::Database : delete 'Vxx_cut_off_frq' */
	/* ASAP2::Database : delete 'Vxx_sens_alt_pwm' */
	/* ASAP2::Database : 8 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_sens_alt_fil_pwm_vld
			Vxx_sens_alt_fil_pwm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin FUNCTION
		InVfiEmi_Batxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_vb_l
			Cxx_dfdec_vb_rly_scw
			Cxx_dfinc_vb_h
			Cxx_dfinc_vb_l
			Cxx_dfinc_vb_rly_oc_scg
			Cxx_dfinc_vb_rly_scw
			Cxx_thd_n_diag_vb_h
			Cxx_thd_n_diag_vb_l
			Cxx_thd_vb_h
			Cxx_thd_vb_l
			Cxx_mv_vb_fac
			Cxx_dfdec_vb_rly_oc_scg
			Cxx_dfdec_vb_h
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_vb_h
			Vbx_df_vb_l
			Vbx_diag_ena_vb_h
			Vbx_diag_ena_vb_l
			Vsx_vb_rly_vld
			Vsx_vb_vld
			Vxx_mv_vb
			Vxx_vb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin FUNCTION
		InVfiEmi_Bduxxcs
		""
	/begin OUT_MEASUREMENT
			Vbx_bdu_ope
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiesi.xml' */
/begin FUNCTION
		InVfiEsi
		""
	/begin SUB_FUNCTION
			InVfiEsi_Mngtxcs
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfiesi.xml' */
/begin FUNCTION
		InVfiEsi_Mngtxcs
		""
	/begin OUT_MEASUREMENT
			Vxx_airb1
			Vxx_airb2
			Vxx_eng_stop_req_ssg
			Vxx_eng_stop_req_rgb
			Vxx_eng_stop_req_ccu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi
		""
	/begin SUB_FUNCTION
			InVfiVsi_Mngtxcs
			InVfiVsi_Dgtdvcs
			InVfiVsi_Tacelmd
			InVfiVsi_Dsplvcs
			InVfiVsi_Lacelmd
			InVfiVsi_Rwsxxcs
			InVfiVsi_Tacelcs
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi_Dgtdvcs
		""
	/begin DEF_CHARACTERISTIC
			Cxx_vh_dist_max_dif
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			INVFIVSI_NVM.Vxx_vh_dist_NVM
			Vsx_vh_dist_vld
			Vxx_vh_dist_l_res
			Vbx_ecu_pres
			Vsx_vh_dist_l_res_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi_Dsplvcs
		""
	/begin OUT_MEASUREMENT
			Vsx_dspl_vs_vld
			Vxx_dspl_vs
			Vbx_dspl_vs_in_mph
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi_Lacelmd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_lg_acel_fil
			Cxx_vs_tkof_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_lg_acel
			Vxx_lg_acel_raw
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi_Mngtxcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_vs_vld_bch_mod_ena
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_vs_vld
			Vxx_vs
			Vsx_vs_2_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi_Rwsxxcs
		""
	/begin OUT_MEASUREMENT
			Vsx_lft_rwhs_vld
			Vsx_rgt_rwhs_vld
			Vxx_lft_rwhs
			Vxx_rgt_rwhs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi_Tacelcs
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tra_acel_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_tra_acel_vld
			Vxx_tra_acel
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin FUNCTION
		InVfiVsi_Tacelmd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_h_thd_tra_acel_ok
			Cxx_l_thd_tra_acel_ok
			Cxx_rel_err_fil
			Cxx_rel_err_thd_max
			Cxx_rwhb
			Cxx_rwhs_fil
			Cxx_rwhs_max_tra_acel
			Cxx_rwhs_min_tra_acel
			Cxx_tra_acel_mv_fil
			Cxx_wait_tra_acel_vld
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ini_rel_err_fil
			Vbx_mdl_tra_acel_ok
			Vbx_rwhs_ok
			Vbx_t_end
			Vsx_mdl_tra_acel_vld
			Vxx_abs_tra_acel_mv
			Vxx_diff_rel_err
			Vxx_mdl_tra_acel
			Vxx_mdl_tra_acel_clc
			Vxx_rel_err
			Vxx_rel_err_mv
			Vxx_rel_err_mv_dly
			Vxx_rwhs_diff
			Vxx_rwhs_sum
			Vxx_t_wait_tra_acel_vld
			Vxx_tra_acel_mv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin FUNCTION
		OuAsoEgr
		""
	/begin OUT_MEASUREMENT
			OuAsoEgr_NVM.Vxx_emtv_psn_err_sat_1_NVM
			OuAsoEgr_NVM.Vxx_emtv_reg_h_thd_1_NVM
			OuAsoEgr_NVM.Vxx_emtv_reg_l_thd_1_NVM
			OuAsoEgr_NVM.Vxx_emtv_psn_ofs_clos_frst_NVM
			OuAsoEgr_NVM.Vxx_emtv_psn_ofs_clos_last_NVM
			OuAsoEgr_NVM.Vxx_dfctr_emtv_cutt_NVM
			OuAsoEgr_NVM.Vxx_dfctr_emtv_reg_dirt_eprm_NVM
			OuAsoEgr_NVM.Vxx_dfctr_emtv_ofs_no_norm_eprm_NVM
			OuAsoEgr_NVM.Vxx_emtv_clos_rat_h_thd_1_NVM
			OuAsoEgr_NVM.Vxx_emtv_clos_rat_h_thd_2_NVM
			OuAsoEgr_NVM.Vxx_emtv_clos_rat_l_thd_1_NVM
			OuAsoEgr_NVM.Vxx_emtv_clos_rat_l_thd_2_NVM
			OuAsoEgr_NVM.Vxx_emtv_clos_rat_val_1_NVM
			OuAsoEgr_NVM.Vxx_emtv_clos_rat_val_2_NVM
			OuAsoEgr_NVM.Vbx_emtv_ofs_clos_frst_1_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			OuAsoEgr_Evdiagx
			OuAsoEgr_Evmonxx
			OuAsoEgr_Evregul
			OuAsoEgr_Bypxcmd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin FUNCTION
		OuAsoEgr_Bypxcmd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_egr_byp_h
			Cxx_dfdec_egr_byp_l
			Cxx_dfinc_egr_byp_h
			Cxx_dfinc_egr_byp_l
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_egr_byp_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin FUNCTION
		OuAsoEgr_Evdiagx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_emtv_clos_dly
			Cxx_emtv_clos_nok_thd
			Cxx_emtv_clos_thd
			Cxx_emtv_reg_clos_fail_mod
			Cxx_emtv_reg_open_fail_mod
			Cbx_emtv_obd_thd_cho
			Cbx_emtv_v_lim_ena
			Cxx_emtv_vb_nok_dly
			Cxx_emtv_vb_lim_up_2
			Cxx_emtv_vb_lim_up_1
			Cxx_emtv_vb_lim_down_1
			Cxx_emtv_vb_lim_down_2
			Ctb_emtv_psn_ofs_disp_last_1
			Ctp_emtv_psn_ofs_disp_last_1
			Cxx_emtv_amp_thd_h_mon
			Cxx_emtv_amp_thd_l_mon
			Cxx_emtv_clos_rat_h_thd_1
			Cxx_emtv_clos_rat_h_thd_2
			Cxx_emtv_clos_rat_thd
			Cxx_emtv_crt_val_neg_dly_1
			Cxx_emtv_crt_val_neg_dly_2
			Cxx_emtv_crt_val_pos_dly_1
			Cxx_emtv_crt_val_pos_dly_2
			Cxx_emtv_el_fail_mod
			Cxx_emtv_lacq_fail_mod
			Cxx_emtv_ofs_fail_mod
			Cxx_emtv_ofs_lim_clos_down
			Cxx_emtv_ofs_lim_clos_up
			Cxx_emtv_psn_cutt_thd
			Cxx_emtv_psn_ofs_frst_thd
			Cxx_emtv_reg_blk_dly_1
			Cxx_emtv_reg_blk_dly_2
			Cxx_emtv_reg_blk_open_fail_mod
			Cxx_emtv_reg_blk_open_thd
			Cxx_emtv_vb_fail_mod
			Cxx_emtv_reg_h_thd
			Cxx_emtv_reg_l_thd
			Cxx_emtv_sens_fail_mod
			Cxx_emtv_tco_thd_h_mon
			Cxx_emtv_tco_thd_l_mon
			Cxx_emtv_v_neg_thd
			Cxx_emtv_v_pos_thd
			Cxx_dfdec_emtv_flow_meca
			Cxx_dfdec_emtv_hbdg_el
			Cxx_dfdec_emtv_hbdg_ovh
			Cxx_dfdec_emtv_ofs_no_norm
			Cxx_dfdec_emtv_reg_blk
			Cxx_dfdec_emtv_reg_blk_open
			Cxx_dfdec_emtv_reg_dirt
			Cxx_dfinc_emtv_flow_meca
			Cxx_dfinc_emtv_hbdg_el
			Cxx_dfinc_emtv_hbdg_ovh
			Cxx_dfinc_emtv_ofs_no_norm
			Cxx_dfinc_emtv_reg_blk
			Cxx_dfinc_emtv_reg_blk_open
			Cxx_dfinc_emtv_reg_dirt
			Cxx_dfctr_emtv_cutt_thd
			Cxx_dfctr_emtv_ofs_no_norm_thd
			Cxx_dfctr_emtv_reg_dirt_thd
			Ctp_emtv_psn_ofs_disp_last_2
			Ctb_emtv_psn_ofs_disp_last_2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_dft_emtv_cutt_1
			Vbx_dft_emtv_flow_meca_1
			Vbx_dft_emtv_ofs
			Vbx_dft_emtv_ofs_no_norm
			Vbx_dft_emtv_reg_blk_open_1
			Vbx_dft_emtv_reg_clos_tco
			Vbx_dft_emtv_reg_dirt
			Vbx_dft_emtv_reg_neg
			Vbx_dft_emtv_reg_neg_open
			Vbx_dft_emtv_reg_pos
			Vbx_dft_emtv_reg_pos_open
			Vbx_emtv_eprm_rst_tool
			Vxx_dfctr_emtv_cutt_1
			Vxx_dfctr_emtv_cutt_2
			Vxx_dfctr_emtv_ofs_no_norm_1
			Vxx_dfctr_emtv_ofs_no_norm_2
			Vxx_dfctr_emtv_reg_dirt_1
			Vxx_dfctr_emtv_reg_dirt_2
			Vbx_dft_emtv_cutt
			Vbx_emtv_clos
			Vbx_emtv_diag_ofs_done
			Vbx_emtv_v_lim_req
			Vxx_emtv_clos_rat
			Sbx_pfo_emtv_flow_meca
			Sbx_pfo_emtv_reg_blk
			Sbx_pfo_emtv_reg_blk_open
			Vbx_df_emtv_flow_meca
			Vbx_df_emtv_reg_blk
			Vbx_df_emtv_reg_blk_open
			Vbx_emtv_crt_val_neg
			Vbx_emtv_crt_val_pos
			Vbx_emtv_cutt_res
			Vbx_emtv_lacq
			Vbx_emtv_psn_blk_h
			Vbx_emtv_psn_clos
			Vbx_emtv_reg_blk_chk_ena
			Vbx_emtv_reg_blk_chk_ok
			Vbx_emtv_reg_blk_chk_stop
			Vbx_emtv_vb_nok
			Vxx_emtv_clos_rat_1
			Vxx_emtv_clos_rat_2
			Vxx_emtv_clos_rat_thd
			Vxx_emtv_clos_rat_thd_1
			Vxx_emtv_psn_err_2
			Vxx_emtv_reg_h_thd
			Vxx_emtv_reg_l_thd
			Vsx_emtv_vld
			Vsx_emtv_0_vld
			Vxx_dfctr_emtv_cutt_sta
			Vxx_dfctr_emtv_ofs_no_norm_sta
			Vxx_dfctr_emtv_reg_dirt_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin FUNCTION
		OuAsoEgr_Evmonxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_emtv_bch_mod_ena
			Ctb_emtv_pwl_act
			Cxx_emtv_act_tco_thd
			Cxx_emtv_clos_ctr_1
			Cxx_emtv_clos_ctr_2
			Cxx_emtv_ofs_ctr_1_max
			Cxx_emtv_ofs_tco_thd
			Cxx_emtv_v_lim_down_1
			Cxx_emtv_v_lim_down_2
			Cxx_emtv_v_lim_up_1
			Cxx_emtv_v_lim_up_2
			Cxx_emtv_v_ofs_lim_down
			Cxx_emtv_v_sp_clos_1
			Cxx_emtv_v_sp_clos_2
			Cxx_t_emtv_act_1
			Cxx_t_emtv_act_dly
			Ctp_emtv_pwl_act
			Cbx_emtv_psn_ofs_cho
			Cxx_emtv_psn_clos_rel_thd
			Cxx_emtv_psn_lim_down
			Cxx_emtv_psn_lim_up
			Cxx_emtv_psn_ofs_lim_down
			Cxx_emtv_psn_ofs_open
			Cxx_emtv_psn_sp_clos_thd_in
			Cxx_emtv_psn_sp_clos_thd_out
			Cxx_emtv_psn_ofs_clos_frst_eprm
			Cxx_emtv_psn_ofs_clos_last_eprm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_diag_ena_emtv_reg_err
			Vbx_egr_pws_rtn
			Vbx_emtv_clos_ok_trg
			Vbx_emtv_clos_req
			Vbx_emtv_ofs_done
			Vbx_emtv_ofs_ena
			Vbx_emtv_ofs_fail
			Vbx_emtv_ofs_ok
			Vbx_emtv_pwl_ok
			Vbx_emtv_v_sp_cho
			Vbx_nox_req
			Vbx_pft_req
			Vxx_emtv_t_pwl
			Vxx_emtv_v_lim_down
			Vxx_emtv_v_lim_down_1
			Vxx_emtv_v_lim_up
			Vxx_emtv_v_lim_up_1
			Vbx_emtv_psn_cho
			Vbx_emtv_psn_mv_tot_ena
			Vbx_emtv_psn_stab_ena
			Vxx_emtv_psn_cmd
			Vxx_emtv_psn_cutt
			Vxx_emtv_psn_lim_cutt
			Vxx_emtv_psn_lim_down
			Vxx_emtv_psn_lim_down_1
			Vxx_emtv_psn_lim_up
			Vxx_emtv_psn_ofs_clos
			Vxx_emtv_psn_ofs_down
			Vxx_emtv_psn_ofs_lim_down_1
			Vxx_emtv_psn_ofs_up
			Vxx_emtv_psn_sp_1
			Vxx_emtv_psn_sp_cmd
			Vxx_emtv_psn_sp_pwl
			Vxx_emtv_v_ofs_lim_down
			Vxx_emtv_v_sp_cmd
			Vxx_emtv_ofs_ctr_1
			Vxx_emtv_clos_ctr
			Vbx_emtv_clos_ok
			Vbx_diag_ena_emtv_ofs
			Vbx_emtv_ofs_clos_frst
			Vbx_emtv_ofs_clos_frst_eprm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin FUNCTION
		OuAsoEgr_Evregul
		""
	/begin DEF_CHARACTERISTIC
			Cxx_emtv_cmd_val_1
			Cxx_emtv_cmd_val_2
			Cxx_emtv_cmd_val_3
			Cxx_emtv_cps_v
			Cxx_emtv_ctl_lim
			Cxx_emtv_frn_cps_v
			Cxx_emtv_stab_dly_1
			Cbx_emtv_psn_ctl_sgn
			Cbx_emtv_psn_fil_cho_1
			Cbx_emtv_psn_sp_ctl_sgn
			Cxx_emtv_psn_ctl_0
			Cxx_emtv_psn_ctl_1
			Cxx_emtv_psn_ctl_2
			Cxx_emtv_psn_ctl_3
			Cxx_emtv_psn_frn_cps_thd
			Cxx_emtv_psn_slop_lim_down
			Cxx_emtv_psn_slop_lim_up
			Cxx_emtv_psn_sp_ctl_0
			Cxx_emtv_psn_sp_ctl_1
			Cxx_emtv_psn_sp_ctl_2
			Cxx_emtv_psn_sp_stab_thd
			Cxx_emtv_psn_stab_thd_1
			Cxx_emtv_psn_thd_1
			Cxx_emtv_psn_slop_lim_down_1
			Cxx_emtv_psn_slop_lim_up_1
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_v_lim_down
			Vxx_emtv_cmd_val
			Vxx_emtv_cmd_val_1
			Vxx_emtv_cmd_val_2
			Vxx_emtv_cmd_val_3
			Vxx_emtv_cmd_val_lim
			Vxx_emtv_ctl_err
			Vxx_emtv_ctl_err_lim
			Vxx_emtv_frn_cps_v
			Vxx_emtv_v_sp
			Vxx_emtv_v_sp_cor_lim
			Vbx_emtv_trt_zon
			Vxx_emtv_psn_ctl
			Vxx_emtv_psn_ctl_0
			Vxx_emtv_psn_ctl_1
			Vxx_emtv_psn_ctl_2
			Vxx_emtv_psn_ctl_3
			Vxx_emtv_psn_lim_down_thd
			Vxx_emtv_psn_lim_up_thd
			Vxx_emtv_psn_reg_1
			Vxx_emtv_psn_reg_2
			Vxx_emtv_psn_reg_3
			Vxx_emtv_psn_rel
			Vxx_emtv_psn_sp_cor
			Vxx_emtv_psn_sp_cor_1
			Vxx_emtv_psn_sp_ctl
			Vxx_emtv_psn_sp_ctl_0
			Vxx_emtv_psn_sp_ctl_1
			Vxx_emtv_psn_sp_ctl_2
			Vxx_emtv_psn_sp_mod
			Vxx_emtv_psn_sp_reg
			Vxx_emtv_psn_sp_slop
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin FUNCTION
		OuAsoIto
		""
	/begin OUT_MEASUREMENT
			OuAsoIto_NVM.Vxx_it_psn_ofs_clos_frst_NVM
			OuAsoIto_NVM.Vxx_it_psn_ofs_clos_last_NVM
			OuAsoIto_NVM.Vxx_it_psn_ofs_open_frst_NVM
			OuAsoIto_NVM.Vxx_it_psn_ofs_open_last_NVM
			OuAsoIto_NVM.Vxx_dfctr_it_dirt_clos_NVM
			OuAsoIto_NVM.Vxx_dfctr_it_cutt_NVM
			OuAsoIto_NVM.Vxx_dfctr_sit_reg_el_eprm_NVM
			OuAsoIto_NVM.Vxx_dfctr_sit_reg_blk_open_eprm_NVM
			OuAsoIto_NVM.Vxx_dfctr_it_ofs_clos_frst_NVM
			OuAsoIto_NVM.Vxx_dfctr_it_ofs_open_frst_NVM
			OuAsoIto_NVM.Vbx_it_ofs_clos_frst_eprm_NVM
			OuAsoIto_NVM.Vbx_it_ofs_open_frst_eprm_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			OuAsoIto_Itdiagx
			OuAsoIto_Itmonxx
			OuAsoIto_Itregul
			OuAsoIto_Itcoxxx
			OuAsoIto_Oitdiag
			OuAsoIto_Oitmonx
			OuAsoIto_Schxxxx
			OuAsoIto_Sitdiag
			OuAsoIto_Sitmonx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin FUNCTION
		OuAsoIto_Itcoxxx
		""
	/begin OUT_MEASUREMENT
			Vbx_it_pws_req
			Vsx_it_vld
			Vxx_it_psn_sp_1
			Vxx_it_psn_sp_2
			Vxx_it_psn_sp_cmd
			Vbx_it_open
			Vbx_it_ofs_clos_frst
			Vbx_it_ofs_open_frst
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin FUNCTION
		OuAsoIto_Itdiagx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_it_v_lim_ena
			Cxx_dfctr_it_cutt_thd
			Cxx_dfctr_it_dirt_clos_thd
			Cxx_dfctr_it_ofs_clos_frst_thd
			Cxx_dfctr_it_ofs_open_frst_thd
			Cxx_dfdec_it_hbdg_el
			Cxx_dfdec_it_hbdg_ovh
			Cxx_dfdec_it_ofs_no_norm
			Cxx_dfdec_it_reg_blk
			Cxx_dfdec_it_reg_blk_clos
			Cxx_dfdec_it_reg_blk_open
			Cxx_dfdec_it_reg_dirt
			Cxx_dfinc_it_hbdg_el
			Cxx_dfinc_it_hbdg_ovh
			Cxx_dfinc_it_ofs_no_norm
			Cxx_dfinc_it_reg_blk
			Cxx_dfinc_it_reg_blk_clos
			Cxx_dfinc_it_reg_blk_open
			Cxx_dfinc_it_reg_dirt
			Cxx_it_blk_dly_1
			Cxx_it_blk_dly_2
			Cxx_it_blk_fail_mod
			Cxx_it_blk_thd
			Cxx_it_clos_thd
			Cxx_it_crt_val_neg_dly_1
			Cxx_it_crt_val_neg_dly_2
			Cxx_it_crt_val_pos_dly_1
			Cxx_it_crt_val_pos_dly_2
			Cxx_it_el_fail_mod
			Cxx_it_ofs_fail_mod
			Cxx_it_ofs_lim_clos_down
			Cxx_it_ofs_lim_clos_up
			Cxx_it_ofs_lim_open_down
			Cxx_it_ofs_lim_open_up
			Cxx_it_open_dly
			Cxx_it_open_nok_thd
			Cxx_it_open_thd
			Cxx_it_psn_cmd_clos
			Cxx_it_psn_cmd_open
			Cxx_it_psn_cutt_thd
			Cxx_it_psn_ofs_frst_thd
			Cxx_it_psn_rat_thd
			Cxx_it_reg_fail_mod
			Cxx_it_reg_h_thd
			Cxx_it_reg_l_thd
			Cxx_it_sens_fail_mod
			Cxx_it_v_neg_thd
			Cxx_it_v_pos_thd
			Cxx_it_vb_fail_mod
			Cxx_it_vb_lim_down_1
			Cxx_it_vb_lim_down_2
			Cxx_it_vb_lim_up_1
			Cxx_it_vb_lim_up_2
			Cxx_it_vb_nok_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Sbx_pfo_it_reg_blk_clos
			Sbx_pfo_it_reg_blk_open
			Vbx_df_it_reg_blk
			Vbx_df_it_reg_blk_clos
			Vbx_df_it_reg_blk_open
			Vbx_dft_it_cutt
			Vbx_dft_it_cutt_1
			Vbx_dft_it_ofs
			Vbx_dft_it_ofs_clos_frst
			Vbx_dft_it_ofs_open_frst
			Vbx_dft_it_reg_clos
			Vbx_dft_it_reg_dirt
			Vbx_dft_it_reg_neg
			Vbx_dft_it_reg_neg_clos
			Vbx_dft_it_reg_neg_open
			Vbx_dft_it_reg_open
			Vbx_dft_it_reg_pos
			Vbx_dft_it_reg_pos_clos
			Vbx_dft_it_reg_pos_open
			Vbx_it_blk_chk_ena
			Vbx_it_blk_chk_ok
			Vbx_it_blk_chk_stop
			Vbx_it_clos_open_req
			Vbx_it_clos_req
			Vbx_it_crt_val_neg
			Vbx_it_crt_val_pos
			Vbx_it_cutt_res
			Vbx_it_diag_ofs_done
			Vbx_it_diag_ofs_done_clos
			Vbx_it_diag_ofs_done_open
			Vbx_it_eprm_rst_tool
			Vbx_it_hbdg_nok
			Vbx_it_ofs_frst
			Vbx_it_psn_clos
			Vbx_it_v_lim_req
			Vbx_it_vb_nok
			Vxx_dfctr_it_cutt_1
			Vxx_dfctr_it_cutt_2
			Vxx_dfctr_it_cutt_sta
			Vxx_dfctr_it_dirt_clos_1
			Vxx_dfctr_it_dirt_clos_2
			Vxx_dfctr_it_dirt_clos_sta
			Vxx_dfctr_it_ofs_clos_frst_1
			Vxx_dfctr_it_ofs_clos_frst_2
			Vxx_dfctr_it_ofs_clos_frst_sta
			Vxx_dfctr_it_ofs_open_frst_1
			Vxx_dfctr_it_ofs_open_frst_2
			Vxx_dfctr_it_ofs_open_frst_sta
			Vxx_it_psn_err
			Vxx_it_psn_rat
			Vbx_it_open_0
			Vsx_it_vld_0
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin FUNCTION
		OuAsoIto_Itmonxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_it_frst_ofs_act
			Ctb_it_pwl_act
			Ctb_it_sp_cor
			Ctp_it_frst_ofs_act
			Ctp_it_pwl_act
			Ctp_it_sp_cor
			Cbx_it_bch_mod_ena
			Cbx_it_frst_ofs_ena
			Cbx_it_frst_ofs_ena_1
			Cbx_it_frst_ofs_open_ena
			Cbx_it_ofs_last_ena
			Cbx_it_psn_ofs_cho
			Cxx_it_clos_ctr_1
			Cxx_it_ofs_ctr_1_max
			Cxx_it_ofs_tco_thd_max
			Cxx_it_ofs_tco_thd_min
			Cxx_it_open_ctr_1
			Cxx_it_psn_clos_rel_thd
			Cxx_it_psn_lim_down
			Cxx_it_psn_lim_up
			Cxx_it_psn_ofs_clos_frst_eprm
			Cxx_it_psn_ofs_clos_last_eprm
			Cxx_it_psn_ofs_lim_down
			Cxx_it_psn_ofs_lim_up
			Cxx_it_psn_ofs_open_frst_eprm
			Cxx_it_psn_ofs_open_last_eprm
			Cxx_it_psn_open_rel_thd
			Cxx_it_psn_sp_clos_thd_in
			Cxx_it_psn_sp_clos_thd_out
			Cxx_it_psn_sp_open_thd_in
			Cxx_it_psn_sp_open_thd_out
			Cxx_it_pwm_clos
			Cxx_it_pwm_open
			Cxx_it_t_frst_ofs_act
			Cxx_it_t_pwl_act
			Cxx_it_turnon_dly_clos
			Cxx_it_turnon_dly_open
			Cxx_it_v_lim_down_1
			Cxx_it_v_lim_down_2
			Cxx_it_v_lim_up_1
			Cxx_it_v_lim_up_2
			Cxx_it_v_ofs_lim_down
			Cxx_it_v_ofs_lim_up
			Cxx_it_v_sp_clos_1
			Cxx_it_v_sp_open_1
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_diag_ena_it_ofs
			Vbx_diag_ena_it_reg_err
			Vbx_it_ofs_clos_frst_1
			Vbx_it_ofs_clos_frst_2
			Vbx_it_ofs_clos_open
			Vbx_it_ofs_clos_open_trg
			Vbx_it_ofs_done
			Vbx_it_ofs_ena
			Vbx_it_ofs_fail
			Vbx_it_ofs_ok
			Vbx_it_ofs_open_frst_1
			Vbx_it_ofs_open_frst_2
			Vbx_it_psn_cho
			Vbx_it_psn_frst_ofs_ena
			Vbx_it_psn_mv_tot_ena
			Vbx_it_psn_stab_ena
			Vbx_it_sp_swi_frst_ofs
			Vbx_it_trt_typ
			Vbx_it_v_sp_cho
			Vxx_it_clos_ctr
			Vxx_it_ofs_clos_frst_ctr
			Vxx_it_ofs_ctr_1
			Vxx_it_ofs_open_frst_ctr
			Vxx_it_open_ctr
			Vxx_it_psn_cmd
			Vxx_it_psn_lim_down
			Vxx_it_psn_lim_up
			Vxx_it_psn_ofs_clos
			Vxx_it_psn_ofs_down
			Vxx_it_psn_ofs_open
			Vxx_it_psn_ofs_up
			Vxx_it_psn_sp_3
			Vxx_it_psn_sp_ofs
			Vxx_it_psn_sp_pwl
			Vxx_it_t_frst_ofs
			Vxx_it_t_pwl_act
			Vxx_it_v_lim_down
			Vxx_it_v_lim_down_1
			Vxx_it_v_lim_up
			Vxx_it_v_lim_up_1
			Vxx_it_v_ofs_lim_down
			Vxx_it_v_ofs_lim_up
			Vxx_it_v_sp_cmd
			Vbx_it_ofs_clos_frst_0
			Vbx_it_ofs_open_frst_0
			Vbx_it_pws_req_0
			Vxx_it_psn_sp_1_0
			Vxx_it_psn_sp_2_0
			Vxx_it_psn_sp_cmd_0
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin FUNCTION
		OuAsoIto_Itregul
		""
	/begin DEF_CHARACTERISTIC
			Cbx_it_psn_ctl_sgn
			Cbx_it_psn_fil_cho_1
			Cbx_it_psn_sp_ctl_sgn
			Cxx_it_cmd_val_1
			Cxx_it_cmd_val_2
			Cxx_it_cmd_val_3
			Cxx_it_cps_v
			Cxx_it_ctl_lim
			Cxx_it_frn_cps_v
			Cxx_it_psn_ctl_0
			Cxx_it_psn_ctl_1
			Cxx_it_psn_ctl_2
			Cxx_it_psn_ctl_3
			Cxx_it_psn_frn_cps_thd
			Cxx_it_psn_slop_lim_down
			Cxx_it_psn_slop_lim_down_1
			Cxx_it_psn_slop_lim_up
			Cxx_it_psn_slop_lim_up_1
			Cxx_it_psn_sp_ctl_0
			Cxx_it_psn_sp_ctl_1
			Cxx_it_psn_sp_ctl_2
			Cxx_it_psn_sp_stab_thd
			Cxx_it_psn_stab_thd_1
			Cxx_it_psn_thd_1
			Cxx_it_stab_dly_1
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_it_trt_zon
			Vbx_it_v_lim_down
			Vbx_it_v_lim_up
			Vxx_it_cmd_val
			Vxx_it_cmd_val_1
			Vxx_it_cmd_val_2
			Vxx_it_cmd_val_3
			Vxx_it_cmd_val_lim
			Vxx_it_ctl_err
			Vxx_it_ctl_err_lim
			Vxx_it_frn_cps_v
			Vxx_it_psn_ctl
			Vxx_it_psn_ctl_0
			Vxx_it_psn_ctl_1
			Vxx_it_psn_ctl_2
			Vxx_it_psn_ctl_3
			Vxx_it_psn_lim_down_thd
			Vxx_it_psn_lim_up_thd
			Vxx_it_psn_reg_1
			Vxx_it_psn_reg_2
			Vxx_it_psn_reg_3
			Vxx_it_psn_sp_cor
			Vxx_it_psn_sp_cor_1
			Vxx_it_psn_sp_ctl
			Vxx_it_psn_sp_ctl_0
			Vxx_it_psn_sp_ctl_1
			Vxx_it_psn_sp_ctl_2
			Vxx_it_psn_sp_mod
			Vxx_it_psn_sp_reg
			Vxx_it_psn_sp_slop
			Vxx_it_v_sp
			Vxx_it_v_sp_cor_lim
			Vxx_it_psn_rel
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		OuAsoIto_Oitdiag
		""
	/* ASAP2::Database : delete 'Vbx_oit_vb_nok' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_oit_open
			Vsx_oit_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		OuAsoIto_Oitmonx
		""
	/* ASAP2::Database : delete 'Vxx_oit_psn_sp_1' */
	/* ASAP2::Database : delete 'Vxx_oit_psn_sp_3' */
	/* ASAP2::Database : delete 'Vxx_oit_psn_sp_pwl' */
	/* ASAP2::Database : delete 'Vxx_oit_t_pwl_act' */
	/* ASAP2::Database : 4 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_oit_pws_req
			Vxx_oit_psn_sp_2
			Vxx_oit_psn_sp_cmd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin FUNCTION
		OuAsoIto_Schxxxx
		""
	/begin DEF_CHARACTERISTIC
			Csx_it_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_it_cfm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		OuAsoIto_Sitdiag
		""
	/* ASAP2::Database : delete 'Vbx_df_sit_reg_blk_open' */
	/* ASAP2::Database : delete 'Vbx_dft_sit_reg_el' */
	/* ASAP2::Database : delete 'Vbx_sit_diag_sttl' */
	/* ASAP2::Database : delete 'Vbx_sit_diag_sttl_fedg_det' */
	/* ASAP2::Database : delete 'Vbx_sit_eprm_rst' */
	/* ASAP2::Database : delete 'Vbx_sit_rglr_mod' */
	/* ASAP2::Database : delete 'Vbx_sit_sttl' */
	/* ASAP2::Database : delete 'Vbx_sit_sttl_deb_1' */
	/* ASAP2::Database : delete 'Vbx_sit_sttl_deb_2' */
	/* ASAP2::Database : delete 'Vbx_sit_sttl_nok' */
	/* ASAP2::Database : delete 'Vbx_sit_sttl_vb_nok' */
	/* ASAP2::Database : delete 'Vbx_sit_vb_nok' */
	/* ASAP2::Database : delete 'Vxx_dfctr_sit_reg_blk_open_sta' */
	/* ASAP2::Database : delete 'Vxx_dfctr_sit_reg_el_sta' */
	/* ASAP2::Database : 14 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_sit_open
			Vsx_sit_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		OuAsoIto_Sitmonx
		""
	/* ASAP2::Database : delete 'Vbx_sit_swi_pwl' */
	/* ASAP2::Database : delete 'Vxx_sit_psn_sp_1' */
	/* ASAP2::Database : delete 'Vxx_sit_psn_sp_3' */
	/* ASAP2::Database : delete 'Vxx_sit_psn_sp_pwl' */
	/* ASAP2::Database : delete 'Vxx_sit_t_pwl_act' */
	/* ASAP2::Database : 5 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_sit_pws_req
			Vxx_sit_psn_sp_2
			Vxx_sit_psn_sp_cmd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/begin FUNCTION
		OuAsoTco
		""
	/begin SUB_FUNCTION
			OuAsoTco_Vntxcmd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/begin FUNCTION
		OuAsoTco_Vntxcmd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_vnt_h
			Cxx_dfinc_vnt_h
			Cxx_dfdec_vnt_l
			Cxx_dfinc_vnt_l
			Cxx_vb_vnt_pwm_max
			Cxx_vb_vnt_ref
			Cbx_vb_vnt_pwm_fac_cfm
			Ctb_vb_vnt_pwm_fac
			Ctp_vb_vnt_pwm_fac
			Cxx_vb_vnt_pwm_min
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_vnt_vld
			Vxx_vnt_pwm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin FUNCTION
		OuAtoEfi
		""
	/begin OUT_MEASUREMENT
			OuAtoEfi_NVM.Vxx_efi_purg_fwe_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			OuAtoEfi_Command
			OuAtoEfi_Dgpumpx
			OuAtoEfi_Diaginj
			OuAtoEfi_Purgexx
			OuAtoEfi_Dgsldvx
			OuAtoEfi_Tempdgx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin FUNCTION
		OuAtoEfi_Command
		""
	/begin DEF_CHARACTERISTIC
			Ctb_efi_fuel_prs_n
			Ctb_pft_efi_prs_pwm_cor
			Cxx_pft_efi_prs_ftc
			Cxx_pft_efi_pwm_min
			Ctp_efi_fuel_prs_n
			Ctp_pft_efi_pwm_cor
			Ctb_pft_egaf
			Cxx_pft_efi_ff_t
			Cxx_pft_efi_cmd_ftc
			Ctb_efi_ff_pwm
			Ctb_efi_ff_pwm_ff
			Ctp_efi_ff_pwm_ff
			Cxx_pft_efi_act_dly
			Cmp_pft_egaf_tt_t
			Ctb_tt
			Ctb_efi_mv_vb
			Ctp_vb_efi_dly_cor
			Cxx_diag_ena_tefi_t
			Cxx_efy_dly
			Ctp_efi_ff_pwm_prct
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_airb_on
			Vxx_pft_efi_efv_ff
			Vxx_pft_efi_fuel_rel_prs
			Vxx_pft_efi_pwm_prct
			Vbx_eng_run
			Vbx_pft_efi_cmd_ind
			Vbx_pft_efi_cmd_on
			Vbx_pft_efi_ctr_on
			Vbx_rst_on
			Vxx_pft_efi_efv_ff_clc
			Vxx_pft_efi_pwm_ind
			Vxx_pft_efi_pwm_rel
			Vxx_pft_efi_ff_cmd_tmp_ind
			Vxx_pft_efi_ff_cmd_ind
			Vxx_pft_efi_prs_pwm_cor
			Vxx_pft_efi_pwm_prct_ind
			Vxx_pft_efi_pwm_prct_ind_cor
			Vsx_diag_sta_tefi_stt
			Vbx_pft_exh_fsys_open_cmd
			Vbx_diag_sta_tefi_abrt
			Vbx_diag_sta_tefi_ena
			Vbx_diag_sta_tefi_end
			Vxx_efi_dly
			Vxx_efi_dly_vb_cor
			Vxx_pft_efi_ff_cmd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		OuAtoEfi_Dgpumpx
		""
	/* ASAP2::Database : delete 'Vbx_pft_efi_pump_cmd' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_efi_pump_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin FUNCTION
		OuAtoEfi_Dgsldvx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_efi_sldv_oc
			Cxx_dfinc_efi_sldv_oc
			Cxx_dfdec_efi_sldv_scw
			Cxx_dfinc_efi_sldv_scw
			Cxx_dfdec_efi_sldv_scg
			Cxx_dfinc_efi_sldv_scg
			Cxx_pft_sldv_dp_pump_dly
			Cxx_pft_sldv_dp_open_dly
			Cxx_pft_sldv_dp_pwl_rtn_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_efi_sldv_cmd
			Vbx_pft_sldv_dp_open_cmd
			Vsx_efi_sldv_vld
			Vbx_pft_pwl_rtn
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin FUNCTION
		OuAtoEfi_Diaginj
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_efi_inj_oc
			Cxx_dfdec_efi_inj_scg
			Cxx_dfdec_efi_inj_scw
			Cxx_dfinc_efi_inj_oc
			Cxx_dfinc_efi_inj_scg
			Cxx_dfinc_efi_inj_scw
			Cbx_efi_pump_sldv_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_efi_inj_sys_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin FUNCTION
		OuAtoEfi_Purgexx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_efi_purg_msf_egaf
			Ctb_fwe_tco
			Cxx_efi_purg_egaf_ftc
			Cxx_efi_purg_egaf_thd
			Cxx_efi_purg_fuel_min_wht
			Cxx_efi_purg_fwe_thd
			Cxx_efi_purg_max_t
			Cxx_efi_purg_rgn_t
			Cxx_efi_purg_utp_ftc
			Cxx_efi_purg_utp_thd
			Cxx_fwe_tco_max
			Ctp_egaf_efi_purg_msf
			Cmp_tt_tco_fwe_fac
			Ctb_fwe_tt
			Cxx_fwe_tt_max
			Cxx_tt_cor
			Cxx_pft_efi_act_off_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_efi_purg_act
			Vbx_efi_purg_cdn
			Vbx_efi_purg_dem
			Vbx_efi_purg_t_rst
			Vbx_efi_purg_wht_rst
			Vxx_efi_purg_ff
			Vxx_efi_purg_fwe_clc
			Vxx_efi_purg_t
			Vxx_efi_purg_t_clc
			Vxx_efi_purg_wht
			Vxx_efi_purg_wht_clc
			Vxx_tco_clc
			Vxx_tt_clc
			Vbx_efi_purg_act_dly
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin FUNCTION
		OuAtoEfi_Tempdgx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_tbf_fct_apl_down
			Cxx_dfdec_tbf_fct_apl_up
			Cxx_dfinc_tbf_fct_apl_down
			Cxx_dfinc_tbf_fct_apl_up
			Cxx_aftr_rgn_req_dly
			Cxx_mv_dly
			Cxx_pft_utp_max_thd
			Cxx_pft_utp_mv_min_thermal_dft
			Cbx_diag_ena_on_efi_inj_sys
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_tbf_fct_apl_down
			Vbx_df_tbf_fct_apl_up
			Vbx_diag_ena_tbf_fct_apl_down
			Vbx_diag_ena_tbf_fct_apl_up
			Vxx_pft_utp_mv
			Vxx_step_mv
			Vbx_cdn_pft_utp_mv_clc
			Vsx_tbf_fct_apl_down_vld
			Vsx_tbf_fct_apl_up_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/begin FUNCTION
		OuCboFuo
		""
	/begin SUB_FUNCTION
			OuCboFuo_Adacxxx_xxxxxd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/begin FUNCTION
		OuCboFuo_Adacxxx_xxxxxd
		""
	/begin DEF_CHARACTERISTIC
			Cxx_efv_ff_mg_strk_min_acum
			Cxx_fim_sum_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_csm
			Vxx_csm_cyl_comb
			Vxx_csm_rij
			Vxx_csm_sum_mux
			Vxx_csm_sum_mux_rij
			Vxx_fms_fim_tot
			Vxx_csm_cyl_tot
			Vxx_efv_ff_mg_strk
			Vxx_efv_ff_mg_strk_acum
			Vxx_fim_sum_mux_dies[0]
			Vxx_fim_sum_mux_dies[1]
			Vxx_fim_sum_mux_dies_PREV[0]
			Vxx_fim_sum_mux_dies_PREV[1]
			Vxx_fms_fim_cyl_comb
			Vxx_fms_fim_cyl_tot
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/begin FUNCTION
		OuCloCoo
		""
	/* ASAP2::Database : delete 'OuCloCoo_Paoegrx' */
	/* ASAP2::Database : delete 'OuCloCoo_Wfmdfan' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin SUB_FUNCTION
			OuCloCoo_Chvcmdx
			OuCloCoo_Diagthp
			OuCloCoo_Mdfanxx
			OuCloCoo_Tceauxx
			OuCloCoo_Clatoxx
			OuCloCoo_Paotxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/begin FUNCTION
		OuCloCoo_Chvcmdx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_thpl1_not_ena_cfm
			Cbx_thpl2_not_ena_cfm
			Cbx_thpl3_not_ena_cfm
			Cbx_thpl_cut_ena
			Cxx_dfdec_thpl_cmd1_oc
			Cxx_dfdec_thpl_cmd1_scg
			Cxx_dfdec_thpl_cmd1_scw
			Cxx_dfdec_thpl_cmd2_oc
			Cxx_dfdec_thpl_cmd2_scg
			Cxx_dfdec_thpl_cmd2_scw
			Cxx_dfdec_thpl_cmd3_oc
			Cxx_dfdec_thpl_cmd3_scg
			Cxx_dfdec_thpl_cmd3_scw
			Cxx_dfinc_thpl_cmd1_oc
			Cxx_dfinc_thpl_cmd1_scg
			Cxx_dfinc_thpl_cmd1_scw
			Cxx_dfinc_thpl_cmd2_oc
			Cxx_dfinc_thpl_cmd2_scg
			Cxx_dfinc_thpl_cmd2_scw
			Cxx_dfinc_thpl_cmd3_oc
			Cxx_dfinc_thpl_cmd3_scg
			Cxx_dfinc_thpl_cmd3_scw
			Cxx_thpl_min_dec_dly
			Cxx_thpl_min_inc_dly
			Cxx_thpl_samp
			Ctx_thpl_stt_rly_conf1[0]
			Ctx_thpl_stt_rly_conf1[1]
			Ctx_thpl_stt_rly_conf1[2]
			Ctx_thpl_stt_rly_conf2[0]
			Ctx_thpl_stt_rly_conf2[1]
			Ctx_thpl_stt_rly_conf2[2]
			Ctx_thpl_stt_rly_conf3[0]
			Ctx_thpl_stt_rly_conf3[1]
			Ctx_thpl_stt_rly_conf3[2]
			Ctx_thpl_stt_rly_conf4[0]
			Ctx_thpl_stt_rly_conf4[1]
			Ctx_thpl_stt_rly_conf4[2]
			Ctx_thpl_stt_rly_conf5[0]
			Ctx_thpl_stt_rly_conf5[1]
			Ctx_thpl_stt_rly_conf5[2]
			Ctx_thpl_stt_rly_conf6[0]
			Ctx_thpl_stt_rly_conf6[1]
			Ctx_thpl_stt_rly_conf6[2]
			Ctx_thpl_stt_rly_conf7[0]
			Ctx_thpl_stt_rly_conf7[1]
			Ctx_thpl_stt_rly_conf7[2]
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_thpl_is_acel
			Vbx_thpl_cmd1
			Vbx_thpl_cmd2
			Vbx_thpl_cmd3
			Vsx_thpl_vld
			Vxx_thpl_cmd_ref
			Vxx_thpl_ofs
			Vbx_thpl_cut2
			Vbx_thpl_frz2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/begin FUNCTION
		OuCloCoo_Clatoxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dft_lght_off_tco_thd
			Cxx_dft_lght_on_tco_thd
			Cxx_tsta_dft_lght_off_tco_thd
			Cxx_tsta_dft_lght_on_tco_thd
			Cxx_dfdec_ip_lght_tco_ovh
			Cxx_dfinc_ip_lght_tco_ovh
			Cbx_ip_lght_tco_ovh_igk_off_ena
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ip_dft_lght_tco
			Vbx_df_ip_lght_tco_ovh
			Vbx_ip_lght_tco_ovh_igk_off_ena
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/begin FUNCTION
		OuCloCoo_Diagthp
		""
	/begin DEF_CHARACTERISTIC
			Ctb_thpl_diag_n
			Cxx_alt_pwm_nok
			Cxx_thpl_diag_alt_pwm_dif_mv
			Cxx_thpl_diag_alt_pwm_fil_fac
			Cxx_thpl_diag_alt_pwm_t
			Cxx_thpl_diag_alt_pwm_tot_t
			Cxx_thpl_diag_fedg_dec
			Cxx_thpl_diag_fedg_inc
			Cxx_thpl_diag_max_thd
			Cxx_thpl_diag_redg_dec
			Cxx_thpl_diag_redg_inc
			Cxx_thpl_diag_redg_tot_dec
			Cxx_thpl_diag_redg_tot_inc
			Cxx_thpl_diag_tot_on_t
			Cxx_thpl_diag_vb_t
			Cxx_thpl_nr_1
			Cxx_thpl_nr_2
			Cxx_thpl_nr_3
			Cxx_thpl_vb_dif_thd
			Cxx_vb_fil_fac_neg
			Cxx_vb_fil_fac_pos
			Ctp_thpl_alt_pwm_diag
			Ctb_cf_conf_thpl
			Ctt_cf_conf_thpl
			Cbx_thpl_diag_ena
			Cxx_dfdec_unk_thpl2_chr
			Cxx_dfdec_unk_thpl3_chr
			Cxx_dfdec_unk_thpl4_chr
			Cxx_dfdec_unk_thpl_chr
			Cxx_dfinc_unk_thpl1_chr
			Cxx_dfinc_unk_thpl2_chr
			Cxx_dfinc_unk_thpl3_chr
			Cxx_dfinc_unk_thpl4_chr
			Cxx_dfinc_unk_thpl_chr
			Cxx_dfdec_unk_thpl1_chr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_thpl_1_cf
			Vbx_thpl_1_fail_fedg_stt
			Vbx_thpl_1_fail_stt
			Vbx_thpl_1_fedg_ena
			Vbx_thpl_1_redg_ena
			Vbx_thpl_2_cf
			Vbx_thpl_2_fail_fedg_stt
			Vbx_thpl_2_fail_stt
			Vbx_thpl_2_fedg_ena
			Vbx_thpl_2_redg_ena
			Vbx_thpl_3_cf
			Vbx_thpl_3_fail_fedg_stt
			Vbx_thpl_3_fail_stt
			Vbx_thpl_3_fedg_ena
			Vbx_thpl_3_redg_ena
			Vbx_thpl_4_cf
			Vbx_thpl_4_fail_fedg_stt
			Vbx_thpl_4_fail_stt
			Vbx_thpl_4_fedg_ena
			Vbx_thpl_4_redg_ena
			Vbx_thpl_cf_cdi
			Vbx_thpl_diag_alt_pwm_ena
			Vbx_thpl_diag_pwm_ena
			Vbx_thpl_fedg
			Vbx_thpl_ini_eprm
			Vbx_thpl_redg
			Vbx_thpl_tot_cf
			Vxx_thpl_diag_alt_pwm_dif_mv
			Vxx_thpl_fedg_lvl
			Vxx_thpl_nr_on
			Vxx_thpl_nr_on_ena
			Vxx_thpl_vb_dif
			Vxx_thpl_cnt_cf
			Vxx_thpl_lvl_cf
			Vbx_df_thpl_alt_pwm
			Vbx_ini_tout
			Vbx_df_thpl2_ena
			Vbx_df_thpl3_ena
			Vbx_df_thpl4_ena
			Vbx_df_thpl_ena
			Vbx_df_unk_thpl1_chr
			Vbx_df_unk_thpl2_chr
			Vbx_df_unk_thpl3_chr
			Vbx_df_unk_thpl4_chr
			Vbx_df_unk_thpl_chr
			Vbx_diag_ena_unk_thpl1_chr
			Vbx_diag_ena_unk_thpl2_chr
			Vbx_diag_ena_unk_thpl3_chr
			Vbx_diag_ena_unk_thpl4_chr
			Vbx_diag_ena_unk_thpl_chr
			Vbx_eng_ena
			Vxx_thpl_alt_pwm_dif
			Vxx_tout
			Vbx_df_thpl1_ena
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/begin FUNCTION
		OuCloCoo_Mdfanxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_mdf_min_dly
			Cxx_mdf_on_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_mdf1_cmd
			Vbx_mdf2_cmd
			Vbx_ac_mdf2_req
			Vbx_mdf1_cmd_dly
			Vbx_mdf2_cmd_dly
			Vbx_ac_mdf1_req
			Vxx_mdf_min_dly_cnt
			Vxx_mdf_min_dly_dt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/begin FUNCTION
		OuCloCoo_Paotxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_wpmp_tcr_oc
			Cxx_dfdec_wpmp_tcr_scg
			Cxx_dfinc_wpmp_tcr_scg
			Cxx_dfinc_wpmp_tcr_scw
			Cxx_wpmp_tcr_max_t
			Cxx_wpmp_tcr_max_tco_t
			Cxx_wpmp_tcr_tco_hys
			Cxx_wpmp_tcr_tco_thd
			Cxx_dfdec_wpmp_tcr_scw
			Cxx_dfdec_wpmp_tcr_blk
			Cxx_dfinc_wpmp_tcr_oc
			Cxx_dfinc_wpmp_tcr_blk
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_wpmp_tcr_cmd
			Vbx_wpmp_tcr_stop
			Vxx_wpmp_tco_tcr_dly
			Vxx_wpmp_tcr_dly
			Vbx_wpmp_tcr
			Vsx_wpmp_tcr
			Vbx_wpmp_tcr_pws
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/begin FUNCTION
		OuCloCoo_Tceauxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tco_sp
			Ctd_tco_7
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_tsta_ip_trs_l_mux
			Vxx_tco_sp_mux
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/begin FUNCTION
		OuDgoLmp
		""
	/begin SUB_FUNCTION
			OuDgoLmp_Milmgtx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/begin FUNCTION
		OuDgoLmp_Milmgtx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_mux_test_mil_dly
			Cxx_mux_test_rdn_mil_dly
			Cbx_mux_mil_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_mux_mil_req_1
			Vxx_mux_mil_req_2
			Vxx_mux_test_mil_dly
			Vxx_mux_test_rdn_mil_dly
			Vbx_aut_eng_mil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/begin FUNCTION
		OuTqoTqd
		""
	/begin SUB_FUNCTION
			OuTqoTqd_Trnstrs_xxxxxd
			OuTqoTqd_Tqrqstt_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/begin FUNCTION
		OuTqoTqd_Tqrqstt_xxxxxx
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_tq_req_ans
			Vbx_tq_req_stt_01
			Vbx_tq_req_stt_11
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/begin FUNCTION
		OuTqoTqd_Trnstrs_xxxxxd
		""
	/begin OUT_MEASUREMENT
			Vbx_tq_req_stt_10
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin FUNCTION
		PcCruCtl
		""
	/begin OUT_MEASUREMENT
			PcCruCtl_NVM.Vbx_cru_swi_NVM
			PcCruCtl_NVM.Vxx_cru_cmp_diag_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			PcCruCtl_Safetyx
			PcCruCtl_Servoxx
			PcCruCtl_Slarbxx
			PcCruCtl_Fslsvxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		PcCruCtl_Fslsvxx
		""
	/* ASAP2::Database : delete 'Vbx_fsl_svkl_act' */
	/* ASAP2::Database : delete 'Vxx_fsl_forc_ref' */
	/* ASAP2::Database : delete 'Vxx_fsl_svkl_acel_ref' */
	/* ASAP2::Database : delete 'Vxx_fsl_svkl_forc' */
	/* ASAP2::Database : delete 'Vxx_fsl_svkl_forc_ref' */
	/* ASAP2::Database : delete 'Vxx_fsl_svkl_i_cor' */
	/* ASAP2::Database : delete 'Vxx_fsl_svkl_i_cor_init' */
	/* ASAP2::Database : delete 'Vxx_fsl_svkl_p_cor' */
	/* ASAP2::Database : 8 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vbx_fsl_mstr
			Vxx_fsl_forc_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin FUNCTION
		PcCruCtl_Safetyx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_bgin_clu_fail_ccp_ena
			Cbx_bgin_clu_fail_co_ena
			Cbx_brk_fail_ccp_ena
			Cbx_brk_fail_co_ena
			Cbx_ena_brk_cru_swi_cfm
			Cbx_ena_clu_cru_swi_cfm
			Cxx_bgin_clu_fail_ccp_dly
			Cxx_bgin_clu_fail_co_dly
			Cxx_brk_fail_ccp_dly
			Cxx_brk_fail_co_dly
			Cxx_cru_forc_sp_dly
			Cxx_cru_forc_sp_thd
			Cxx_dfdec_bgin_clu_cmp
			Cxx_dfdec_brk_pdl_cmp
			Cxx_dfdec_cru_cmp
			Cxx_dfinc_bgin_clu_cmp
			Cxx_dfinc_brk_pdl_cmp
			Cxx_dfinc_cru_cmp
			Cxx_wf_bgin_clu_rams_dly
			Cxx_wf_brk_rams_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cru_cmp_bgin_clu
			Vbx_cru_cmp_forc_pres
			Vbx_cru_cmp_open_brk
			Vxx_cru_cmp_diag_new
			Vxx_cru_cmp_diag_prev
			Vxx_csl_forc_sp
			Vxx_cru_forc_sp
			Vxx_cru_sl_stt
			Vxx_cru_sl_stt_ip
			Vxx_cru_sl_vs_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin FUNCTION
		PcCruCtl_Servoxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_cru_sl_vs
			Ctp_dyn_forc
			Cbx_sl_max_i_cor
			Cxx_cru_cmf_cut_forc_dec
			Cxx_cru_min_forc
			Cxx_cru_ref_vs_acel_grd
			Cxx_cru_ref_vs_acel_ofs
			Cxx_cru_ref_vs_decl_grd
			Cxx_cru_ref_vs_decl_ofs
			Cxx_cru_sp_acel_grd
			Cxx_cru_sp_decl_grd
			Cxx_cru_sp_max_forc_inc
			Cxx_cru_svkl_ig
			Cxx_cru_svkl_max_i_cor
			Cxx_cru_svkl_min_i_cor
			Cxx_cru_svkl_pg
			Cxx_cru_svkl_vs_thd
			Cxx_sl_cmf_cut_forc_inc
			Cxx_sl_max_forc
			Cxx_sl_sp_max_forc_dec
			Cxx_sl_svkl_ig
			Cxx_sl_svkl_max_i_cor
			Cxx_sl_svkl_min_i_cor
			Cxx_sl_svkl_pg
			Cxx_sl_svkl_vs_thd
			Cxx_vh_wht
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cru_act
			Vbx_cru_mstr
			Vbx_cru_mstr_prev
			Vbx_cru_sl_svkl_act
			Vbx_csl_mstr
			Vxx_cru_fil_vs_ref
			Vxx_cru_fil_vs_ref_init
			Vxx_cru_fil_vs_ref_prev
			Vxx_cru_forc_sp_nom
			Vxx_cru_sl_dyn_forc_ini
			Vxx_cru_sl_fil_vs_ref
			Vxx_cru_sl_forc_ref
			Vxx_cru_sl_svkl_acel_ref
			Vxx_cru_sl_svkl_forc
			Vxx_cru_sl_svkl_forc_ref
			Vxx_cru_sl_svkl_ig
			Vxx_cru_sl_svkl_max_i_cor
			Vxx_cru_sl_svkl_min_i_cor
			Vxx_cru_sl_svkl_p_cor
			Vxx_cru_sl_svkl_pg
			Vxx_cru_sl_svkl_vs_i_cor
			Vxx_cru_sl_svkl_vs_i_cor_init
			Vxx_cru_sl_svkl_vs_i_cor_prev
			Vxx_cru_vs_ref_ofs
			Vxx_csl_forc_sp_nom
			Vxx_dyn_forc
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin FUNCTION
		PcCruCtl_Slarbxx
		""
	/begin OUT_MEASUREMENT
			Vbx_sl_mstr
			Vxx_sl_forc_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt
		""
	/begin OUT_MEASUREMENT
			PcCruSpt_NVM.Vxx_fsl_km_NVM
			PcCruSpt_NVM.Sxx_cru_dgn_eprm_imd_writ_ctr_NVM
			PcCruSpt_NVM.Vxx_max_vs_NVM
			PcCruSpt_NVM.Vxx_cru_fail_NVM
			PcCruSpt_NVM.Vxx_cru_sl_fail_NVM
			PcCruSpt_NVM.Vxx_cru_sl_dacn_sys_NVM
			PcCruSpt_NVM.Vbx_sli_buf_sf_NVM
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[0]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[1]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[2]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[3]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[4]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[5]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[6]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[7]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[8]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[9]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[10]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[11]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[12]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[13]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[14]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[15]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[16]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[17]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[18]
			PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[19]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[0]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[1]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[2]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[3]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[4]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[5]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[6]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[7]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[8]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[9]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[10]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[11]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[12]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[13]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[14]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[15]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[16]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[17]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[18]
			PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[19]
			PcCruSpt_RVLV2_NVM.Sxx_sli_brk_buf_NVM
			PcCruSpt_RVLV2_NVM.Sxx_sli_clu_buf_NVM
			PcCruSpt_RVLV2_NVM.Sxx_sli_cru_stt_buf_NVM
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[0]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[1]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[2]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[3]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[4]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[5]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[6]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[7]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[8]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[9]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[10]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[11]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[12]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[13]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[14]
			PcCruSpt_RVLV2_NVM.Sxx_sli_vs_buf_NVM[15]
			PcCruSpt_RVLV2_NVM.Vxx_crsh_dly_ctr_NVM
			PcCruSpt_RVLV2_NVM.Vxx_cru_dgn_diag_NVM
			PcCruSpt_RVLV2_NVM.Vbx_crsh_end_rec_eprm_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'PcCruSpt_Fslvsxx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			PcCruSpt_Dacaxxx
			PcCruSpt_Dgaddon
			PcCruSpt_Dsbccxx
			PcCruSpt_Schxxxx
			PcCruSpt_Setptxx
			PcCruSpt_Stflwxx
			PcCruSpt_Vsintxx
			PcCruSpt_Fslinxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt_Dacaxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_brk_det_dly
			Cxx_brk_min_decl_thd
			Cxx_cru_clu_navl_dly
			Cxx_dfdec_cru_sl_tot
			Cxx_dfinc_cru_sl_tot
			Cxx_sp_vs_dif_brk_det
			Cxx_sudn_brk_det_dly
			Cxx_sudn_brk_min_decl_thd
			Cxx_cru_brk_fail_dly
			Cxx_cru_brk_nok_dly
			Cxx_cru_clu_nok_dly
			Cxx_lih_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_brk_pdl_vld_fail
			Vbx_brk_pdl_vld_nok
			Vbx_cru_brk_det
			Vbx_cru_brk_det_sudn
			Vbx_cru_clu_abst_fil
			Vbx_cru_clu_navl_fil
			Vbx_gear_vld_nok_fail
			Vsx_cru_vld
			Vsx_sl_vld
			Vbx_diag_ena_cru
			Vbx_diag_ena_cru_sl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt_Dgaddon
		""
	/begin DEF_CHARACTERISTIC
			Cbx_cru_diag_add_on
			Cxx_cru_dgn_eprm_imd_writ_thr
			Cxx_togl_dly
			Cxx_togl_thr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_crsh_det
			Vbx_cru_dgn_eprm_writ_off
			Vbx_cru_dgn_eprm_writ_on
			Vbx_cru_diag_ena
			Vbx_cru_sl_dacn_bit0
			Vbx_cru_sl_dacn_bit1
			Vbx_ram_full
			Vbx_ram_full_prev
			Vbx_set_id_bit6
			Vbx_set_id_bit7
			Vxx_act_deact_id_buf_2
			Vxx_cru_act_deact_id
			Vxx_cru_act_deact_id_to_saved
			Vxx_cru_dsb_buf[0]
			Vxx_cru_dsb_buf[1]
			Vxx_cru_dsb_buf[2]
			Vxx_cru_dsb_buf[3]
			Vxx_cru_dsb_buf[4]
			Vxx_cru_dsb_buf[5]
			Vxx_cru_dsb_buf[6]
			Vxx_cru_dsb_buf[7]
			Vxx_cru_dsb_buf[8]
			Vxx_cru_dsb_buf[9]
			Vxx_cru_dsb_buf[10]
			Vxx_cru_dsb_buf[11]
			Vxx_cru_dsb_buf[12]
			Vxx_cru_dsb_buf[13]
			Vxx_cru_dsb_buf[14]
			Vxx_cru_dsb_buf[15]
			Vxx_cru_dsb_buf[16]
			Vxx_cru_dsb_buf[17]
			Vxx_cru_dsb_buf[18]
			Vxx_cru_dsb_buf[19]
			Vxx_cru_dist_buf[0]
			Vxx_cru_dist_buf[1]
			Vxx_cru_dist_buf[2]
			Vxx_cru_dist_buf[3]
			Vxx_cru_dist_buf[4]
			Vxx_cru_dist_buf[5]
			Vxx_cru_dist_buf[6]
			Vxx_cru_dist_buf[7]
			Vxx_cru_dist_buf[8]
			Vxx_cru_dist_buf[9]
			Vxx_cru_dist_buf[10]
			Vxx_cru_dist_buf[11]
			Vxx_cru_dist_buf[12]
			Vxx_cru_dist_buf[13]
			Vxx_cru_dist_buf[14]
			Vxx_cru_dist_buf[15]
			Vxx_cru_dist_buf[16]
			Vxx_cru_dist_buf[17]
			Vxx_cru_dist_buf[18]
			Vxx_cru_dist_buf[19]
			Vxx_sli_brk_buf
			Vxx_sli_clu_buf
			Vxx_sli_cru_stt_buf
			Vxx_sli_vs_buf[0]
			Vxx_sli_vs_buf[1]
			Vxx_sli_vs_buf[2]
			Vxx_sli_vs_buf[3]
			Vxx_sli_vs_buf[4]
			Vxx_sli_vs_buf[5]
			Vxx_sli_vs_buf[6]
			Vxx_sli_vs_buf[7]
			Vxx_sli_vs_buf[8]
			Vxx_sli_vs_buf[9]
			Vxx_sli_vs_buf[10]
			Vxx_sli_vs_buf[11]
			Vxx_sli_vs_buf[12]
			Vxx_sli_vs_buf[13]
			Vxx_sli_vs_buf[14]
			Vxx_sli_vs_buf[15]
			Vxx_togl_ctr
			Vxx_togl_tmr
			Vxx_vh_dist_buf_2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt_Dsbccxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_cru_eng_dsb_wal_1_req_cfm
			Cbx_sl_eng_dsb_wal_1_req_cfm
			Cbx_cru_sl_eng_dsb_vld_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cru_eng_dsb
			Vbx_cru_eng_dsb_sys
			Vbx_sl_eng_dsb
			Vbx_sl_eng_dsb_sys
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		PcCruSpt_Fslinxx
		""
	/begin OUT_MEASUREMENT
			Vxx_fsl_max_vs_sp_kmh
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt_Schxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fsl_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fsl_cfm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt_Setptxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ena_reg_decl_resu_on
			Cxx_cru_ovs_warn_thd
			Cxx_cru_ovs_warn_thd_mph
			Cxx_cru_sl_long_sp_dec_t
			Cxx_cru_sl_long_sp_inc_t
			Cxx_cru_sl_sp_inc_t
			Cxx_cru_sl_warn_dly
			Cxx_sl_ovs_warn_thd
			Cxx_sl_ovs_warn_thd_mph
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cru_sl_warn_prev
			Vbx_cru_sl_warn_raw
			Vxx_cru_sl_driv_vs_sp
			Vxx_cru_sl_driv_vs_sp_kmh
			Vxx_cru_sl_sp_inc_dec_dly_cnt
			Vxx_cru_sl_stt_ip_nom
			Vxx_cru_sl_vs_sp_nom
			Vbx_cru_sl_warn
			Vbx_vs_clos_spt_lamp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt_Stflwxx
		""
	/begin OUT_MEASUREMENT
			Vbx_cru_cmf_cut
			Vbx_sta_swi_act
			Vsx_sl_stt
			Vxx_cru_sl_dacn
			Vxx_cru_sl_dacn_prev
			Vxx_cru_sl_dacn_sys_prev
			Vxx_cru_sl_stt_nom
			Vsx_cru_stt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin FUNCTION
		PcCruSpt_Vsintxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_cru_abst_dspl_vs_dly
			Cxx_cru_abst_vs_dly
			Cxx_cru_long_step
			Cxx_cru_long_step_mph
			Cxx_cru_nok_vs_dly
			Cxx_cru_sl_fil_acel_fac
			Cxx_cru_sl_fil_vs_fac
			Cxx_cru_sl_max_vs
			Cxx_cru_sl_max_vs_mph
			Cxx_cru_sl_min_vs
			Cxx_cru_sl_min_vs_mph
			Cxx_cru_sl_no_efv_vs_thd
			Cxx_cru_sl_no_efv_vs_thd_mph
			Cxx_cru_sl_smal_step
			Cxx_cru_sl_smal_step_mph
			Cxx_cru_vs_secu_min
			Cxx_cru_vs_sp_rat
			Cxx_dfdec_cru_vs_cmp
			Cxx_dfinc_cru_vs_cmp
			Cxx_dspl_vs_secu_fac
			Cxx_dspl_vs_secu_ofs
			Cxx_dspl_vs_secu_thd
			Cxx_sl_long_step
			Cxx_sl_long_step_mph
			Cxx_vs_clos_spt_lamp_off_thd
			Cxx_vs_clos_spt_lamp_off_thd_mph
			Cxx_vs_clos_spt_lamp_on_thd
			Cxx_vs_clos_spt_lamp_on_thd_mph
			Cbx_fsl_ena_cfm
			Cbx_cru_sl_vs_cmp_prmt
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cru_sl_kmh_mph_cge
			Vbx_cru_sl_oor_vs
			Vbx_cru_smal_vs_sp_rat
			Vbx_df_cru_vs_cmp
			Vbx_dspl_vs_abst_fil
			Vbx_dspl_vs_navl_fil
			Vbx_vs_abst_fil
			Vbx_vs_navl_fil
			Vbx_vs_nok
			Vxx_cru_sl_acel
			Vxx_cru_sl_long_step
			Vxx_cru_sl_max_vs
			Vxx_cru_sl_min_vs
			Vxx_cru_sl_no_efv_vs_thd
			Vxx_cru_sl_raw_vs
			Vxx_cru_sl_smal_step
			Vxx_cru_sl_vs
			Vxx_cru_sl_vs_kmh
			Vxx_vs_clos_spt_lamp_off_thd
			Vxx_vs_clos_spt_lamp_on_thd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin FUNCTION
		PcDrCRds
		""
	/begin SUB_FUNCTION
			PcDrCRds_Fstqdxx_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin FUNCTION
		PcDrCRds_Fstqdxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_gear_fs
			Ctb_tq_dif_tco
			Ctb_tq_dif_vs
			Ctp_tq_dif_tco_fac
			Ctp_tq_res
			Ctp_vh_wht_eq
			Cxx_end_sip_ena_dly
			Cxx_pow_r_fil
			Cxx_tq_dif_acel_dec_fil
			Cxx_tq_dif_acel_inc_fil
			Cxx_tq_dif_degr_fac
			Cxx_tq_dif_esti_tqe_fil
			Cxx_tq_dif_fil
			Cxx_whl_rad
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fil_rst
			Vbx_frz
			Vbx_sip_frz
			Vsx_pow_r_vld
			Vsx_tq_dif_vld
			Vxx_dly_pow_r
			Vxx_dly_tq_dif
			Vxx_free_shf_acel
			Vxx_gear_lim_tq_dif
			Vxx_pow_r
			Vxx_pow_r_fil
			Vxx_pow_r_raw
			Vxx_tq_dif
			Vxx_tq_dif_esti_tqe_fil
			Vxx_tq_dif_fil
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin FUNCTION
		PcDrcDrs
		""
	/begin SUB_FUNCTION
			PcDrcDrs_Dynmoxx
			PcDrcDrs_Drstyxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin FUNCTION
		PcDrcDrs_Drstyxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_agb_driv_spt_fac_cfm
			Cbx_driv_sp_mv_upd_pdl_thd_cfm
			Cbx_mnl_driv_spt_fac_cfm
			Ctb_driv_sp_mv_fil_fac_vs
			Ctb_driv_spt_fac_driv_sp_mv
			Ctb_driv_spt_fac_driv_sp_grd_mv
			Cmp_driv_spt_fac_map
			Ctb_driv_sp_mv_fil_fac_pwt_sp
			Ctb_fast_driv_spt_fac_pdl
			Cmp_driv_sp_mv_fil_fac
			Cmp_fast_driv_spt_fac
			Ctb_fast_driv_spt_fac_vs
			Ctb_driv_sp_grd_ref_vs
			Ctp_driv_sp_grd_ref
			Cxx_acel_pdl_dif_t
			Cxx_acel_pdl_grd_abs_fil_fac
			Cxx_driv_sp_100_pow
			Cxx_driv_sp_grd_mv_down_fil_fac
			Cxx_driv_sp_grd_mv_frz_fil_fac
			Cxx_driv_sp_grd_mv_upd_h_thd
			Cxx_driv_sp_grd_mv_upd_l_thd
			Cxx_driv_sp_grd_mv_upd_vs_thd
			Cxx_driv_sp_mv_upd_pdl_thd
			Cxx_driv_sp_mv_upd_vs_thd
			Cxx_driv_sp_pow_ref
			Cxx_driv_spt_fac_fail_slop
			Cxx_fast_driv_spt_fac_kd
			Cxx_mnl_driv_spt_fac
			Cxx_fast_driv_spt_fac_dec_slop
			Cxx_driv_sp_grd_mv_up_fil_fac
			Cxx_driv_sp_mv_frz_fil_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_driv_sp_grd_mv_upd_ena
			Vbx_driv_sp_mv_upd_ena
			Vxx_mdl_driv_spt_fac
			Vxx_acel_pdl_grd_abs
			Vxx_acel_pdl_grd_abs_fil
			Vxx_driv_sp
			Vxx_driv_sp_grd
			Vxx_acel_pdl_dif
			Vxx_driv_sp_grd_mv
			Vxx_driv_sp_mv
			Vxx_fast_driv_spt_fac
			Vxx_slow_driv_spt_fac
			Vxx_driv_sp_vs_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin FUNCTION
		PcDrcDrs_Dynmoxx
		""
	/begin OUT_MEASUREMENT
			Vxx_driv_spt_fac
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo
		""
	/begin SUB_FUNCTION
			PcDrcOpo_Fsapgxx_xxxxxx
			PcDrcOpo_Fsapmxx_xxxxxx
			PcDrcOpo_Fscurxx_xxxxxx
			PcDrcOpo_Fsdisxx_xxxxxx
			PcDrcOpo_Fsdlyxx_xxxxxx
			PcDrcOpo_Fsfofxx_xxxxxx
			PcDrcOpo_Fsfonxx_xxxxxx
			PcDrcOpo_Fsgihxx_xxxxxx
			PcDrcOpo_Fslawxx_xxxxxx
			PcDrcOpo_Fslslxx_xxxxxx
			PcDrcOpo_Fspfzxx_xxxxxx
			PcDrcOpo_Schxxxx_xxxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fsapgxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_apmp
			Ctp_apmp_max_pow
			Ctp_n_lim_apmp_down_shf
			Cxx_down_shf_pow_rat
			Cxx_n_lim_apmp_down_shf_hys
			Cxx_max_pow_fs
			Cxx_pow_apmp_hys
			Cxx_up_shf_pow_rat
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_apmp_down_shf
			Vbx_apmp_up_shf
			Vxx_apmp_gear
			Vxx_gear_lim
			Vxx_gear_lim_inc
			Vxx_max_avl_pow
			Vxx_max_avl_pow_inc
			Vxx_max_avl_pow_rat
			Vxx_n_gear
			Vxx_n_gear_inc
			Vxx_pow_r_req_down
			Vxx_pow_r_req_up
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fsapmxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_apmp_ena_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_apmp_free_shf_mod
			Vxx_apmp_gear_sel
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fscurxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cmp_cur_tra_acel_thd
			Ctb_cur_spd
			Ctp_cur_dly
			Cxx_cur_tra_acel_hys
			Cxx_tra_acel_cur_fil
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_up_shf_blk_cur
			Vxx_cur_dly
			Vxx_cur_tra_acel_thd
			Vxx_t_cur
			Vxx_t_max_cur
			Vxx_tra_acel_abs
			Vxx_tra_acel_abs_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fsdisxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_sta_dspl_arw_up_dly
			Cxx_max_dspl_arw_cyc_nr
			Cxx_max_dspl_arw_down_dly
			Cxx_max_dspl_arw_up_dly
			Cxx_min_dspl_arw_down_dly
			Cxx_min_dspl_arw_up_dly
			Cxx_rest_dspl_arw_down_dly
			Cxx_rest_dspl_arw_up_dly
			Cxx_sta_dspl_arw_down_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_arw_down
			Vbx_arw_down_raw
			Vbx_arw_up
			Vbx_arw_up_raw
			Vsx_free_shf_dspl
			Vxx_ctr_dspl_up
			Vxx_min_dspl_arw_up_dly
			Vxx_sta_dspl_arw_up_dly
			Vxx_t_max_arw_down
			Vxx_t_max_arw_up
			Vxx_t_min_arw_down
			Vxx_t_min_arw_up
			Vxx_t_rest_arw_down
			Vxx_t_rest_arw_up
			Vxx_t_sta_arw_down
			Vxx_t_sta_arw_up
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fsdlyxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_dly_ena_cfm
			Ctp_gear_pdl_no_seq_dly
			Cxx_down_shf_no_seq_dly
			Cxx_driv_ant_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_dly_ini
			Vsx_no_seq_free_shf_mod
			Vsx_stt_dly
			Vxx_fast_off_gear_sel_bk
			Vxx_gear_bk
			Vxx_no_seq_gear_sel
			Vxx_t_ant
			Vxx_t_no_seq_down_shf
			Vxx_t_no_seq_up_shf
			Vxx_up_shf_no_seq_dly
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fsfofxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fast_off_ena_cfm
			Cbx_fast_off_kd_ena_cfm
			Cmp_fast_off_law_pdl_grd_dly
			Ctb_fast_off_pdl_grd
			Ctb_law
			Ctp_fast_off_kd_n_thd
			Ctp_fast_off_no_pdl_dly
			Cxx_fast_off_kd_pdl_thd
			Cxx_free_shf_no_pdl_fast_off
			Cxx_pdl_grd_in_neg_thd
			Cxx_pdl_grd_out_neg_thd
			Cxx_up_shf_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_fast_off_free_shf_mod
			Vsx_stt_fast_off
			Vxx_dly_frz_gear_sel
			Vxx_fast_off_dly
			Vxx_fast_off_gear_sel
			Vxx_fast_off_kd_n_thd
			Vxx_fast_off_max_dly
			Vxx_fast_off_no_pdl_dly
			Vxx_t_fast_off
			Vxx_t_no_pdl
			Vxx_t_up_shf_dly
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fsfonxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fast_on_ena_cfm
			Cxx_free_shf_no_pdl_fast_on
			Cxx_pdl_fast_on_kd_thd
			Cxx_pdl_grd_fast_on_thd
			Cxx_pdl_grd_fil
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_fast_on_free_shf_mod
			Vsx_stt_fast_on
			Vxx_dly_gear_sel
			Vxx_fast_on_gear_sel
			Vxx_pdl_grd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fsgihxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_cru_blk_cfm
			Cbx_cur_ena_cfm
			Cbx_down_shf_blk_cur_cfm
			Cbx_gear_blk_cfm
			Cbx_wal_1_req_fs_cfm
			Cxx_max_decl
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_free_shf_dft
			Vsx_frz_free_shf_mod
			Vxx_frz_gear_sel
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fslawxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_brk_ass_ena_cfm
			Ctb_down_shf_pdl
			Ctb_up_shf_pdl
			Ctp_brk_ass_fac
			Ctp_dhil_n_up_shf_in_thd
			Ctp_dhil_n_up_shf_out_thd
			Ctp_dhil_vs_down_shf_thd
			Ctp_law_eco_1_2
			Ctp_law_eco_2_1
			Ctp_law_eco_2_3
			Ctp_law_eco_3_2
			Ctp_law_eco_3_4
			Ctp_law_eco_4_3
			Ctp_law_eco_4_5
			Ctp_law_eco_5_4
			Ctp_law_eco_5_6
			Ctp_law_eco_6_5
			Ctp_law_uhil_1_2
			Ctp_law_uhil_2_1
			Ctp_law_uhil_2_3
			Ctp_law_uhil_3_2
			Ctp_law_uhil_3_4
			Ctp_law_uhil_4_3
			Ctp_law_uhil_4_5
			Ctp_law_uhil_5_4
			Ctp_law_uhil_5_6
			Ctp_law_uhil_6_5
			Ctp_law_wup_cata_1_2
			Ctp_law_wup_cata_2_1
			Ctp_law_wup_cata_2_3
			Ctp_law_wup_cata_3_2
			Ctp_law_wup_cata_3_4
			Ctp_law_wup_cata_4_3
			Ctp_law_wup_cata_4_5
			Ctp_law_wup_cata_5_4
			Ctp_law_wup_cata_5_6
			Ctp_law_wup_cata_6_5
			Ctp_law_xurb_1_2
			Ctp_law_xurb_2_1
			Ctp_law_xurb_2_3
			Ctp_law_xurb_3_2
			Ctp_law_xurb_3_4
			Ctp_law_xurb_4_3
			Ctp_law_xurb_4_5
			Ctp_law_xurb_5_4
			Ctp_law_xurb_5_6
			Ctp_law_xurb_6_5
			Ctp_min_vs_decl
			Ctp_v1000
			Cxx_acel_in_brk_ass_thd
			Cxx_acel_out_brk_ass_thd
			Cxx_free_shf_no_pdl
			Cxx_free_shf_no_pdl_brk_ass
			Cxx_gear_max
			Cxx_lg_acel_law_fil
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_forc_gear_1
			Vsx_law_free_shf_mod
			Vsx_stt_dhil
			Vxx_ant_vs
			Vxx_dhil_gear_sel
			Vxx_dhil_n_up_shf_in_thd
			Vxx_dhil_n_up_shf_out_thd
			Vxx_dhil_vs_down_shf_thd
			Vxx_gear_sel
			Vxx_law_gear_sel
			Vxx_n_dhil
			Vxx_vs_thd_1_2
			Vxx_vs_thd_2_1
			Vxx_vs_thd_2_3
			Vxx_vs_thd_3_2
			Vxx_vs_thd_3_4
			Vxx_vs_thd_4_3
			Vxx_vs_thd_4_5
			Vxx_vs_thd_5_4
			Vxx_vs_thd_5_6
			Vxx_vs_thd_6_5
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fslslxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dhil_flat_thd
			Cxx_flat_dhil_thd
			Cxx_flat_uhil_thd
			Cxx_law_sel_cfm
			Cxx_mv_vs_dec_fil
			Cxx_mv_vs_inc_fil
			Cxx_n_run_thd
			Cxx_tco_thd
			Cxx_uhil_flat_thd
			Cxx_vs_eco_xurb_thd
			Cxx_vs_xurb_eco_thd
			Cxx_wup_cata_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_out_tco
			Vbx_sta_tco_ena
			Vbx_wup_cata_dsb
			Vbx_wup_cata_ena
			Vsx_law_sel
			Vsx_load_lvl
			Vsx_road_typ
			Vxx_tco_ctr
			Vxx_vs_mv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Fspfzxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_pdl_cru_max_lim
			Cxx_pdl_cru_min_lim
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_dly_driv_pwt_sp_100
			Vxx_driv_pwt_sp_100
			Vxx_free_shf_pdl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin FUNCTION
		PcDrcOpo_Schxxxx_xxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_free_shf_dsb_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_free_shf_dsb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/begin FUNCTION
		PcDrcTko
		""
	/begin SUB_FUNCTION
			PcDrcTko_Tkofxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/begin FUNCTION
		PcDrcTko_Tkofxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tkof_ass_driv_spt_fac_cfm
			Cbx_tkof_ass_ena_gear_cfm
			Ctb_tkof_amp
			Ctb_tkof_ass_h_vs_mv
			Ctb_tkof_ass_l_vs_mv
			Ctb_tkof_tenv
			Cxx_tkof_ass_h_vs_mv_min
			Cxx_tkof_ass_h_vs_mv_t
			Cxx_tkof_ass_l_vs_mv_max
			Cxx_tkof_ass_l_vs_mv_min
			Cxx_tkof_ass_l_vs_mv_t_down
			Cxx_tkof_ass_l_vs_mv_t_up
			Cxx_tkof_ass_slop_swi
			Cxx_tkof_spt_inc
			Cxx_tkof_spt_pdl_grd_cdn
			Cxx_tkof_spt_pdl_rat_cdn
			Cxx_tkof_spt_pdl_rat_grd_cdn
			Cxx_tkof_spt_slop_dec
			Cxx_tkof_spt_vs_max
			Cxx_tkof_spt_vs_min
			Ctp_tkof_amp
			Ctp_tkof_ass_h_vs_mv
			Ctp_tkof_ass_l_vs_mv
			Ctp_tkof_tenv
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_tkof_ass_spt_pdl_cdn
			Vxx_tkof_ass_h_vs_mv
			Vxx_tkof_ass_h_vs_mv_fac
			Vxx_tkof_ass_l_vs_mv
			Vxx_tkof_ass_l_vs_mv_fac
			Vxx_tkof_ass_mv_vs_fac
			Vxx_tkof_ass_spt_pdl_fac
			Vxx_tkof_ass_vs
			Vxx_tkof_tenv_amp_fac
			Vxx_tkof_ass_fac
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin FUNCTION
		PcDrvDit
		""
	/begin SUB_FUNCTION
			PcDrvDit_Pedlhxx
			PcDrvDit_Pedfmxx
			PcDrvDit_Drtqexx
			PcDrvDit_Drarbxx
			PcDrvDit_Ditcfxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin FUNCTION
		PcDrvDit_Ditcfxx
		""
	/begin OUT_MEASUREMENT
			Vbx_acel_pdl_lih_min_spc_cdn
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin FUNCTION
		PcDrvDit_Drarbxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_min_max_forc_vs
			Cxx_no_driv_pwt_sp_hys
			Cxx_no_driv_pwt_sp_thd
			Ctp_max_forc
			Ctp_min_forc
			Cxx_no_virt_driv_pwt_sp_hys
			Cxx_no_virt_driv_pwt_sp_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_no_driv_pwt_sp
			Vbx_virt_driv_on
			Vsx_driv_pwt_sp_vld
			Vxx_acc_pwt_sp
			Vxx_cru_pwt_sp
			Vxx_driv_pwt_sp
			Vxx_sdl_pwt_sp
			Vxx_sl_pwt_sp
			Vxx_max_forc
			Vxx_min_forc
			Vxx_acel_pdl_forc_sp
			Vbx_cru_acc_virt_driv_on
			Vxx_arb_driv_pwt_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin FUNCTION
		PcDrvDit_Drtqexx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ref_max_pow_cfm
			Ctb_driv_tqe_map_n
			Ctb_driv_tqe_map_pwt_sp
			Cxx_ref_max_pow
			Ctb_min_driv_tqe_pwt_sp
			Cmp_driv_tqe_map
			Cmp_min_driv_tqe_map
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_driv_tqe_sp
			Vxx_main_driv_tqe_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin FUNCTION
		PcDrvDit_Pedfmxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_acel_pdl_fmt_mnl_cfm
			Ctb_acel_pdl_fmt
			Ctp_acel_pdl_fmt_1
			Ctp_acel_pdl_fmt_2
			Cxx_acel_pdl_fmt_rvr_fac
			Ctb_acel_pdl_fmt_fac_driv
			Ctb_acel_pdl_fmt_tkof_fac_driv
			Ctb_acel_pdl_fmt_fac_vs
			Ctb_acel_pdl_fmt_tkof_fac_vs
			Cmp_acel_pdl_fmt_fac
			Cmp_acel_pdl_fmt_tkof_fac
			Cxx_acel_pdl_fmt_mnl_fac
			Cxx_pdl_fmt_fac_slop_swi_down
			Cxx_pdl_fmt_fac_slop_swi_up
			Cxx_tkof_cdn_vs_max
			Cxx_tkof_stop_vs
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_acel_pdl_pwt_sp_vld
			Vxx_acel_pdl_fmt_fac
			Vxx_acel_pdl_pwt_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin FUNCTION
		PcDrvDit_Pedlhxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_acel_pdl_lvl_cfm
			Cxx_acel_pdl_lih_hys_n_l
			Cxx_acel_pdl_lih_hys_vs_h
			Cxx_acel_pdl_lih_hys_vs_l
			Cxx_acel_pdl_lih_max_vs
			Cxx_acel_pdl_lih_min_l
			Cxx_acel_pdl_lih_n_ig
			Cxx_acel_pdl_lih_n_pg
			Cxx_acel_pdl_lih_n_sp_srs
			Cxx_acel_pdl_lih_n_tqe_h
			Cxx_acel_pdl_lih_slop_h1
			Cxx_acel_pdl_lih_slop_h2
			Cxx_acel_pdl_lih_slop_n_h
			Cxx_acel_pdl_lih_slop_vs
			Cxx_acel_pdl_lih_vs_ig
			Cxx_acel_pdl_lih_vs_pg
			Cxx_acel_pdl_lih_vs_rvr
			Cxx_acel_pdl_lih_vs_sp
			Cxx_acel_pdl_lih_vs_tqe_h
			Cxx_acel_pdl_lvl_tqe_thd
			Cxx_acel_pdl_trs_slop_neg
			Cxx_acel_pdl_trs_slop_pos
			Cxx_max_pow
			Ctp_acel_pdl_lih_hys_n_h
			Ctp_acel_pdl_lih_n_sp
			Cxx_acel_pdl_lih_n_sp_bpk_on
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_acel_pdl_lih_act
			Vbx_acel_pdl_lih_dft_act
			Vbx_acel_pdl_lih_dft_prev
			Vbx_acel_pdl_lih_i_rst
			Vbx_acel_pdl_lih_min_cdn
			Vbx_acel_pdl_lih_n_i_frz
			Vbx_acel_pdl_lih_n_tqe_h
			Vbx_acel_pdl_lih_n_tqe_l
			Vbx_acel_pdl_lih_reg_swi
			Vbx_acel_pdl_lih_sp_cdn
			Vbx_acel_pdl_lih_vs_i_frz
			Vbx_acel_pdl_lih_vs_p_rst
			Vbx_acel_pdl_lih_vs_tqe_h
			Vbx_acel_pdl_lih_vs_tqe_l
			Vxx_acel_pdl_lih_n_dif
			Vxx_acel_pdl_lih_n_i
			Vxx_acel_pdl_lih_n_sp
			Vxx_acel_pdl_lih_n_tqe
			Vxx_acel_pdl_lih_pwt
			Vxx_acel_pdl_lih_pwt_load
			Vxx_acel_pdl_lih_pwt_sp
			Vxx_acel_pdl_lih_tqe_sp
			Vxx_acel_pdl_lih_vs_dif
			Vxx_acel_pdl_lih_vs_i
			Vxx_acel_pdl_lih_vs_sp
			Vxx_acel_pdl_lih_vs_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin FUNCTION
		PcPajCtl
		""
	/begin SUB_FUNCTION
			PcPajCtl_Ajmodxx
			PcPajCtl_Ajspvxx
			PcPajCtl_Estixxx
			PcPajCtl_Spccdxx
			PcPajCtl_Spcpaxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin FUNCTION
		PcPajCtl_Ajmodxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_ajs_modu_stt_cfm
			Cbx_ajs_slk_td_cfm
			Ctb_ajs_tq_fac
			Cxx_ajs_modu_slk_fil_t1_acel
			Cxx_ajs_modu_slk_fil_t1_decl
			Cxx_ajs_modu_t1_decl_dt_modu
			Cxx_ajs_modu_t1_decl_dt_open
			Cxx_ajs_modu_t1_dt_clos_max
			Cxx_ajs_modu_t1_dt_ini
			Cxx_ajs_modu_td_decl_dt_modu
			Cxx_ajs_modu_td_decl_dt_open
			Cxx_ajs_modu_td_dt_ini
			Cxx_ajs_slk_act_ctr
			Cmp_ajs_modu_t1_decl_dt_clos
			Cmp_ajs_modu_td_acel_dt_clos
			Cmp_ajs_modu_t1_acel_driv_fac
			Cmp_ajs_modu_td_acel_driv_fac
			Cmp_ajs_modu_td_decl_dt_clos
			Cmp_ajs_modu_td_decl_driv_fac
			Cxx_ajs_modu_vs_thd_on
			Cxx_ajs_n_mv_dft
			Cmp_ajs_modu_t1_acel_dt_clos
			Cmp_ajs_modu_t1_decl_driv_fac
			Cmp_ajs_decl_slk_dly_t1
			Cmp_ajs_acel_slk_dly_t1_fac
			Cmp_ajs_decl_slk_dly_t1_fac
			Cmp_ajs_acel_slk_t1_ini_max
			Cmp_ajs_decl_slk_t1_ini_max
			Cmp_ajs_acel_slk_t1_ini_max_fac
			Cmp_ajs_decl_slk_t1_ini_max_fac
			Cmp_ajs_acel_slk_dly_t1
			Cxx_ajs_slk_td_ini_fac
			Ctb_ajs_modu_tkof_spt_fac
			Ctp_ajs_modu_t1_tkof_dt_open
			Cxx_ajs_modu_vs_thd_off
			Cxx_ajs_modu_tkof_vs_thd
			Cxx_ajs_modu_t1_fast_cor
			Cxx_ajs_modu_td_fast_cor
			Cxx_ajs_modu_loss_fil_cut_thd
			Ctb_ajs_modu_n
			Ctb_ajs_drag_tq_fac
			Ctp_ajs_modu_td_tkof_dt_open
			Ctp_ajs_drag_t1_dly
			Cbx_ajs_dt_slk_cfm
			Cbx_ajs_modu_td_dec_cfm
			Ctp_ajs_modu_t1_acel_dt_modu
			Ctp_ajs_modu_t1_acel_dt_open
			Ctp_ajs_modu_td_acel_dt_modu
			Ctp_ajs_modu_td_acel_dt_open
			Cmp_ajs_modu_t1_acel_tql_fac
			Cmp_ajs_modu_td_acel_tql_fac
			Cmp_ajs_modu_t1_decl_tql_fac
			Cmp_ajs_modu_td_decl_tql_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_ajs_modu_stt_para
			Vxx_ajs_modu_t1
			Vxx_ajs_modu_t1_acel
			Vxx_ajs_modu_t1_acel_dt_clos
			Vxx_ajs_modu_t1_decl_fac
			Vxx_ajs_modu_td
			Vxx_ajs_modu_td_acel
			Vxx_ajs_modu_td_acel_fac
			Vxx_ajs_modu_td_decl
			Vxx_ajs_modu_td_decl_fac
			Vxx_ajs_modu_tqe_sp_fil
			Vxx_ajs_slk_dly_t1
			Vxx_ajs_slk_t1_ini_max
			Vxx_ajs_modu_td_decl_dt_clos
			Vxx_ajs_modu_tqe_tgt
			Vxx_ajs_modu_tqe_sp
			Vxx_ajs_modu_t1_sp
			Vxx_ajs_modu_t1_tgt
			Vxx_ajs_modu_td_sp
			Vxx_ajs_modu_td_tgt
			Vxx_ajs_modu_t1_acel_fac
			Vxx_ajs_modu_n_mv
			Vxx_ajs_modu_tqe_tgt_fil
			Vbx_ajs_modu_stt_cut
			Vbx_ajs_modu_tkof_ena
			Vxx_ajs_modu_t1_decl_dt_clos
			Vxx_ajs_modu_t1_acel_dt_open
			Vxx_ajs_modu_td_acel_dt_clos
			Vxx_ajs_modu_td_acel_dt_open
			Vbx_ajs_modu_loss_fil_cut
			Vxx_ajs_modu_t1_decl
			Vxx_ajs_modu_t1_bfr_drag
			Vxx_ajs_modu_t1_acel_dt_modu
			Vxx_ajs_modu_td_acel_dt_modu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin FUNCTION
		PcPajCtl_Ajspvxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_dt_tq_rat_grip_cfm
			Csx_spv_tq_rat_drv_cfm
			Ctb_ajs_driv_tq_drv
			Ctb_ajs_gear_rat
			Cxx_ajs_decl_tq_thd
			Cxx_ajs_dt_grip_rat_open
			Ctp_ajs_dt_gear_tq_rat
			Ctp_ajs_gear_rat
			Ctp_ajs_spv_driv_tq_drv
			Cbx_ajs_spv_stt_cfm
			Ctp_ajs_slk_tqe_off_decl
			Cxx_ajs_acel_tq_thd
			Cxx_ajs_slk_drv_tq_thd_on
			Cxx_ajs_slk_drv_tq_thd_off
			Cxx_ajs_spv_slk_decl_dly
			Cxx_ajs_spv_driv_tq_t1_fil
			Cxx_ajs_spv_tq_rat_t1_fil
			Cbx_ajs_spv_cut_cfm
			Cbx_ajs_spv_grd_cfm
			Cbx_ajs_tqe_slk_cfm
			Ctb_ajs_spv_n
			Ctp_ajs_spv_fast_cor_dly_fac
			Cxx_ajs_driv_pwt_sp_fil
			Cxx_ajs_spv_n_mv_thd
			Cxx_ajs_spv_tco_thd
			Cxx_ajs_spv_tq_drv_hys
			Cxx_ajs_spv_tq_drv_thd
			Cxx_ajs_spv_tqe_tgt_thd
			Cxx_ajs_spv_wait_dly
			Cxx_ajs_driv_pwt_sp_grd_hys
			Cxx_ajs_driv_pwt_sp_grd_thd
			Cbx_ajs_fast_cor_cfm
			Cbx_ajs_no_drag_cfm
			Ctb_ajs_spv_tq_fac
			Ctp_ajs_slk_tqe_off_acel
			Ctp_ajs_drag_acel_tq_diff_thd
			Ctp_ajs_drag_decl_tq_diff_thd
			Cxx_ajs_driv_pwt_sp_thd
			Cxx_ajs_drag_pwt_sp_thd
			Cxx_ajs_dt_grip_rat_clos
			Cxx_ajs_drag_tq_drv_hys
			Cxx_ajs_drag_tq_drv_thd
			Cbx_ajs_dt_open_slk_cfm
			Cxx_ajs_spd_diff_thd_off_decl
			Cxx_ajs_spd_diff_thd_off_acel
			Ctb_ajs_spv_drag_tq_fac
			Ctb_ajs_slk_tq_fac
			Ctp_ajs_coup_grip_rat
			Ctp_ajs_spd_diff_thd_on_decl
			Cmp_ajs_spv_fast_cor_dly
			Cmp_ajs_spd_diff_thd_on_acel
			Ctb_ajs_aux_tql
			Cmp_ajs_slk_tqe_on_acel
			Cmp_ajs_slk_tqe_on_decl
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ajs_acel_decl_stt
			Vbx_ajs_spv_stt_cut
			Vbx_vs_n_rat_fil_on
			Vsx_ajs_dt_tq_rat_vld
			Vsx_ajs_spv_stt_para
			Vxx_ajs_coup_grip_rat
			Vxx_ajs_driv_tq_drv
			Vxx_ajs_dt_grip_rat
			Vxx_ajs_gear_rat_n
			Vxx_ajs_spv_driv_tq_drv
			Vxx_ajs_spv_driv_tq_fac
			Vxx_ajs_spv_driv_tq_rat
			Vxx_ajs_dt_tq_rat
			Vbx_ajs_slk_decl_on
			Vbx_ajs_slk_decl_off
			Vbx_ajs_slk_on_prev
			Vbx_ajs_slk_tqe_decl_out
			Vbx_ajs_fast_cor_on
			Vbx_ajs_pdl_cdn_on
			Vbx_ajs_tq_cdn_on
			Vxx_ajs_driv_pwt_sp_grd
			Vxx_ajs_slk_tqe_sp
			Vxx_ajs_spv_fast_cor_dly
			Vbx_ajs_cut_cdn_on
			Vbx_ajs_no_drag
			Vxx_ajs_spd_diff
			Vbx_ajs_slk_tqe_off
			Vbx_ajs_slk_tqe_on
			Vbx_ajs_slk_on
			Vbx_ajs_slk_open_on
			Vxx_ajs_aux_tql
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin FUNCTION
		PcPajCtl_Estixxx
		""
	/begin OUT_MEASUREMENT
			Vxx_ajs_esti_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin FUNCTION
		PcPajCtl_Spccdxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ajs_spc_comb_mod_cho_1
			Cxx_ajs_spc_comb_mod_cho_2
			Cxx_ajs_spc_comb_mod_cho_3
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ajs_spc_rat
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin FUNCTION
		PcPajCtl_Spcpaxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ajs_tco
			Cmp_ajs_acel_slk_dly_fac_spc
			Cmp_ajs_acel_slk_dly_spc
			Cmp_ajs_acel_slk_t1_fac_spc
			Cmp_ajs_acel_slk_t1_max_spc
			Cmp_ajs_decl_slk_dly_fac_spc
			Cmp_ajs_decl_slk_dly_spc
			Cmp_ajs_decl_slk_t1_fac_spc
			Cmp_ajs_decl_slk_t1_max_spc
			Cmp_ajs_modu_t1_acel_clos_spc
			Cmp_ajs_modu_t1_acel_fac_spc
			Cmp_ajs_modu_t1_decl_clos_spc
			Cmp_ajs_modu_t1_decl_fac_spc
			Cmp_ajs_modu_td_acel_clos_spc
			Cmp_ajs_modu_td_acel_fac_spc
			Cmp_ajs_modu_td_decl_clos_spc
			Cmp_ajs_modu_td_decl_fac_spc
			Ctp_ajs_slk_tqe_off_acel_spc
			Ctp_ajs_slk_tqe_off_decl_spc
			Ctp_ajs_slk_tqe_on_acel_spc
			Ctp_ajs_slk_tqe_on_decl_spc
			Ctp_ajs_t1_acel_tco_fac
			Ctp_ajs_t1_decl_tco_fac
			Ctp_ajs_td_acel_tco_fac
			Ctp_ajs_td_decl_tco_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ajs_modu_n_mv_spc
			Vxx_ajs_modu_t1_acel_spc
			Vxx_ajs_modu_t1_decl_spc
			Vxx_ajs_modu_td_acel_spc
			Vxx_ajs_modu_td_decl_spc
			Vxx_ajs_slk_dly_t1_spc
			Vxx_ajs_slk_t1_ini_max_spc
			Vxx_ajs_slk_tqe_off_acel_spc
			Vxx_ajs_slk_tqe_off_decl_spc
			Vxx_ajs_slk_tqe_on_acel_spc
			Vxx_ajs_slk_tqe_on_decl_spc
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/begin FUNCTION
		PcTraArb
		""
	/begin SUB_FUNCTION
			PcTraArb_Arbitxx
			PcTraArb_Drlimxx
			PcTraArb_Gbmatxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/begin FUNCTION
		PcTraArb_Arbitxx
		""
	/begin OUT_MEASUREMENT
			Vxx_arb_no_agb_tqe
			Vxx_arb_tqe_raw
			Vxx_arb_tqe_sp
			Vxx_arb_tqe_tgt
			Vxx_raw_arb_no_agb_tqe
			Vbx_tq_trs_ctl_mux
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/begin FUNCTION
		PcTraArb_Drlimxx
		""
	/begin OUT_MEASUREMENT
			Vxx_lim_driv_tqe_sp
			Vxx_lim_driv_tqe_tgt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/begin FUNCTION
		PcTraArb_Gbmatxx
		""
	/begin OUT_MEASUREMENT
			Vxx_gbx_max_tqe_sp
			Vxx_gbx_max_tqe_tgt
			Vxx_gbx_min_tqe_sp
			Vxx_gbx_min_tqe_tgt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/begin FUNCTION
		SmCajCtl
		""
	/begin SUB_FUNCTION
			SmCajCtl_Ajcorxx
			SmCajCtl_Spcpaxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/begin FUNCTION
		SmCajCtl_Ajcorxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ajs_cor_n
			Ctb_ajs_dt_tq_rat
			Cmp_ajs_cor_t1_acel_dt_clos
			Cmp_ajs_cor_td_acel_dt_clos
			Cbx_ajs_cor_driv_cut_cfm
			Cbx_ajs_cor_dz_cfm
			Cxx_ajs_cor_dz_dly
			Cxx_ajs_cor_t1_acel_dt_modu
			Cxx_ajs_cor_t1_acel_dt_open
			Cxx_ajs_cor_t1_decl_dt_modu
			Cxx_ajs_cor_t1_decl_dt_open
			Cxx_ajs_cor_t1_dt_ini
			Cxx_ajs_cor_td_acel_dt_modu
			Cxx_ajs_cor_td_acel_dt_open
			Cxx_ajs_cor_td_decl_dt_modu
			Cxx_ajs_cor_td_decl_dt_open
			Cxx_ajs_cor_td_dt_ini
			Ctb_ajs_cor_driv_tq_fac
			Ctp_ajs_cor_dz_tqe
			Cxx_ajs_cor_max_cor_dyn_dt_open
			Cxx_ajs_cor_min_cor_dyn_dt_open
			Cxx_ajs_cor_tkof_vs_thd
			Cmp_ajs_cor_t1_decl_dt_clos
			Cmp_ajs_cor_fast_cor_dly
			Cmp_ajs_cor_t1_fast_cor
			Cmp_ajs_cor_td_decl_dt_clos
			Cmp_ajs_cor_td_fast_cor
			Ctp_ajs_cor_max_cor_dyn_tqe
			Ctp_ajs_cor_fast_cor_dly_fac
			Ctp_ajs_cor_t1_fast_cor_fac
			Ctp_ajs_cor_td_fast_cor_fac
			Ctp_ajs_cor_min_cor_dyn_tqe
			Cbx_ajs_cor_stt_cfm
			Cbx_ajs_cor_is_cfm
			Ctb_ajs_cor_tco
			Ctb_ajs_cor_n_diff
			Cmp_ajs_cor_td_tq_fac
			Cmp_ajs_cor_td_acel_n_diff_fac
			Cmp_ajs_cor_td_decl_n_diff_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ajs_cor_lim_dz_dyn_tqe
			Vxx_ajs_cor_t1_decl
			Vxx_ajs_cor_td_acel
			Vxx_ajs_cor_td_decl
			Vxx_ajs_cor_tqe
			Vxx_ajs_cor_dyn_tqe
			Vxx_ajs_cor_lim_dyn_tqe
			Vxx_ajs_cor_dz_tqe
			Vxx_ajs_cor_max_cor_dyn
			Vxx_ajs_cor_min_cor_dyn
			Vsx_ajs_cor_stt_para
			Vxx_ajs_cor_tqe_tmp
			Vbx_ajs_cor_stt_cut
			Vbx_ajs_cor_fast_cor_off
			Vbx_ajs_cor_fast_cor_on
			Vxx_ajs_cor_td_tq_fac
			Vxx_ajs_cor_fast_cor_dly
			Vxx_ajs_cor_t1_acel
			Vxx_ajs_cor_t1_fast_cor
			Vxx_ajs_cor_td
			Vxx_ajs_cor_td_fast_cor
			Vxx_ajs_cor_t1
			Vxx_ajs_cor_n_diff
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/begin FUNCTION
		SmCajCtl_Spcpaxx
		""
	/begin DEF_CHARACTERISTIC
			Cmp_ajs_cor_t1_acel_clos_spc
			Cmp_ajs_cor_t1_decl_clos_spc
			Cmp_ajs_cor_td_acel_clos_spc
			Cmp_ajs_cor_td_decl_clos_spc
			Cmp_ajs_cor_td_tq_fac_spc
			Ctp_ajs_cor_dz_tqe_spc
			Ctp_ajs_cor_max_dyn_tqe_spc
			Ctp_ajs_cor_min_dyn_tqe_spc
			Cxx_ajs_cor_dz_dly_spc
			Cxx_ajs_cor_max_dyn_open_spc
			Cxx_ajs_cor_min_dyn_open_spc
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ajs_cor_dz_dly_spc
			Vxx_ajs_cor_dz_tqe_spc
			Vxx_ajs_cor_max_cor_dyn_spc
			Vxx_ajs_cor_min_cor_dyn_spc
			Vxx_ajs_cor_spc_rat
			Vxx_ajs_cor_t1_acel_dt_clos_spc
			Vxx_ajs_cor_t1_decl_dt_clos_spc
			Vxx_ajs_cor_td_acel_dt_clos_spc
			Vxx_ajs_cor_td_decl_dt_clos_spc
			Vxx_ajs_cor_td_tq_fac_spc
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl
		""
	/begin OUT_MEASUREMENT
			SmIsrCtl_NVM.Vxx_is_ad_tq_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'SmIsrCtl_Obdisxx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			SmIsrCtl_Dervxxx
			SmIsrCtl_Hookxxx
			SmIsrCtl_Idactxx
			SmIsrCtl_Intxxxx
			SmIsrCtl_Propxxx
			SmIsrCtl_Tkodlxx
			SmIsrCtl_Idctrxx
			SmIsrCtl_Adaptxx
			SmIsrCtl_Tkocoxx
			SmIsrCtl_Ctlfacx
			SmIsrCtl_Schedul
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* ASAP2::Database : delete OUT_MEASUREMENT, since it is empty */
/begin FUNCTION
		SmIsrCtl_Adaptxx
		""
	/* ASAP2::Database : delete 'Cbx_is_ad_mdf_cfm' */
	/* ASAP2::Database : delete 'Cxx_ac_pow' */
	/* ASAP2::Database : delete 'Cxx_ad_cor_dsb_dly' */
	/* ASAP2::Database : delete 'Cxx_dri_agb_ad_is_fil' */
	/* ASAP2::Database : delete 'Cxx_h_ad_is_alt_pow' */
	/* ASAP2::Database : delete 'Cxx_is_i_fil_fac1' */
	/* ASAP2::Database : delete 'Cxx_is_i_fil_fac2' */
	/* ASAP2::Database : delete 'Cxx_l_ad_is_alt_pow' */
	/* ASAP2::Database : delete 'Cxx_max_is_ad_tq' */
	/* ASAP2::Database : delete 'Cxx_max_n_ad_sp_dif' */
	/* ASAP2::Database : delete 'Cxx_min_is_ad_tq' */
	/* ASAP2::Database : delete 'Cxx_min_tco_ad_cor' */
	/* ASAP2::Database : delete 'Cxx_neut_ad_is_fil' */
	/* ASAP2::Database : 13 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_is_ad_tq_dft
	/end DEF_CHARACTERISTIC
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Ctlfacx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_comb_mod_is_3
			Cxx_comb_mod_is_4
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_is_fac_cho
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Dervxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_fac_n_d
			Ctp_is_d_max
			Ctp_is_d_min
			Ctp_is_d_err_fac
			Ctp_is_d_gear_fac
			Ctp_is_d_tco_fac
			Ctb_is_n_d_dif
			Cxx_is_d_pft_rgn_fac
			Ctb_is_tco
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_dif_n_sp_grd
			Vxx_is_d_cor
			Vxx_is_d_fac
			Vxx_mmv_n_dif_drv
			Vxx_raw_n_dif_drv
			Vxx_max_is_d
			Vxx_min_is_d
			Vbx_ini_drv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Hookxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_on_ac_cor_cfm
			Cbx_on_mdf_cor_cfm
			Cbx_on_pwst_cor_cfm
			Cxx_fast_ad_cdn_dly
			Cxx_is_i_zon_out_dly
			Cxx_min_is_i_ofs
			Cbx_on_alt_cor_cfm
			Cxx_h_blk_is_alt_pow
			Cxx_l_blk_is_alt_pow
			Cbx_is_blk_vh_run_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_blk_n
			Vbx_is_blk_n_cdn
			Vxx_is_i_zon_out_dly
			Vbx_is_blk_vh
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Idactxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ac_is_in_cdn_ofs2
			Cxx_ac_is_out_n_ofs
			Cxx_is_act_ofs
			Cxx_is_ast_ofs_zon
			Cxx_is_cdn_h_sta_n_dly
			Cxx_is_deci_in_dly
			Cxx_is_in_cdn_ofs2
			Cxx_is_in_pump_thd
			Cxx_is_n_stab_clc_fac
			Cxx_is_n_stab_drv_thd
			Cxx_is_out_ast_dly
			Cxx_is_out_n_ofs_sta
			Cxx_is_out_pump_thd
			Cxx_sta_stt_is_in_dly
			Cxx_is_deci_in_n_thd
			Cxx_is_in_dly
			Ctb_is_in_ofs_drv
			Ctp_sta_off_ofs
			Cxx_ac_is_in_dly
			Ctd_is_in_ofs_drv
			Ctp_is_out_sta_dly
			Cxx_is_n_stab_clc_ini
			Cxx_ac_is_in_cdn_ofs
			Cxx_is_out_drv_thd
			Cxx_is_out_n_ofs
			Cxx_is_out_n_run_vh_thd
			Cxx_is_in_wit_pdl_ofs
			Cxx_is_out_wit_pdl_ofs
			Cxx_n_drv_ast
			Cxx_fac_n_drv_d
			Cxx_fac_n_drv_fil
			Cxx_is_in_cdn_ofs
			Cxx_is_fil_drv_n_min
			Cxx_is_fil_drv_n_max_ofs
			Cxx_is_out_n_stop_vh_thd
			Ctp_is_in_tco_ofs
			Cxx_is_n_act
			Cxx_is_n_act_hys
			Cxx_n_drv_out
			Cbx_tq_trs_ctl_mux_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_is_n_stab_ini
			Vsx_is
			Vxx_is_cdn_h_n_dly
			Vxx_is_in_n_thd
			Vxx_is_n_stab_fac
			Vxx_is_out_ast_dly
			Vxx_is_in_deci_dly
			Vxx_is_in_dly
			Vxx_is_ast_ofs
			Vxx_is_out_n_thd
			Vxx_sta_off_ofs
			Vbx_sta
			Vxx_is_out_sta_dly
			Vxx_n_drv_is
			Vxx_n_drv_sub
			Vbx_is_act
			Vsx_is_raw
			Vbx_old_igk_cut
			Vsx_mc
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Idctrxx
		""
	/* ASAP2::Database : delete 'Cbx_cdn_is_fil_tgt_cfm' */
	/* ASAP2::Database : delete 'Cbx_tq_pow_is_cfm' */
	/* ASAP2::Database : delete 'Cxx_is_tgt_ftc_dec_slop' */
	/* ASAP2::Database : delete 'Cxx_is_tgt_ftc_inc_slop' */
	/* ASAP2::Database : delete 'Cxx_mfld_dly_dec_slop' */
	/* ASAP2::Database : delete 'Cxx_mfld_dly_inc_slop' */
	/* ASAP2::Database : 6 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Ctb_is_n_dif
			Ctp_raw_p_d_fac
			Cxx_is_tgt_ftc
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vxx_raw_raw_is_tqe' */
	/* ASAP2::Database : delete 'Vxx_raw_sp_is_tqe' */
	/* ASAP2::Database : delete 'Vxx_raw_tgt_is_tqe' */
	/* ASAP2::Database : 3 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_is_tqe_raw
			Vxx_is_tqe_sp
			Vxx_is_tqe_tgt
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Intxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_blk_n_min_is_i
			Ctp_tco_tqe_max_is_i
			Cmp_tco_ini_i
			Ctp_tco_ini_i_sta
			Ctp_is_i_gear_fac
			Cbx_ini_i_tco_cfm
			Cxx_blk_n_i_fac_cor
			Cxx_fil_is_i_sp
			Cxx_ini_i_fac
			Cxx_vh_run_max_is_i_ofs
			Cxx_vh_run_min_is_i_fac
			Cxx_vh_stop_min_is_i_fac
			Cmp_is_i_err_tco_fac
			Cxx_is_i_out_fil_fac
			Cxx_is_i_out_fil_wit_pdl_fac
			Cxx_is_n_max_is_i
			Cxx_is_n_min_is_i
			Cxx_is_n_max_is_i_grd
			Cxx_is_n_min_is_i_grd
			Cbx_i_set_is_cfm
			Cbx_is_int_ftc_n_cfm
			Ctb_is_n_i_dif
			Cxx_is_i_pft_rgn_fac
			Cbx_is_cdn_i_act_cfm
			Cxx_is_i_set_ofs
			Cxx_is_i_tq_trs_ctl_mux_n_in
			Cxx_is_i_tq_trs_ctl_mux_n_out
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_is_i_cor
			Vxx_is_i_fac
			Vxx_max_is_i
			Vxx_is_i_cor_ini
			Vxx_is_i_cor_ini_ad
			Vxx_min_is_i_wio_blk
			Vtx_ini_i[0]
			Vtx_ini_i[1]
			Vxx_min_is_i
			Vxx_tqe_ini_i
			Vxx_is_i_out_fil
			Vxx_is_n_is_i
			Vxx_is_n_is_i_grd
			Vxx_is_i_cor_prev
			Vxx_is_i_cor_wit_set
			Vxx_is_i_cor_wio_set
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Propxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_is_p_max
			Ctp_is_p_min
			Ctp_is_p_gear_fac
			Ctp_is_p_sta_fac
			Cxx_is_p_sta_max
			Ctb_is_n_p_dif
			Cmp_is_p_err_tco_fac
			Cxx_is_p_pft_rgn_fac
			Cxx_is_p_inc_slop
			Cxx_is_p_dec_slop
			Cxx_is_ctl_mux_min_p
			Cbx_tq_trs_ctl_mux_p_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_is_p_cor
			Vxx_max_is_p
			Vxx_min_is_p
			Vxx_is_gear
			Vxx_dif_n_sp
			Vtx_is_p_fac[0]
			Vtx_is_p_fac[1]
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Schedul
		""
	/begin DEF_CHARACTERISTIC
			Cbx_is_loop_diag_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_is_loop_diag_cfm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		SmIsrCtl_Tkocoxx
		""
	/* ASAP2::Database : delete 'Vbx_tkof_tq_cor_ena' */
	/* ASAP2::Database : delete 'Vxx_tkof_d_cor' */
	/* ASAP2::Database : delete 'Vxx_tkof_p_cor' */
	/* ASAP2::Database : 3 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_tkof_tqe_cor
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin FUNCTION
		SmIsrCtl_Tkodlxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_tkof_end_vs_thd
			Cxx_tkof_n_grd_end_thd
			Cxx_tkof_ena_vs_thd
			Cxx_tkof_vs_n_rat_stop_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_tkof_vs_ena
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt
		""
	/begin OUT_MEASUREMENT
			SmIsrSpt_NVM.Vxx_acs_acel_is_NVM
			SmIsrSpt_NVM.Vxx_el_csm_ctr_NVM
			SmIsrSpt_NVM.Vbx_acs_acel_is_ena_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'SmIsrSpt_Ntkofxx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			SmIsrSpt_Alcoxxx
			SmIsrSpt_Dgissxx
			SmIsrSpt_Mcissxx
			SmIsrSpt_Elissxx
			SmIsrSpt_Dynssxx
			SmIsrSpt_Atissxx
			SmIsrSpt_Ptissxx
			SmIsrSpt_Arissxx
			SmIsrSpt_Cfdgiss
			SmIsrSpt_Istatun
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		SmIsrSpt_Alcoxxx
		""
	/* ASAP2::Database : delete 'Vxx_tdc_pn_tco_is_n_ofs_alco' */
	/* ASAP2::Database : delete 'Vxx_cold_tdc_pn_is_n_ofs_alco' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_is_fuel_typ_rat_tra
			Vxx_tco_amp_min_is_n_alco
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Arissxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_mpl_dec_slop_act
			Cxx_inc_slop_ac_sp
			Cxx_inc_slop_agb_sp
			Cxx_dec_slop_el_wind_sp
			Cxx_inc_slop_el_wind_sp
			Cxx_dec_slop_moni_sp
			Cxx_inc_slop_moni_sp
			Cxx_dec_slop_pft_sp
			Cxx_inc_slop_pft_sp
			Cxx_dec_slop_ptc_sp
			Cxx_inc_slop_ptc_sp
			Cxx_dec_slop_pwst_sp
			Cxx_inc_slop_pwst_sp
			Cxx_dec_slop_run_vh_sp
			Cxx_inc_slop_run_vh_sp
			Cxx_dec_slop_tco_sp
			Cxx_inc_slop_tco_sp
			Cxx_dec_slop_thpl_sp
			Cxx_inc_slop_thpl_sp
			Cxx_is_n_sp_max
			Cxx_is_n_sp_min
			Cxx_moni_is_n_sp_max
			Cxx_fast_inc_slop
			Cxx_fast_dec_slop
			Cxx_med_inc_slop
			Cxx_med_dec_slop
			Cxx_slow_inc_slop
			Cxx_slow_dec_slop
			Cxx_n_sp_dec
			Ctd_gear_run_vh_min_is_n
			Cxx_dec_slop_acs_sp
			Cxx_inc_slop_acs_sp
			Cxx_dec_slop_ac_sp
			Cxx_run_vh_min_is_n_dsb
			Cxx_dec_slop_agb_sp
			Cxx_dec_slop_dgi_sp
			Cxx_dec_slop_el_bk_sp
			Cxx_inc_slop_dgi_sp
			Cxx_inc_slop_el_bk_sp
			Cmp_tco_amp_min_is_n
			Cxx_dec_slop_inj_sp
			Cxx_inc_slop_inj_sp
			Cxx_dec_slop_diag_vvtc_sp
			Cxx_inc_slop_diag_vvtc_sp
			Cbx_is_run_vh_min_crp_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_is_n_sp
			Vxx_run_vh_min_is_n
			Vxx_arb_lim_is
			Vxx_crt_is
			Vxx_tco_sp_min_is_n
			Vxx_arb_dec_slop
			Vtx_dec_slop_itl_tb[0]
			Vtx_dec_slop_itl_tb[1]
			Vtx_dec_slop_itl_tb[2]
			Vtx_dec_slop_itl_tb[3]
			Vtx_dec_slop_itl_tb[4]
			Vtx_dec_slop_itl_tb[5]
			Vtx_dec_slop_itl_tb[6]
			Vtx_dec_slop_itl_tb[7]
			Vtx_dec_slop_itl_tb[8]
			Vtx_dec_slop_itl_tb[9]
			Vtx_dec_slop_itl_tb[10]
			Vtx_dec_slop_itl_tb[11]
			Vtx_dec_slop_itl_tb[12]
			Vtx_dec_slop_itl_tb[13]
			Vtx_dec_slop_itl_tb[14]
			Vxx_tco_min_is_n
			Vxx_arb_inc_slop
			Vtx_inc_slop_itl_tb[0]
			Vtx_inc_slop_itl_tb[1]
			Vtx_inc_slop_itl_tb[2]
			Vtx_inc_slop_itl_tb[3]
			Vtx_inc_slop_itl_tb[4]
			Vtx_inc_slop_itl_tb[5]
			Vtx_inc_slop_itl_tb[6]
			Vtx_inc_slop_itl_tb[7]
			Vtx_inc_slop_itl_tb[8]
			Vtx_inc_slop_itl_tb[9]
			Vtx_inc_slop_itl_tb[10]
			Vtx_inc_slop_itl_tb[11]
			Vtx_inc_slop_itl_tb[12]
			Vtx_inc_slop_itl_tb[13]
			Vtx_inc_slop_itl_tb[14]
			Vtx_is_sp_itl_tb[0]
			Vtx_is_sp_itl_tb[1]
			Vtx_is_sp_itl_tb[2]
			Vtx_is_sp_itl_tb[3]
			Vtx_is_sp_itl_tb[4]
			Vtx_is_sp_itl_tb[5]
			Vtx_is_sp_itl_tb[6]
			Vtx_is_sp_itl_tb[7]
			Vtx_is_sp_itl_tb[8]
			Vtx_is_sp_itl_tb[9]
			Vtx_is_sp_itl_tb[10]
			Vtx_is_sp_itl_tb[11]
			Vtx_is_sp_itl_tb[12]
			Vtx_is_sp_itl_tb[13]
			Vtx_is_sp_itl_tb[14]
			Vxx_arb_raw_is
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Atissxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_agb_tco_min_is_n
			Ctp_drag_tco_min_is_n
			Cxx_agb_min_is_n
			Cxx_tco_agb_df_min_is_n
			Cxx_is_run_vh_min_crp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_agb_min_is_n
			Vxx_tco_agb_min_is_n
			Vbx_agb_is_clc_ena
			Vbx_is_run_vh_min_crp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Cfdgiss
		""
	/begin OUT_MEASUREMENT
			Vsx_is_inj_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Dgissxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_toil_is_n_ofs
			Cxx_prs_dft_min_is_n
			Cxx_toil_is_n_ofs
			Cxx_n_vld_min_is_n
			Cxx_inj_vld_min_is_n
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_prs_dft_min_is_n
			Vxx_toil_is_n_ofs
			Vxx_moni_min_is_n
			Vxx_n_vld_min_is_n
			Vxx_inj_vld_min_is_n
			Vbx_diag_sta_ndec_abrt
			Vbx_diag_sta_ninc_abrt
			Vxx_diag_vvtc_min_is_n
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Dynssxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_is_ast_ofs
			Ctp_max_ftc_dyn_is_sp
			Cxx_min_ftc_dyn_is_sp
			Cxx_k_ftc_dyn_is_sp
			Cxx_fac_n_drv_ftc_dyn
			Cxx_is_out_dyn_ofs
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_dyn_is_n_sp
			Vxx_ftc_dyn
			Vxx_ftc_dyn_n_drv
			Vbx_dyn_is_n_sp_rst
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Elissxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_el_csm_clc_dly
			Cxx_el_csm_alt_cut_dly
			Cxx_el_csm_clc_neg_fac
			Cxx_el_csm_clc_pos_fac
			Cxx_el_csm_clc_neut_vb
			Cxx_ptc_min_is_n
			Cxx_thpl_min_is_n
			Ctp_el_csm_n_sp_ofs
			Ctb_el_csm_n_sp_ofs
			Cxx_agb_wind_min_is_n
			Cxx_el_bk_wind_is_n
			Cxx_el_wind_tco
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_el_csm_clc_ena
			Vxx_min_vb_is_ofs
			Vxx_ptc_min_is_n
			Vxx_thpl_min_is_n
			Vxx_el_wind_min_is_n
			Vxx_el_bk_wind_min_is_n
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Istatun
		""
	/begin DEF_CHARACTERISTIC
			Cxx_diag_max_is_n
			Cxx_diag_min_is_n
			Cxx_n_step
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_diag_sta_ndec_ena
			Vbx_diag_sta_ninc_ena
			Vsx_diag_sta_ndec_stt
			Vsx_diag_sta_ninc_stt
			Vxx_diag_min_is_ofs
			Vbx_diag_sta_ndec_end
			Vbx_diag_sta_ninc_end
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Mcissxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ac_forb_is_n
			Cxx_pwst_is_acel_rtn_dly
			Ctp_ac_forb_is_n
			Ctp_agb_ac_min_is_n
			Ctp_pn_ac_min_is_n
			Cxx_pn_pwst_min_is_n
			Cxx_agb_pwst_min_is_n
			Cxx_ac_acel_is_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_pwst_min_is_n
			Vxx_acs_min_is_n
			Vxx_ac_min_is_n
			Vxx_eng_ac_min_is_n
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin FUNCTION
		SmIsrSpt_Ptissxx
		""
	/* ASAP2::Database : delete 'Ctb_cold_is_cata_wup_ctr' */
	/* ASAP2::Database : delete 'Ctb_is_cata_wup_ctr' */
	/* ASAP2::Database : delete 'Ctp_cold_tdc_agb_is_n_ofs' */
	/* ASAP2::Database : delete 'Ctp_cold_tdc_pn_is_n_ofs' */
	/* ASAP2::Database : delete 'Ctp_tdc_agb_tco_is_n_ofs' */
	/* ASAP2::Database : delete 'Ctp_tdc_pn_tco_is_n_ofs' */
	/* ASAP2::Database : 6 referenced entries deleted */
	/* ASAP2::Database : delete 'Cxx_agb_tco_is_n_ofs' */
	/* ASAP2::Database : delete 'Cxx_cold_agb' */
	/* ASAP2::Database : delete 'Cxx_cold_agb_tco_is_n_ofs' */
	/* ASAP2::Database : delete 'Cxx_cold_pn' */
	/* ASAP2::Database : delete 'Cxx_cold_pn_tco_is_n_ofs' */
	/* ASAP2::Database : delete 'Cxx_cold_sta_tco' */
	/* ASAP2::Database : delete 'Cxx_pn_tco_is_n_ofs' */
	/* ASAP2::Database : delete 'Cxx_cold_pn_alco' */
	/* ASAP2::Database : delete 'Cxx_cold_pn_tco_is_n_ofs_alco' */
	/* ASAP2::Database : delete 'Cxx_pn_tco_is_n_ofs_alco' */
	/* ASAP2::Database : 10 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_pft_min_is_n
			Cxx_comb_mod_is_1
			Cxx_comb_mod_is_2
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vbx_cata_wup_cdn_ena' */
	/* ASAP2::Database : delete 'Vxx_tco_no_neut_raw_val' */
	/* ASAP2::Database : delete 'Vxx_tco_neut_raw_val' */
	/* ASAP2::Database : delete 'Vbx_cata_wup_dri' */
	/* ASAP2::Database : delete 'Vxx_cold_pn_tco_is_n_ofs' */
	/* ASAP2::Database : delete 'Vxx_is_n_ofs_cold' */
	/* ASAP2::Database : delete 'Vxx_pn_tco_is_n_ofs' */
	/* ASAP2::Database : delete 'Vxx_tdc_pn_tco_is_n_ofs' */
	/* ASAP2::Database : 8 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_pft_min_is_n
			Vxx_tco_is_n_ofs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/begin FUNCTION
		SmLimCtl
		""
	/begin SUB_FUNCTION
			SmLimCtl_Ntqcxxx
			SmLimCtl_Ntspcxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/begin FUNCTION
		SmLimCtl_Ntqcxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctd_n_prop_thd
			Ctd_ovn_tq_int_k
			Ctd_ovn_tq_prop_k
			Cxx_ovn_tq_prop_t_fil
			Cxx_tqe_max_ovn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ovn_tq_cor
			Vxx_lim_dif_n
			Vxx_lim_dif_n_prop
			Vxx_ovn_tq_cor_p_i
			Vxx_ovn_tq_int
			Vxx_ovn_tq_prop
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/begin FUNCTION
		SmLimCtl_Ntspcxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_inj_stop_n_ofs
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ovn_cut_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/begin FUNCTION
		SmLimSpt
		""
	/begin SUB_FUNCTION
			SmLimSpt_Nramsxx
			SmLimSpt_Nlimxxx
			SmLimSpt_Fsncfxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/begin FUNCTION
		SmLimSpt_Fsncfxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_n_lim_ff_actr_0_cfm
			Cbx_n_lim_ff_actr_3_cfm
			Cbx_n_lim_ff_actr_4_cfm
			Cbx_n_lim_ff_fct_0_cfm
			Cbx_n_lim_ff_fct_4_cfm
			Cbx_n_lim_ff_fct_5_cfm
			Cbx_n_lim_fprs_actr_0_cfm
			Cbx_n_lim_fprs_fct_0_cfm
			Cbx_n_lim_fprs_fct_3_cfm
			Cbx_n_lim_fprs_fct_4_cfm
			Cbx_n_lim_inj_0_cfm
			Cbx_n_lim_mpl_fail_cfm
			Cbx_n_lim_inj_ecu_0_cfm
			Cbx_n_lim_sens_rail_prs_cfm
			Cbx_n_lim_sens_rail_prs_2_cfm
			Cxx_n_lim_crk_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_n_rams_lim_act_1
			Vbx_n_rams_lim_act_2
			Vbx_ovn_tq_cor_dft_dsb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/begin FUNCTION
		SmLimSpt_Nlimxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_max_n_tco
			Ctp_max_n_toil
			Ctp_sta_tco_dly
			Ctp_ovn_tq_cor_ena
			Ctp_max_n_gear
			Ctd_gear_cge_max_n_ofs
			Cxx_max_n_tco_toil_dft
			Cxx_max_n_thd_oil_ovn
			Cxx_sta_tco_dly_dft
			Cxx_max_n_ovn_ofs
			Cxx_max_n_gear_dft
			Cbx_max_n_fl_tkof_ant_coup_dsb
			Cbx_max_n_fl_tkof_ena
			Cbx_max_n_fl_tkof_ovn_tq_ena
			Cxx_max_n_dec_slop
			Cxx_max_n_fl_tkof
			Cxx_max_n_fl_tkof_ext_ctrl_dly
			Cxx_max_n_fl_tkof_vs_thd
			Cxx_max_n_inc_slop
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_max_n_inj
			Vxx_max_n_ovn
			Vxx_max_n_nom
			Vbx_ovn_tq_cor_ena
			Vbx_ovn_sta_ena
			Vbx_gear_cge_max_n
			Vbx_max_n_fl_tkof_act
			Vbx_max_n_fl_tkof_cdn
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/begin FUNCTION
		SmLimSpt_Nramsxx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_max_rams_n_dec
			Cxx_max_rams_n_1
			Cxx_max_rams_n_2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_n_rams_lim_act
			Vxx_max_rams_n
			Vsx_n_rams_lim_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/begin FUNCTION
		SmStaSpv
		""
	/* ASAP2::Database : delete 'SmStaSpv_Stalixx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			SmStaSpv_Engstxx
			SmStaSpv_Entrfxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/begin FUNCTION
		SmStaSpv_Engstxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_aut_eng_n_thd_h
			Ctp_aut_eng_n_thd
			Ctp_sta_dly
			Cxx_drvn_eng_n_thd_h
			Cxx_drvn_eng_n_thd_l
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			SmStaSpv_NVM.Vbx_frst_sta_done_NVM
			SmStaSpv_NVM.Vbx_clu_stal_NVM
			SmStaSpv_NVM.Vbx_swlk_stal_NVM
			SmStaSpv_NVM.Vbx_mem_swlk_NVM
			Vbx_trs_eng_aut
			Vsx_eng
			Vsx_prev_eng
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/begin FUNCTION
		SmStaSpv_Entrfxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ini_stop_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_vh_eng
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/begin FUNCTION
		TqLimLos
		""
	/begin SUB_FUNCTION
			TqLimLos_Lossxxx
			TqLimLos_Rubtqxx
			TqLimLos_Ptqxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/begin FUNCTION
		TqLimLos_Lossxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pwst_prs_tql
			Cbx_is_ad_eng_tql_cmf
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_aux_tql_sp
			Vxx_eng_tql
			Vxx_is_tql
			Vsx_eng_tql_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/begin FUNCTION
		TqLimLos_Ptqxxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ptq_dp_form_fac
			Ctp_ptq_dp_form_fac
			Cxx_ptq_ftc
			Cxx_ptq_max
			Cbx_ptq_ex_prs_mdl_ok_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ptq
			Vxx_dp
			Vxx_dp_fil
			Vsx_ptq_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/begin FUNCTION
		TqLimLos_Rubtqxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tql_temp_cfm
			Cmp_tql_eng_frn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tql_eng_frn
			Vsx_tql_eng_frn_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/begin FUNCTION
		TqLimMnt
		""
	/begin SUB_FUNCTION
			TqLimMnt_Mintqxx
			TqLimMnt_Statqxx
			TqLimMnt_Engtqxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		TqLimMnt_Engtqxx
		""
	/* ASAP2::Database : delete 'Vxx_l_eng_map' */
	/* ASAP2::Database : delete 'Vxx_l_eng_tq' */
	/* ASAP2::Database : 2 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_l_eng_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/begin FUNCTION
		TqLimMnt_Mintqxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_min_tqe_n
			Cxx_agb_max_tqe_cor
			Cxx_agb_min_tqe_fac
			Cxx_min_is_n
			Cxx_min_n_thd_min_tq
			Cxx_min_l_eng_tqe_tqe_hys
			Cxx_min_n_tq_grd
			Cxx_min_n_tq_grd_sta
			Cbx_min_tq_mod_cfm
			Cxx_min_tq_ast_dsb_dly
			Cmp_n_tco_min_tq_fmt
			Ctp_min_tq_tco_ofs
			Ctb_inj_cut_n
			Ctb_dt_tq_rat
			Cmp_cut_fil_fac
			Cmp_driv_swi_fil_fac
			Cxx_fil_fac_dft
			Cbx_min_avl_tqe_raw_cfm
			Cbx_min_driv_tqe_cfm
			Cbx_n_mv_n_cfm
			Ctp_swi_fil_fac
			Ctd_gear_min_driv_tqe_ftc
			Ctd_coup_grip_rat
			Ctd_gear_tq_rat
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_min_avl_tqe
			Vxx_min_bas_tqe
			Vxx_min_driv_tqe
			Vxx_min_agb_tqe
			Vxx_min_is_tql
			Vbx_l_eng_tqe
			Vxx_min_bas_tqe_raw
			Vxx_min_bas_agb_tqe
			Vxx_min_avl_tqe_raw
			Vxx_min_driv_tqe_wit_inj_cut
			Vxx_cut_fil_fac
			Vxx_min_driv_tqe_raw
			Vxx_cut_tq_cor_fil
			Vxx_dt_tq_rat
			Vxx_swi_fil_fac
			Vxx_n_dif_tq
			Vxx_n_mv_min_driv_tqe
			Vxx_n_mv_min_driv_tqe_raw
			Vbx_sta_min_tq
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/begin FUNCTION
		TqLimMnt_Statqxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_sta_n
			Cxx_sta_tq_inc
			Cxx_sta_tq_inc_dly
			Cmp_n_tco_sta_tq
			Ctp_tco_sta_is_trs_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_sta_is_fil_fac
			Vxx_sta_tq
			Vxx_raw_sta_tq
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt
		""
	/begin SUB_FUNCTION
			TqLimMxt_Gbxlixx
			TqLimMxt_Maxtqpr
			TqLimMxt_Maxtqri
			TqLimMxt_Maxtqxx
			TqLimMxt_Ovhtqxx
			TqLimMxt_Protqxx
			TqLimMxt_Smkppxx
			TqLimMxt_Smkprxx
			TqLimMxt_Smkrijx
			TqLimMxt_Smokexx
			TqLimMxt_Statlxx
			TqLimMxt_Tqramsx
			TqLimMxt_Fstqcfx
			TqLimMxt_Protcxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Fstqcfx
		""
	/* ASAP2::Database : delete 'Cxx_tq_lim_spg_reg_cfm' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_tq_lim_tbt_reg_cfm
			Cbx_tq_lim_egt_tq_lim_0_cfm
			Cbx_tq_lim_egt_tq_lim_2_cfm
			Cbx_tq_lim_egt_tq_lim_3_cfm
			Cbx_tq_lim_ff_actr_0_cfm
			Cbx_tq_lim_ff_actr_3_cfm
			Cbx_tq_lim_ff_actr_4_cfm
			Cbx_tq_lim_ff_fct_0_cfm
			Cbx_tq_lim_ff_fct_4_cfm
			Cbx_tq_lim_ff_fct_5_cfm
			Cbx_tq_lim_fprs_actr_cfm
			Cbx_tq_lim_fprs_fct_0_cfm
			Cbx_tq_lim_fprs_fct_3_cfm
			Cbx_tq_lim_fprs_fct_4_cfm
			Cbx_tq_lim_inj_0_cfm
			Cbx_tq_lim_mpl_fail_cfm
			Cbx_tq_lim_sens_rail_prs_cfm
			Cbx_tq_lim_tbt_reg_0_cfm
			Cbx_tq_lim_tbt_reg_3_cfm
			Cbx_tq_lim_tsta_0_cfm
			Cbx_tq_lim_vs_ff_actr_0_cfm
			Cbx_tq_lim_vs_ff_fct_0_cfm
			Cbx_tq_lim_vs_ff_fct_5_cfm
			Cbx_tq_lim_vs_fprs_fct_0_cfm
			Cbx_tq_lim_vs_mpl_fail_cfm
			Cbx_tq_lim_vs_sens_rail_2_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_mpl_fail
			Vbx_tq_rams_lim_act_3
			Vbx_tq_rams_lim_act_1
			Vbx_tq_rams_lim_act_2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Gbxlixx
		""
	/begin DEF_CHARACTERISTIC
			Ctp_gear_lim_tq
			Cxx_gear_dft_lim_tq
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_max_gbx_tqe
			Vxx_max_agb_tqe
			Vxx_max_mgb_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Maxtqpr
		""
	/begin DEF_CHARACTERISTIC
			Cmp_n_map_tqi_max_pr
			Cmp_n_ms_tqi_max_cor_pr
			Cbx_it_temp_tqi_max_cor_pr_dsb
			Cbx_n_ms_tqi_max_cor_pr_dsb
			Cmp_n_amp_tqi_max_cor_pr
			Ctp_n_max_tqi_pr
			Ctp_up_it_temp_max_tqi_cor_pr
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vxx_tqi_max_pr' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_tqi_max_rich_pr
			Vxx_tqi_max_tbt_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Maxtqri
		""
	/begin DEF_CHARACTERISTIC
			Cmp_n_map_tqi_max_rij
			Cmp_n_ms_tqi_max_cor_rij
			Ctb_tqi_max_map
			Cmp_n_amp_tqi_max_rij
			Ctp_n_max_tqi_rij
			Ctp_up_it_temp_max_tqi_cor_rij
			Ctb_tqi_max_ms_dp
			Ctb_tqi_max_up_it_temp
			Ctb_eng_amp_2
			Cmp_n_amp_tqi_max_cor_rij
			Cmp_n_map_tqi_rij
			Cbx_it_temp_tqi_max_cor_rij_dsb
			Cbx_n_ms_tqi_max_cor_rij_dsb
			Cxx_map_fil_max_tqi_ftc
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_map_fil_max_tq
			Vxb_n_eng_amp.factor
			Vxb_n_eng_amp.index
			Vxb_n_eng_amp.num_dp
			Vxx_tqi_max_rich_rij
			Vxx_tqi_max_tbt_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Maxtqxx
		""
	/* ASAP2::Database : delete 'Ctp_mat_max_tqi_cor' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/* ASAP2::Database : delete 'Cmp_amp_n_max_tqi_cor' */
	/* ASAP2::Database : delete 'Ctp_n_tqi_dyn_lim' */
	/* ASAP2::Database : delete 'Ctp_n_max_tqi_lih' */
	/* ASAP2::Database : delete 'Ctp_n_max_tqi' */
	/* ASAP2::Database : 4 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cxx_tqi_max_comb_slop
			Cxx_tqe_max_gear_slop_pos
			Cxx_tqe_max_gear_slop_neg
			Cxx_gear_max_tqe_h
			Ctp_n_gear_tqe_max_h
			Ctp_n_gear_tqe_max_l
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vxx_max_tqi' */
	/* ASAP2::Database : delete 'Vxx_max_tqi_alti_mat_cor' */
	/* ASAP2::Database : delete 'Vxx_max_tqi_inj_cut' */
	/* ASAP2::Database : delete 'Vxx_raw_max_tqi' */
	/* ASAP2::Database : 4 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_tqi_max_rich_comb
			Vxx_tqi_max_tbt_comb
			Vbx_tqi_max_slop_on
			Vbx_tqi_max_rich_slop_on
			Vbx_tqi_max_tbt_slop_on
			Vxx_tot_max_avl_tqe
			Vxx_max_avl_tqe
			Vxx_tqe_max_gear
			Vxx_max_dyn_avl_tqe
			Vxx_max_gear_avl_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Ovhtqxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ovh_tco
			Ctb_ovh_n
			Ctb_ovh_toil
			Ctb_ovh_up_it_temp
			Ctb_ovh_vs
			Ctp_temp_ovh_tq
			Cbx_ovh_temp_cfm
			Ctp_tco_ovh_tq
			Cmp_n_vs_ovh_tq_fac
			Ctp_n_ovh_tq_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_ovh_prot_tq
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Protcxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tqi_max_n
			Ctb_tqi_vnt_dft_spg
			Cxx_max_prot_spg_tqe_slop
			Ctp_amp_vnt_diag_tqi_cor
			Cmp_n_map_vnt_diag_tqi
			Ctb_eng_amp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_max_prot_spg_tqe_act
			Vxx_max_prot_spg_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Protqxx
		""
	/* ASAP2::Database : delete 'Ctp_n_min_gas_lim_tq' */
	/* ASAP2::Database : delete 'Cxx_min_gas_dec' */
	/* ASAP2::Database : delete 'Cxx_min_gas_inc' */
	/* ASAP2::Database : 3 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cmp_tqi_max_fuel_temp_n
			Ctb_tqi_max_fuel_temp
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'Vxx_min_fuel' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vxx_max_prot_tqe
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin FUNCTION
		TqLimMxt_Smkppxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_smk_rich_lim_maf_pp
			Ctb_smk_rich_lim_n_pp
			Cmp_smk_rich_lim_cor_pp_1
			Cmp_smk_rich_lim_n_maf_pp
			Ctp_smk_rich_lim_fac_vs_pp
