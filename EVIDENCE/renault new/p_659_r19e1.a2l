    ECU_ADDRESS 0xd0002338 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[2]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[2] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002339 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[3]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[3] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000233a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[4]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[4] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000233b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[5]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[5] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000233c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[6]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[6] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000233d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[7]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[7] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000233e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[8]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[8] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000233f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[9]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[9] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002340 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_slow_driv_spt_fac
		"Driver sportivity factor given by 'slow' adaptation algorithm"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_slow_driv_spt_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002354 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_fim
		"Smoke limitation fuel mass"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_smk_fim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00009d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_fim_bas
		"Smoke limitation fuel mass without over smoke value"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_smk_fim_bas 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000639a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_rich_agb_ofs
		"Richness offset during automatic transmission gearshift"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_rich_agb_ofs 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000639c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_rich_lim
		"Smoke limitation richness without oversmoke offset"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_rich_lim 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000639e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_rich_lim_bas
		"Basic smoke limitation richness"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_rich_lim_bas 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00063a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkppxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_rich_lim_pp
		"Smoke limitation richness for pp mode"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_rich_lim_pp 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00009ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_rich_lim_pr
		"Smoke limitation richness for pr mode"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_rich_lim_pr 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00009cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_rich_lim_rij
		"Smoke limitation richness for normal combustion mode"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_rich_lim_rij 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00009ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_tkof_ofs_pr
		"Richness offset for takeoff on PR combustion mode"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_tkof_ofs_pr 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000637e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_smk_tkof_ofs_rij
		"Richness offset for takeoff on rij combustion mode"
		UWORD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_smk_tkof_ofs_rij 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006396 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_snd_edge_dly
		"EGR by-pass throttle desactivation delay"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_snd_edge_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_spg
		"Boost pressure measurement value."
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_spg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_spg_fail_val
		"Boost pressure default value"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_spg_fail_val 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_spg_reg_apl_down
		"Negative deviation diagnostic criteria"
		UWORD
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_spg_reg_apl_down 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001352 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_spg_reg_apl_up
		"Positive deviation diagnostic criteria"
		UWORD
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_spg_reg_apl_up 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001354 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsnpux_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_spg_sp_npu
		"Boost air pressure setpoint in nox purge mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_spg_sp_npu 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001500 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_spg_sp_pr
		"Boost air pressure setpoint  in regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_spg_sp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001502 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_spg_sp_rij
		"Boost air pressure setpoint in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_spg_sp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000151e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sta_dspl_arw_up_dly
		"Vxx_sta_dspl_arw_up_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002359 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sta_is_fil_fac
		"Variable of transition between Start Torque and Current Torque Set Point of Torque Structure"
		UWORD
		wijukob_vbAeApa_hCDsnsa_n__a40a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_sta_is_fil_fac 
    FORMAT "%11.9" 
    ECU_ADDRESS 0xd00009b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sta_off_ofs
		"Offset (depending coolant temperature) about idle speed setpoint to create start state threshold"
		SWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_sta_off_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00011f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invficri_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sta_stt
		"Starter status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_sta_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001cd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sta_swi_act_ctr
		"Counter : increment at each START button push"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_sta_swi_act_ctr 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sta_tco
		"Starting coolant temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_sta_tco 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007626 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sta_tq
		"Start Torque Set Point"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_sta_tq 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_checkxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sta_tq_raw
		"Raw start torque setpoint"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_sta_tq_raw 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000131a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stab_toil
		"Oil temperature in stabilised conditions"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_stab_toil 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007638 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stal_ac_ant_dsb_n
		"Stalling anticipation engine speed threshold"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_stal_ac_ant_dsb_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00077c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stal_ac_max_pow_ena
		"Consolidated air conditioning maximum power for anti-stall"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_stal_ac_max_pow_ena 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00077c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stal_ac_max_pow_ena_clc
		"Air conditioning maximum power calculated in anti-stall strategy"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_stal_ac_max_pow_ena_clc 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00077c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stal_ac_max_tq
		"Air conditioning maximum torque calculated in anti-stall strategy"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_stal_ac_max_tq 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00077ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stal_ac_max_tq_clc
		"Air conditioning maximum torque calculated from proportional and derivative corrections in anti-stall strategy"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_stal_ac_max_tq_clc 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00077cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stal_acs_dsb_dly
		"Timer to leave stalling states in anti-stall strategy"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_stal_acs_dsb_dly 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00077ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_stal_acs_dsb_n
		"Stalling engine speed threshold"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_stal_acs_dsb_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00077d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_step_mv
		"mean value step"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_step_mv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006304 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_swa_ecu_stt
		"State of Steering Wheel Angle Control Unit for CAN failure detection."
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_swa_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_swa_ecu_stt_ctr
		"Steering Wheel Angle Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swa_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_swa_ecu_stt_ctr_mem_dec
		"SWA current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swa_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_swa_ecu_stt_ctr_mem_prev
		"SWA current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swa_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_swa_ecu_stt_diag
		"State of Steering Wheel Angle Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swa_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swi_cut_n_ofs
		"switch of injection cut engine speed offset"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_swi_cut_n_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000a00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swi_drv_cut_n_ofs
		"switch of derivate injection cut offset"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_swi_drv_cut_n_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000a02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swi_fil_fac
		"Torque slope limitation for re-injection"
		UWORD
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_swi_fil_fac 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001296 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swlk_diag_1
		"Byte used to allow Immobiliser diagnosis"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swlk_diag_1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swlk_diag_2
		"Byte used to allow Immobiliser diagnosis"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swlk_diag_2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swlk_diag_3
		"Byte used to allow Immobiliser diagnosis"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swlk_diag_3 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swlk_key_mem_stt
		"secret key memory area"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_swlk_key_mem_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000b2b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_swlk_nok_id_ctr
		"False authentications counter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_swlk_nok_id_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_t_acq_tenv
		"Number of time steps before the acquisition of tenv"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_t_acq_tenv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_ant
		"Vxx_t_ant"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0001d97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_cur
		"Vxx_t_cur"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0001d8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_fast_off
		"Vxx_t_fast_off"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002363 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_max_arw_down
		"Vxx_t_max_arw_down"
		UWORD
		VA_F_0v02_p0_4
		2
		100
		0
		1310.7
    ECU_ADDRESS 0xd000772a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_max_arw_up
		"Vxx_t_max_arw_up"
		UWORD
		VA_F_0v02_p0_4
		2
		100
		0
		1310.7
    ECU_ADDRESS 0xd000772c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_max_cur
		"Vxx_t_max_cur"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0001d90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_min_arw_down
		"Vxx_t_min_arw_down"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd000235a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_min_arw_up
		"Vxx_t_min_arw_up"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd000235b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_no_pdl
		"Vxx_t_no_pdl"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002364 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_no_seq_down_shf
		"Vxx_t_no_seq_down_shf"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0001d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_no_seq_up_shf
		"Vxx_t_no_seq_up_shf"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0001d99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_t_ovn
		"Value of th time delay to avoid the ear to be saturated in case of overrun conditions"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_t_ovn 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001584 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_rest_arw_down
		"Vxx_t_rest_arw_down"
		UWORD
		VA_F_0v02_p0_4
		2
		100
		0
		1310.7
    ECU_ADDRESS 0xd000772e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_rest_arw_up
		"Vxx_t_rest_arw_up"
		UWORD
		VA_F_0v02_p0_4
		2
		100
		0
		1310.7
    ECU_ADDRESS 0xd0007730 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_sta_arw_down
		"Vxx_t_sta_arw_down"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd000235c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_sta_arw_up
		"Vxx_t_sta_arw_up"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd000235d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_t_step
		"Time step used in criteria calculation stateflow to decrease timers"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_t_step 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_up_shf_dly
		"Vxx_t_up_shf_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002365 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_t_wait_tra_acel_vld
		"Timer to wait the convergence of the filters"
		UBYTE
		xjpwlzd_oiewmrb_devberc_s_R0ooa
		1
		100
		0.
		5.1
    DISPLAY_IDENTIFIER Vxx_t_wait_tra_acel_vld 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001ceb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tac_tout_timer
		"Timeout timer"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tac_tout_timer 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0000d42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_acclumd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tair_ext
		"Environmental temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tair_ext 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001922 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtcsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt
		"Measured temperature before turbine"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000761c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_adv_cor
		"Main injection advance correction"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_tbt_adv_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_advsatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_adv_max_cor
		"Maximal advance correction of the main injection"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_tbt_adv_max_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001708 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_adv_max_cor_pr
		"Maximal advance correction of the main injection in PR mode"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_tbt_adv_max_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000afa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_advsatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_adv_min_cor
		"Minimal advance correction of the main injection"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_tbt_adv_min_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000170a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_adv_min_cor_pr
		"Minimal advance correction of the main injection in PR mode"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_tbt_adv_min_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000afc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_conv
		"Exhaust gas temperature pre turbine converted in Kelvin"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_tbt_conv 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_regfacx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_dg_fac
		"D part gain"
		UWORD
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_dg_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007a3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_dg_fac_pr
		"D part gain in PR mode"
		UWORD
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_dg_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00066b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_dg_fac_rij
		"D part gain in RIJ mode"
		UWORD
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_dg_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00066ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_dg_reg_out
		"Final output value of the D part regulator"
		SLONG
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_dg_reg_out 
    FORMAT "%12.3" 
    ECU_ADDRESS 0xd00050a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_err
		"Limited temperature loop deviation"
		UWORD
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_err 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00066d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_err_ulim
		"Unlimited temperature loop deviation"
		UWORD
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_err_ulim 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00066dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_err_ulim_dif_pr
		"Temperature loop deviation (t) -Temperature loop deviation (t-1) in PR mode"
		UWORD
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_err_ulim_dif_pr 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00066b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_err_ulim_dif_rij
		"Temperature loop deviation (t) -Temperature loop deviation (t-1) in RIJ mode"
		UWORD
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_err_ulim_dif_rij 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00066c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fim_main_cor
		"Main injection fuel quantity correction"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fim_main_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fmisatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fim_main_max_cor
		"Maximal fuel mass quantity correction for main injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fim_main_max_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001720 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fim_main_max_cor_pr
		"Maximal fuel mass quantity correction for main injection in PR mode"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fim_main_max_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000afe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fim_main_max_cor_rij
		"Maximal fuel mass quantity correction for main injection in RIJ mode"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fim_main_max_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fmisatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fim_main_min_cor
		"Minimal fuel mass quantity correction for main injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fim_main_min_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001722 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fim_main_min_cor_pr
		"Minimal fuel mass quantity correction for main injection in PR mode"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fim_main_min_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fim_main_min_cor_rij
		"Minimal fuel mass quantity correction for main injection in rij mode"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fim_main_min_cor_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fpo_cor
		"Fuel mass quantity correction of the post injection"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fpo_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fposatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fpo_max_cor
		"Maximal correction for the post injection quantity"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fpo_max_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001738 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fpo_max_cor_pr
		"Maximal fuel mass quantity correction for the post injection in PR mode"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fpo_max_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fposatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fpo_min_cor
		"Minimal correction for the post injection quantity"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fpo_min_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000173a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_fpo_min_cor_pr
		"Minimal fuel mass quantity correction for the post injection in PR mode"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_fpo_min_cor_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000b04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_regfacx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_ig_fac
		"I part gain"
		UWORD
		rEBznhd_Dkorjta_Aqgesjb_1CC_1o0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_ig_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007a3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_ig_fac_pr
		"I part gain in PR mode"
		UWORD
		rEBznhd_Dkorjta_Aqgesjb_1CC_1o0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_ig_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00066b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_ig_fac_rij
		"I part gain in RIJ mode"
		UWORD
		rEBznhd_Dkorjta_Aqgesjb_1CC_1o0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_ig_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00066bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_ig_reg
		"Output value of the I part regulator"
		SLONG
		kmtvsEa_tEilDdc_jbmwFrb_n_99870
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_ig_reg 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd00050a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_ig_reg_out
		"Final output value of the I part regulator"
		SLONG
		kmtvsEa_tEilDdc_jbmwFrb_n_99870
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_ig_reg_out 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd00050ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_max_tqi_cor
		"Max inner torque correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_tbt_max_tqi_cor 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000b46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tqisatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_max_tqi_min_cor
		"Minimal correction of the max inner torque"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_tbt_max_tqi_min_cor 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000b52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_max_tqi_min_cor_pr
		"Minimal correction of the max inner torque in PR mode"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_tbt_max_tqi_min_cor_pr 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000b06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_max_tqi_min_cor_rij
		"Minimal correction of the max inner torque in RIJ mode"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_tbt_max_tqi_min_cor_rij 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000b38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_regfacx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_pg_fac
		"P part gain"
		UWORD
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_pg_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007a40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_pg_fac_pr
		"P part gain in PR mode"
		UWORD
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_pg_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00066b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_pg_fac_rij
		"P part gain in RIJ mode"
		UWORD
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tbt_pg_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00066be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_pg_reg_out
		"Final output value of the P part regulator"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_pg_reg_out 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_pid_out
		"Final output value of the PID regulator"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_pid_out 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_pid_reg
		"Sum of P, I and D parts regulators"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tbt_pid_reg 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_spunfil_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_sp
		"Unfiltered value of the tbt setpoint"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_sp_fil
		"Filtered value of the target temperature before turbine"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_sp_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00066d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_sp_pr
		"Unfiltered value of the tbt setpoint in PR mode"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_sp_pr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00066b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tbt_sp_rij
		"Unfiltered value of the tbt setpoint in RIJ mode"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_tbt_sp_rij 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00066c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco
		"Engine coolant temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000dd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_agb_min_is_n
		"Nominal idle speed setpoint under drive or drag reduction mode"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_tco_agb_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007744 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_alcoxxx_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_amp_min_is_n_alco
		"Idle speed setpoint according to the engine coolant temperature and atmospheric pressure in alcohol configuration"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_tco_amp_min_is_n_alco 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000194a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tco_cata
		"Local engine coolant temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_cata 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007906 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tco_clc
		"Engine coolant temperature calculated"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_clc 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000769e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_ctr
		"Vxx_tco_ctr"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0002368 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_dif
		"Delta between water temperature and reference water temperature in running conditions."
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_dif 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000763a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tco_ena
		"Engine coolant temperature for strategy need"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_ena 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007a28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_fil
		"Filtered coolant temperature for oil temperature computing"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_fil 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000763c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_ini
		"Initial value of engine coolant temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_ini 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0006b88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_ptissxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tco_is_n_ofs
		"Engine warm-up idle speed setpoint offset"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_tco_is_n_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007778 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_min_is_n
		"Nominal idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_tco_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00009aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcoospt_cteaubc_data.c' */
/begin MEASUREMENT
		Vxx_tco_sp
		"Water temperature set point for controlled thermostat."
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_sp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000676c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_sp_min_is_n
		"Arbitrated decrease slope applied to the current arbitrated idle speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_tco_sp_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00009a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_tceauxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tco_sp_mux
		"Water temperature set point for controlled thermostat on MUX"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_tco_sp_mux 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000201b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tco_temp
		"Timer for temporization in check_temperature state"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tco_temp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007922 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_synchro_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tdc_ctr
		"TDC counter, indicates wich cylinder is active"
		UBYTE
		FrDdxAd_gBlBhnd_wuyyxkd_T_A_1oa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_tdc_ctr 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ccd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tdc_per
		"tdc period (32bits)"
		ULONG
		rzcztbb_Agrdkud_Abvlbcc_s__300a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_tdc_per 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0004a0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_temp_cor_egrless
		"Temperature correction coefficient"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_temp_cor_egrless 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000755e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_temp_frst_edge_bfr
		"Temperature downstream the EGR cooler before by-pass throttle activation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_temp_frst_edge_bfr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_temp_frst_edge_dif
		"Delta temperature downstream the EGR cooler on by-pass activation"
		SWORD
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_temp_frst_edge_dif 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0000a5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_temp_init
		"Initial value of the corrected intake air temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_temp_init 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_temp_snd_edge_aftr
		"Temperature downstream the EGR cooler after by-pass throttle desactivation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_temp_snd_edge_aftr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_temp_snd_edge_dif
		"Delta temperature downstream the EGR cooler on by-pass desactivation"
		SWORD
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_temp_snd_edge_dif 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0000a60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_temp_sp
		"CSF up temp set point"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_temp_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006468 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tenvxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tenv
		"Environmental temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tenv 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000756c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_n
		"Alternator speed"
		ULONG
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		65534.75
    DISPLAY_IDENTIFIER Vxx_thpl_alt_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000520c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_pwm_dif
		"Difference between alt PWM before and after the THP activation"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_thpl_alt_pwm_dif 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000231c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_pwm_err_lim_reg
		"Limited and Filtered error of alternator PWM balance governor (after deadzone)"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_thpl_alt_pwm_err_lim_reg 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00077de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_pwm_err_reg
		"Error of alternator PWM balance governor"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_thpl_alt_pwm_err_reg 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00077e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_pwm_reg
		"Alternator PWM governor output"
		SLONG
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_thpl_alt_pwm_reg 
    FORMAT "%12.3" 
    ECU_ADDRESS 0xd0005210 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_pwm_reg_ig
		"Alternator PWM governor integral gain"
		UWORD
		kwurkla_ttkCtib_tonninb_1aC_1a0
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_thpl_alt_pwm_reg_ig 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00077e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_pwm_reg_pg
		"Alternator PWM governor proportional gain"
		UWORD
		BtFhkBa_DFkireb_EeDBpgd_1__000a
		1
		100
		0.
		0.5
    DISPLAY_IDENTIFIER Vxx_thpl_alt_pwm_reg_pg 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00077e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_alt_pwm_sp
		"Alternator pwm setpoint for THP regulation"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_thpl_alt_pwm_sp 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0002389 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_cmd_nr
		"Number of required coolant heaters"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_cmd_nr 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002388 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_cmd_ref
		"Number of coolant heater activated with delay"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_cmd_ref 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000230b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_cnt_cf
		"Connectors confirmed values (3)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_cnt_cf 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000231d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_diag_alt_pwm_dif_mv
		"Mean value of Alt PWM difference for THP Diagnostic"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_thpl_diag_alt_pwm_dif_mv 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000231e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_fedg_lvl
		"Number of activated THP following a falling edge."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_fedg_lvl 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000231f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_lvl_cf
		"Levels of confirmed failure (4)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vxx_thpl_lvl_cf 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0002320 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_min_is_n
		"thermoplunger idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_thpl_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000775c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_nr
		"Authorized number of coolant heaters"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_nr 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002116 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_nr_on
		"Number of coolant heater element activated"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_nr_on 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002321 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_nr_on_ena
		"Number of coolant heater element activated, enabled if Vxx_alt_pwm is valid"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_nr_on_ena 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002322 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_ofs
		"Number of THP to activate with delay"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_ofs 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000230c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_reg
		"THP governor output"
		SLONG
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_thpl_reg 
    FORMAT "%12.3" 
    ECU_ADDRESS 0xd0005214 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_tqi_nr
		"Authorized number of coolant heaters for torque request"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_thpl_tqi_nr 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002037 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_vb_dif
		"Difference between battery voltage before and after the THPL activation"
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_thpl_vb_dif 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00076b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_vb_err_lim_reg
		"Limited and filtered error of voltage balance governor"
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_thpl_vb_err_lim_reg 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00077e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_vb_err_reg
		"Filtered error of voltage balance governor"
		SWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		-30.
		30.
    DISPLAY_IDENTIFIER Vxx_thpl_vb_err_reg 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00077e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_vb_reg
		"Voltage governor output"
		SLONG
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_thpl_vb_reg 
    FORMAT "%12.3" 
    ECU_ADDRESS 0xd0005218 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_vb_reg_ig
		"Voltage governor integral gain"
		UWORD
		obckiAc_Dodygqd_swoAikd_1aCR1a0
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_thpl_vb_reg_ig 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00077ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_vb_reg_pg
		"Voltage governor proportional gain"
		UWORD
		tjaueDb_oDycymc_yApmcia_1__000a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_thpl_vb_reg_pg 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00077ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_thpl_vb_sp
		"Voltage setpoint for THP regulation"
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_thpl_vb_sp 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd00077ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia
		"Intake air temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_cata
		"Intake air temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_cata 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007908 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_conv
		"Temperature field induction system converted in Kelvin"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		473.
    DISPLAY_IDENTIFIER Vxx_tia_conv 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_cor
		"Corrected air intake temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_cor 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_cor_1
		"Air intake temperature after speed correction"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_cor_1 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_cor_ctl
		"Flag of the state of the tia correction controller"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_tia_cor_ctl 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001bf7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_cor_ctr
		"Value of the delay's counter in the tia correction controller"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_tia_cor_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_ena
		"Intake air temperature for strategy need"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_ena 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007a2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_ex_sp_pr
		"Intake air temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_ex_sp_pr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007820 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_ex_sp_rij
		"Intake air temperature."
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_ex_sp_rij 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007834 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_ol_spg_pr
		"Intake air temperature after consolidation for supercharger open loop in PR mode"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_ol_spg_pr 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd00013f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_ol_spg_rij
		"Intake air temperature after consolidation for supercharger open loop in RIJ mode"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_ol_spg_rij 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001408 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_reg
		"Local intake air temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_reg 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000644e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_spg_sp_max
		"Intake air temperature after specific boost pressure control strategy consolidation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_spg_sp_max 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000a42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_spg_sp_pr
		"Intake air temperature used for spg sp corrections"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_spg_sp_pr 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001504 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_spg_sp_rij
		"Intake air temperature after consolidation for supercharger setpoint in RIJ mode"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_spg_sp_rij 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0001520 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tia_temp
		"Timer for temporization in check_temperature state"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_tia_temp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007924 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd.c' */
/begin MEASUREMENT
		Vxx_timeout
		"Byte 4 of the request"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_timeout 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019c1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_acs_dsb_vs
		"Vehicle speed for takeoff strategy"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_tkof_acs_dsb_vs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00077d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_fac
		"Take off assistance factor"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_tkof_ass_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002021 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_h_vs_mv
		"High vehicle speed average"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_tkof_ass_h_vs_mv 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000630e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_h_vs_mv_fac
		"High vehicle speed average factor"
		UBYTE
		sDwtuec_riAActa_vnpvdDd_ri__50a
		1
		100
		0.
		5.1
    DISPLAY_IDENTIFIER Vxx_tkof_ass_h_vs_mv_fac 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0002022 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_l_vs_mv
		"Low vehicle speed average"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_tkof_ass_l_vs_mv 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006310 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_l_vs_mv_fac
		"Low vehicle speed average factor"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_tkof_ass_l_vs_mv_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002023 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_mv_vs_fac
		"Driving behavior factor"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_tkof_ass_mv_vs_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002024 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_spt_pdl_fac
		"Sportivity take off factor"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_tkof_ass_spt_pdl_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002025 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_ass_vs
		"Vehicle speed inhibited if rear gear or neutral gear are selected"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_tkof_ass_vs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006312 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_tenv_amp_fac
		"Environmental conditions (temperature and pressure) factor"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_tkof_tenv_amp_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002026 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_tkocoxx_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_tkof_tqe_cor
		"take off torque correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_tkof_tqe_cor 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0000998 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tmp_pri
		"Temporary failure calculated priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_tmp_pri 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002283 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_togl_ctr
		"Counter to detect toggling effect"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_togl_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_togl_tmr
		"Timer to detect toggling effect"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		2.55
    DISPLAY_IDENTIFIER Vxx_togl_tmr 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001d85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_toil
		"Oil temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_toil 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007632 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_toil_is_n_ofs
		"High oil temperature protection idle speed setpoint offset"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_toil_is_n_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007750 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_toil_pws_max_dly
		"Remaining duration after engine stall of maintain of the calculation of the oil temperature."
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_toil_pws_max_dly 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000763e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tot_max_avl_tqe
		"Maximum effective engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_tot_max_avl_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tout
		"Output of the timer"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tout 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00076b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tq_dif
		"Vxx_tq_dif"
		SWORD
		VA_F_1_p0_5
		2
		100
		-32768
		32767
    ECU_ADDRESS 0xd00010ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tq_dif_esti_tqe_fil
		"Vxx_tq_dif_esti_tqe_fil"
		UWORD
		VA_F_0v03125_m400_13
		2
		100
		-400
		1647.96875
    ECU_ADDRESS 0xd00010fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tq_dif_fil
		"Vxx_tq_dif_fil"
		SWORD
		VA_F_1_p0_5
		2
		100
		-32768
		32767
    ECU_ADDRESS 0xd00010f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqe_ini_i
		"Initial Value of Idle Speed regulator integral torque correction (in ast and cdn states)"
		SLONG
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		1
		100
		-1024.
		1023.999996875
    DISPLAY_IDENTIFIER Vxx_tqe_ini_i 
    FORMAT "%12.6" 
    ECU_ADDRESS 0xd0004ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqe_max_gear
		"Maximum effective engine torque in function of the gearbox"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_tqe_max_gear 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_aftrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_aftr_efy
		"After injection relative efficiency"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_aftr_efy 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_aftr_efy_npu
		"Corrected after injection relative efficiency in npu mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_aftr_efy_npu 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0002033 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_aftr_efy_spu
		"Corrected after injection relative efficiency in spu mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_aftr_efy_spu 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0002034 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_fac_ocd
		"Corrections for late post torque model in ocd mode"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_fac_ocd 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_fil_ocd
		"Torque compensation filtered value in ocd mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_cor_fil_ocd 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_fim_tot_npu
		"Total fuel quantity in npu mode"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_fim_tot_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00063a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_fim_tot_ocd
		"Total fuel quantity in ocd mode"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_fim_tot_ocd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00012b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_fim_tot_pr
		"Total fuel quantity in pr mode"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_fim_tot_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00012c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_fim_tot_rij
		"Total fuel quantity in rij mode"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_fim_tot_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00012cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_fim_tot_spu
		"Total fuel quantity in spu mode"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_fim_tot_spu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00063a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_ocd
		"Torque compensation value in ocd mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_cor_ocd 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_post_efy_npu
		"Corrected post injection relative efficiency in npu mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_post_efy_npu 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0002035 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_post_efy_pr
		"Corrected post injection relative efficiency in pr mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_post_efy_pr 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_cor_post_efy_spu
		"Corrected post injection relative efficiency in spu mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_cor_post_efy_spu 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0002036 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_err
		"Tqi error"
		UWORD
		zbhcjic_qmhpFyc_chelcsd_N__338a
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_tqi_err 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00063ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_fim_tot
		"Total fuel quantity"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_tqi_fim_tot 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00009ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_fim_tot_cor_pr
		"Fuel quantity correction for torque model corrections in pr mode"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_fim_tot_cor_pr 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_fim_tot_cor_rij
		"Fuel quantity correction for torque model corrections in rij mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_fim_tot_cor_rij 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_maf_err_fil_ocd
		"Filtered mass air flow deviation for calculation of torque compensation in ocd mode"
		UWORD
		tClffab_hirDflc_mxtqjrd_mtA_o00
		1
		100
		-3000.
		3000.
    DISPLAY_IDENTIFIER Vxx_tqi_maf_err_fil_ocd 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd00012be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_fim
		"Maximum torque due to maximum injected fuel mass"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_fim 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_fim_npu
		"Maximum torque due to maximum injected fuel mass in npu mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_fim_npu 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00063aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_fim_pr
		"Maximum torque due to maximum injected fuel mass in pr mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_fim_pr 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_fim_rij
		"Maximum torque due to maximum injected fuel mass in rij mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_fim_rij 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_fim_spu
		"Maximum torque due to maximum injected fuel mass in spu mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_fim_spu 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00063ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_rich_comb
		"Maximum inner torque for richness after the combustion mode change"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_rich_comb 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_rich_pr
		"Maximum inner torque for richness in regeneration mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_rich_pr 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_rich_rij
		"Maximum inner torque for richness in normal mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_rich_rij 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007786 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_tbt_comb
		"Maximum inner torque for TBT after the combustion mode change"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_tbt_comb 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_tbt_pr
		"Maximum inner torque for TBT in regeneration mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_tbt_pr 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_max_tbt_rij
		"Maximum inner torque for TBT in normal mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_max_tbt_rij 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007788 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_ovn
		"Torque threshold for the definition of overrun"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_ovn 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001586 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_post_efy
		"Post injection relative efficiency"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_post_efy 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_post_efy_cor_pr
		"Post efficiency correction in pr mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_post_efy_cor_pr 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_post_efy_phi_cor_pr
		"Post efficiency correction f(diff between current and basic post timing) in pr mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_post_efy_phi_cor_pr 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_post_efy_ti_dif_cor_pr
		"Post efficiency correction f(diff between post and last injection timing) in pr mode"
		UBYTE
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_tqi_post_efy_ti_dif_cor_pr 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0001e27 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_rat_tgt
		"Final indicated target torque ratio"
		UWORD
		wijukob_vbAeApa_hCDsnsa_n__a40a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_tqi_rat_tgt 
    FORMAT "%11.9" 
    ECU_ADDRESS 0xd00009f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_raw
		"final indicated torque raw"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_raw 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_smk
		"Smoke limitation torque"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_smk 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_smk_npu
		"Limitation torque smoke limit in npu mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_smk_npu 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00063a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_smk_pr
		"Limitation torque smoke limit in pr mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_smk_pr 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_smk_rij
		"Limitation torque smoke limit in rij mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_smk_rij 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00012d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_smk_spu
		"Limitation torque smoke limit in spu mode"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_smk_spu 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00063a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_sp
		"Final indicated torque set point"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_sp_no_ajs
		"Final indicated torque set point without AJCOR correction"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_sp_no_ajs 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_t_fil_ocd
		"Low pass filter time constant for torque model filtration in ocd mode"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tqi_t_fil_ocd 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00012c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_tgt
		"Final indicated target torque"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tqi_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_thpl_err_lim
		"Tqi limited error for thpl (after deadzone)"
		UWORD
		zbhcjic_qmhpFyc_chelcsd_N__338a
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_tqi_thpl_err_lim 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00063b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tqi_thpl_gov
		"output of the tqi thpl governor"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_tqi_thpl_gov 
    FORMAT "%4.3" 
    ECU_ADDRESS 0xd00063b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tqi_tpo_dif_pr
		"Difference between current and basic post timing in pr mode"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_tqi_tpo_dif_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001306 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_rubtqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tql_eng_frn
		"Engine rubbing torque losses"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_tql_eng_frn 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tra_acel
		"Transverse acceleration"
		SLONG
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_tra_acel 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0004a14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tra_acel_abs
		"Vxx_tra_acel_abs"
		UWORD
		VA_F_0v0004_p0_1
		2
		100
		0
		26.214
    ECU_ADDRESS 0xd00010a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tra_acel_abs_vld
		"Vxx_tra_acel_abs_vld"
		UWORD
		VA_F_0v0004_p0_1
		2
		100
		0
		26.214
    ECU_ADDRESS 0xd00010a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_tra_acel_mv
		"Temporal average of the transverse acceleration"
		SLONG
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_tra_acel_mv 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0004a28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_ttcfmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tt
		"Temperature next to turbine"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_tt 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007608 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tt_clc
		"Measured temperature before turbine calculated"
		UWORD
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		1
		100
		0.
		1200.
    DISPLAY_IDENTIFIER Vxx_tt_clc 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00076a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tt_fms_bas
		"Considering the operating point (N,Tqi), DOC up temp for the basic engine settings"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_tt_fms_bas 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006424 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tt_fms_bas_ftc
		"DOC up temp filtering time constant"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_tt_fms_bas_ftc 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006426 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tt_fms_pft_utp_fac
		"DOC up temp / CSF up temp current gain"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tt_fms_pft_utp_fac 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006428 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_tt_k
		"CSF upstream temperature in Kelvin"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_tt_k 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007606 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ttr_diff_cmd_sat
		"Difference between the limited and the not limited command"
		SWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_ttr_diff_cmd_sat 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_up_cool_spg_prs
		"Upstream supercharger cooler pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_up_cool_spg_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_up_cpr_prs
		"Upstream compressor pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_up_cpr_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000da6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_up_it_temp
		"Upstream throttle temperature measurement value"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_up_it_temp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_up_rat_gear_bkp_tgt
		"Up limit of true range for the current anticipated ratio gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_up_rat_gear_bkp_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001920 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_up_shf_no_seq_dly
		"Vxx_up_shf_no_seq_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0001d9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ups_lamb
		"Lambda value upstream of the NOxTrap"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-32.768
		32.767
    DISPLAY_IDENTIFIER Vxx_ups_lamb 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd0000dc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ups_lamb_clc
		"Calculated lambda"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-32.768
		32.767
    DISPLAY_IDENTIFIER Vxx_ups_lamb_clc 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd0000dc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ups_rich
		"Upstream proportional sensor richness"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_ups_rich 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000dc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ups_rich_clc
		"Calculated richness"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_ups_rich_clc 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_usm_ecu_stt
		"State of USM Control Unit for CAN failure detection"
		UBYTE
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_usm_ecu_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_usm_ecu_stt_ctr
		"USM Control Unit counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_usm_ecu_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aa1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_usm_ecu_stt_ctr_mem_dec
		"USM : current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_usm_ecu_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_usm_ecu_stt_ctr_mem_prev
		"USM : current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_usm_ecu_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aa3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_usm_ecu_stt_diag
		"State of USM Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_usm_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vb
		"Battery voltage"
		UWORD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		1
		100
		0.
		60.
    DISPLAY_IDENTIFIER Vxx_vb 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000e6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vh_dist_buf_2
		"milleage of the deactivation or activation stored in RAM in the second buffer"
		ULONG
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_vh_dist_buf_2 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004bcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dgtdvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vh_dist_l_res
		"Total vehicle distance with low resolution"
		UWORD
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		1
		100
		0.
		1048560.
    DISPLAY_IDENTIFIER Vxx_vh_dist_l_res 
    FORMAT "%7.0" 
    ECU_ADDRESS 0xd0007660 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_amp_bas_pr
		"Basic atmopheric correction for open loop value for regeneration operation"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_amp_bas_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00013f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_amp_bas_rij
		"Atmospheric pressure correction offset for vnt control value"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_amp_bas_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000140a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_amp_fac_pr
		"Correction factor of atmospheric pressure correction of open loop value during regeneration mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_amp_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_amp_fac_rij
		"Atmospheric pressure correction factor for vnt control value"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_amp_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000140c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_amp_pr
		"Atmospheric pressure correction for vnt control value for regeneration"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_amp_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00013f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_amp_rij
		"Atmospheric pressure correction for vnt control value in regular injection mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_amp_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000140e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_bas_amp_pr
		"Vnt control value corrected by atmospheric pressure in regeneration mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_bas_amp_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_bas_amp_rij
		"Vnt control value corrected by atmospheric pressure"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_bas_amp_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001410 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_bas_pr
		"Basic open loop value for regeneration mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_bas_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_bas_rij
		"Basic vnt control value"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_bas_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001412 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_ex_lim_ex_df_pr
		"Specific control value correction in case of exhaust pressure sensor limphome in pr mode."
		SWORD
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_ex_lim_ex_df_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00077f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_ex_lim_ex_df_rij
		"Specific control value correction in case of exhaust pressure sensor limphome in rij mode."
		SWORD
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_ex_lim_ex_df_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00077fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcnr_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_npu
		"Vnt open loop value for nox purge mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_pft_ofs
		"Offset correction on ctl pwm due to soot mass load in CSF"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_pft_ofs 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00077fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_pft_ofs_pr
		"Offset correction on ctl pwm due to soot mass load in CSF during PR modes."
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_pft_ofs_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00077fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_pr
		"Vnt open loop value for regeneration mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_pwm
		"Vnt open loop pwm signal"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_pwm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_rij
		"Vnt open loop value for regular injection mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001426 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tco_bas_rij
		"Engine coolant temperature basic correction for vnt control value"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tco_bas_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001414 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tco_fac_rij
		"Engine coolant temperature correction factor for vnt control value in regular injection mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tco_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001416 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tco_rij
		"Coolant temperature correction for vnt control value"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tco_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001418 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tia_bas_pr
		"Intake air temperature basic correction for vnt control value in regeneration mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tia_bas_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00013fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tia_bas_rij
		"Intake air temperature basic correction for vnt control value"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tia_bas_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000141a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tia_fac_pr
		"Intake air temperature correction factor for vnt control value for regeneration"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tia_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tia_fac_rij
		"Intake air temperature correction factor for vnt control value"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tia_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000141c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tia_pr
		"Intake air temperature correction for vnt control value in regeneration mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tia_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001400 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tia_rij
		"Intake air temperature correction for vnt control value in regular injection mode"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tia_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000141e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tkof_bas_pr
		"Take off assistance basic correction for vnt control value in regeneration mode"
		SWORD
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tkof_bas_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001402 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tkof_bas_rij
		"Take off assistance basic correction for vnt control value in regular injection mode"
		SWORD
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tkof_bas_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001420 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tkof_fac_pr
		"Take off assistance correction factor for vnt control value for regeneration"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tkof_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001404 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tkof_fac_rij
		"Take off assistance correction factor for vnt control value in regular injection mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tkof_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001422 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tkof_pr
		"Take off assistance for vnt control value in regeneration mode"
		SWORD
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tkof_pr 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001406 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ctl_tkof_rij
		"Take off assistance for vnt control value in regular injection mode"
		SWORD
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_ctl_tkof_rij 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001424 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_dev_int
		"Integration value of the criteria"
		UWORD
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_vnt_dev_int 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0001348 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy
		"Input of membership functions for derivative error"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-1.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000149c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_neg
		"Ouput of negative membership function for the derivative error"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_neg 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000149e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_neg_typ_1
		"Output of negative membership function for the derivative error gear type 1"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_neg_typ_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_neg_typ_2
		"Ouput of negative membership function for the derivative error gear type 2"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_neg_typ_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_neg_typ_3
		"Ouput of negative membership function for the derivative error gear type 3"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_neg_typ_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_nul
		"Ouput of zero membership function for the derivative error"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_nul 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_nul_typ_1
		"Ouput of zero membership function for the derivative error gear type 1"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_nul_typ_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_nul_typ_2
		"Ouput of zero membership function for the derivative error gear type 2"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_nul_typ_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_nul_typ_3
		"Ouput of zero membership function for the derivative error gear type 3"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_nul_typ_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_pos
		"Ouput of positive membership function for the derivative error"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_pos 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_pos_typ_1
		"Ouput of positive membership function for the derivative error gear type 1"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_pos_typ_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_pos_typ_2
		"Ouput of positive membership function for the derivative error gear type 2"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_pos_typ_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_drv_fzy_pos_typ_3
		"Ouput of positive membership function for the derivative error gear type 3"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_drv_fzy_pos_typ_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy
		"Input of membership functions for error"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-1.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00014b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_neg
		"Ouput of negative membership function for the error"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_neg 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_neg_typ_1
		"Ouput of negative membership function for the error gear type 1"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_neg_typ_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_neg_typ_2
		"Ouput of negative membership function for the error gear type 2"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_neg_typ_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_neg_typ_3
		"Ouput of negative membership function for the error gear type 3"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_neg_typ_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_nul
		"Ouput of zero membership function for the error"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_nul 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_nul_typ_1
		"Ouput of zero membership function for the error gear type 1"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_nul_typ_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_nul_typ_2
		"Ouput of zero membership function for the error gear type 2"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_nul_typ_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_nul_typ_3
		"Ouput of zero membership function for the error gear type 3"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_nul_typ_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_pos
		"Ouput of positive membership function for the error"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_pos 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_pos_typ_1
		"Ouput of positive membership function for the error gear type 1"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_pos_typ_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_pos_typ_2
		"Ouput of positive membership function for the error gear type 2"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_pos_typ_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_err_fzy_pos_typ_3
		"Ouput of positive membership function for the error gear type 3"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_err_fzy_pos_typ_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_ex_dev_int
		"Integration value of the exhaust pressure criteria"
		UWORD
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_vnt_ex_dev_int 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000134a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_i_raw_neg
		"Raw factor of I part in the negative window"
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		1.25
    DISPLAY_IDENTIFIER Vxx_vnt_i_raw_neg 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_i_raw_pos
		"Raw factor of I part in the positive window"
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		1.25
    DISPLAY_IDENTIFIER Vxx_vnt_i_raw_pos 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_i_raw_sig
		"Raw factor of I part in the window"
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		1.25
    DISPLAY_IDENTIFIER Vxx_vnt_i_raw_sig 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_inf_1
		"Inference rule 1"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_inf_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_inf_2
		"Inference rule 2"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_inf_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_inf_3
		"Inference rule 3"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_inf_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_inf_4
		"Inference rule 4"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_inf_4 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_inf_5
		"Inference rule 5"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_inf_5 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_inf_6
		"Inference rule 6"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_inf_6 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_inf_7
		"Inference rule 7"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_inf_7 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00014dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_lih_pwm
		"Vnt pwm in limphome mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_lih_pwm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_off_t
		"Time Threshold value to  desactivate transient for vnt"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_vnt_off_t 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_off_thd
		"Threshold value to desactivate transient for vnt"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_off_thd 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_on_thd
		"Threshold value to activate transient for vnt"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_on_thd 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_pwm
		"Vnt pwm signal"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_pwm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000906 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_pwm_conv
		"correcting variable for boost pressure actuator"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_pwm_conv 
    FORMAT "%2.4" 
    ECU_ADDRESS 0xd00075f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_pwm_raw
		"Vnt pwm signal before battery voltage correction"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_pwm_raw 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_fac
		"Formatting factor correction gain"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001360 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_fac_npu
		"Formatting factor correction gain in nox purge mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_fac_npu 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000136c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_fac_pr
		"Formatting factor correction gain in pr mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000136e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_fac_rij
		"Formatting factor correction gain in rij mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001370 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_fmt
		"The ouput of the fuzzy governor after formatting"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_fmt 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00014de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_max
		"Maximum ouput of fuzzy governor"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_max 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00014e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_min
		"Minimum ouput of fuzzy governor"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_min 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00014e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_dfz_out
		"The ouput of the fuzzy governor"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-1.
		1.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_dfz_out 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00014e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_err
		"Final governor error"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_err 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_err_drv
		"The boost or exhaust pressure derivative error"
		SWORD
		BaetBhc_pDhrFcd_vCpmeDc_BpCRaa0
		1
		100
		-50000.
		50000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_err_drv 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_err_drv_red
		"Reduction factor for the derivative error"
		UWORD
		uxdoaqa_BznFwjc_okphcBc_hp__00a
		1
		100
		2.
		100000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_err_drv_red 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00014e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_err_red
		"Reduction factor for the error"
		UWORD
		bCyeoab_zijwjxc_htqocrc_h___o0a
		1
		100
		2.
		100000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_err_red 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00014e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_ex_prs_err
		"Governor error for exhaust pressure"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_ex_prs_err 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_ex_prs_err_drv
		"The exhaust pressure derivative error"
		SWORD
		BaetBhc_pDhrFcd_vCpmeDc_BpCRaa0
		1
		100
		-50000.
		50000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_ex_prs_err_drv 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_fmt
		"Formatting factor for the ouput of the fuzzy governor"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_fmt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00014ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_fzy_pwm
		"The ouput of the fuzzy governor"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_fzy_pwm 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001496 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_fac_neg
		"Factor of the I part in the negative window"
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_fac_neg 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00014ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_fac_pos
		"Factor of the I part in the positive window"
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_fac_pos 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00014ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_fac_sig
		"Factor of the I part in the window"
		UWORD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_fac_sig 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00014f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_ini
		"initial value of the I part"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_ini 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00014f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_pwm
		"limited output of the vnt regulator i part"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_pwm 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0001498 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_pwm_bfr
		"Previous output of the I part"
		SLONG
		dCxqAad_vCfEADc_yrvpbwb_f__100a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_pwm_bfr 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0005220 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_pwm_raw
		"Raw output of the I part"
		SLONG
		dCxqAad_vCfEADc_yrvpbwb_f__100a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_pwm_raw 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0005224 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_pwm_sum
		"Output of the 1 part"
		SLONG
		dCxqAad_vCfEADc_yrvpbwb_f__100a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_pwm_sum 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0004da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_win_neg
		"Negative window of the I part"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_win_neg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00014f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_i_win_pos
		"Positive window of the I part"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_i_win_pos 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00014f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_lim
		"Boost rco command  from regulator before anti-surging switch mode."
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_lim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00014f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_max
		"Upper PID pwm limitation"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_max 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00014fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_min
		"Lower PID pwm limitation"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_min 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00014fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_pwm
		"PWM signal from saturation or regulator"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_pwm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_raw
		"Ouput of the governor"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_raw 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd00014fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_raw_lim
		"Boost rco command  from regulator."
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_raw_lim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000149a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_rco_err
		"Final rco governor error"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_rco_err 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_rco_err_drv
		"The derivative error"
		SWORD
		BaetBhc_pDhrFcd_vCpmeDc_BpCRaa0
		1
		100
		-50000.
		50000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_rco_err_drv 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_spg_err
		"Governor error for boost air pressure"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_spg_err 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_reg_spg_err_drv
		"The boost pressure derivative error"
		SWORD
		BaetBhc_pDhrFcd_vCpmeDc_BpCRaa0
		1
		100
		-50000.
		50000.
    DISPLAY_IDENTIFIER Vxx_vnt_reg_spg_err_drv 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_rst_emtv_psn
		"Emtv opened position threshold"
		UWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_vnt_rst_emtv_psn 
    FORMAT "%14.9" 
    ECU_ADDRESS 0xd0007800 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sge_emtv_req
		"VNT antisurge request value of emtv position (consolidation)"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_sge_emtv_req 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000158e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sge_emtv_req_pp
		"VNT antisurge request value of emtv position in pp mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_sge_emtv_req_pp 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001596 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sge_emtv_req_pr
		"VNT antisurge request value of emtv position in pr mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_sge_emtv_req_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000159e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sge_emtv_req_rij
		"VNT antisurge request value of emtv position in rij mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_sge_emtv_req_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00015a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sge_pwm
		"Boost rco command during anti-surging mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_sge_pwm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001362 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_amp_bas_pr
		"Basic vnt setpoint correction for atmospheric pressure for regeneration"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_amp_bas_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001506 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_amp_bas_rij
		"Basic vnt setpoint correction for atmosheric pressure"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_amp_bas_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001522 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_amp_fac_pr
		"Vnt setpoint correction factor for atmospheric pressure for regeneration mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_amp_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001508 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_amp_fac_rij
		"Vnt setpoint correction factor for atmospheric pressure"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_amp_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001524 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_amp_pr
		"Vnt atmosheric pressure correction for regeneration mode"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_amp_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000150a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_cor_pr
		"Boost air pressure setpoint for regeneration mode corrected for atm pres and inlet temp"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_cor_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000150c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_cor_rij
		"Vnt corrected setpoint corrected by atmospheric pressure and intake temperature in normal mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_cor_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001526 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_ex_df_bas_pr
		"Basic vnt setpoint correction for intake air temperature in case of exhaust pressure sensor limphome in particule filter regeneration"
		UWORD
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_ex_df_bas_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000150e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_ex_df_bas_rij
		"Basic vnt setpoint correction for intake air temperature in case of exhaust pressure sensor limphome in regular injection mode."
		UWORD
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_ex_df_bas_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001528 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_ex_df_fac_pr
		"Vnt setpoint correction factor for intake air temperature in case of exhaust pressure sensor limphome in particule filter regeneration"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_ex_df_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001510 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_ex_df_fac_rij
		"Vnt setpoint correction factor for intake air temperature in case of exhaust pressure sensor limphome in regular injection mode."
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_ex_df_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000152a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_max
		"Vnt maximum setpoint depending on the atmospheric pressure and intake air temperature"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_max 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000a44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_max_fac
		"Vnt maximum setpoint factor"
		UWORD
		ieyvrqa_pummcoa_ruhaEzb_hCRa00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_max_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0000a46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_max_raw
		"Vnt maximum setpoint depending on the atmospheric pressure only"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_max_raw 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000a48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_min_tia_amp_pr
		"Vnt min setpoint correction (negative) for intake air temperature and atmospheric pressure in pr"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_min_tia_amp_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001512 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_min_tia_amp_rij
		"Vnt min setpoint correction (negative) for intake air temperature and atmospheric pressure in rij"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_min_tia_amp_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000152c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_tia_bas_pr
		"Basic vnt setpoint correction for intake air temperature in regeneration combustion mode"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_tia_bas_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001514 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_tia_bas_rij
		"Basic vnt setpoint correction for intake air temperature in regular injection  mode"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_tia_bas_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000152e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_tia_fac_pr
		"Vnt setpoint correction factor for intake air temperature in regeneration mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_tia_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001516 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_tia_fac_rij
		"Vnt setpoint correction factor for intake air temperature in regular injection mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_tia_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001530 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_tia_pr
		"Vnt setpoint correction for intake air temperature in regeneration mode"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_tia_pr 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001518 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_sp_tia_rij
		"Vnt setpoint correction for intake air temperature in regular injection mode"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_sp_tia_rij 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001532 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_err_tran
		"Boost air pressure error used to activate transient strategy"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_err_tran 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_sp
		"Boost pressure value setpoint"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_sp 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000a40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_sp_bas_pr
		"Basic vnt boost air pressure setpoint in regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_sp_bas_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000151a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_sp_bas_rij
		"Basic vnt boost air pressure setpoint in regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_sp_bas_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001534 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_sp_diff
		"Derivative value of the boost pressure setpoint"
		SWORD
		oulzEua_dFqvdub_ocphcBc_hp__00a
		1
		100
		-327680.
		327670.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_sp_diff 
    FORMAT "%7.0" 
    ECU_ADDRESS 0xd000134c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_sp_dt1
		"Filtered derivative value of the boost pressure setpoint"
		SWORD
		AmckCEa_rzqllkb_aAvivha_hp__a0a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_sp_dt1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000134e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_sp_pft_max_pr
		"Max bap setpoint depending on before particule filter pressure and eng speed for regeneration mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_sp_pft_max_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000151c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_spg_sp_pft_max_rij
		"Maximum map value depending on before particule filter pressure for regular injection mode"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_vnt_spg_sp_pft_max_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0001536 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_tran_clos_open_pwm
		"PWM signal during transient or opening mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_tran_clos_open_pwm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_tran_pwm
		"PWM signal during transient mode  after combustion mode arbitration."
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_tran_pwm 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001364 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_tran_pwm_npu
		"PWM signal on transient mode for npu mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_tran_pwm_npu 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_tran_pwm_pr
		"PWM signal on saturation mode for pr combustion mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_tran_pwm_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_tran_pwm_rij
		"PWM signal on saturation mode for rij mode"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_vnt_tran_pwm_rij 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00013e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpcoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_zon_n_thd_1
		"Engine speed threshold 1"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_vnt_zon_n_thd_1 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000142c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpcoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_zon_n_thd_2
		"Engine speed threshold 2"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_vnt_zon_n_thd_2 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000142e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpcoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_zon_n_thd_3
		"Engine speed threshold 3"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_vnt_zon_n_thd_3 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001430 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpcoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_zon_tqi_thd_2
		"Torque threshold 2"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_vnt_zon_tqi_thd_2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001432 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpcoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vnt_zon_tqi_thd_3
		"Torque threshold 3"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_vnt_zon_tqi_thd_3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001434 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vol_eff_ex
		"The exhaust volumetric efficiency"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vol_eff_ex 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007560 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vol_eff_in
		"The intake volumetric efficiency"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_vol_eff_in 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0007562 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs
		"Vehicle speed"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_vs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_clos_spt_lamp_off_thd
		"Difference between vehicle speed and requested speed to turn OFF the lamp indicating that vehicle speed is reaching the setpoint."
		UBYTE
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_vs_clos_spt_lamp_off_thd 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd0001989 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_clos_spt_lamp_on_thd
		"Difference between vehicle speed and requested speed to turn ON the lamp indicating that vehicle speed is reaching the setpoint."
		UBYTE
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_vs_clos_spt_lamp_on_thd 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd000198a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_mv
		"Vxx_vs_mv"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_n_rat
		"Non filtered but quantized and saturated value of V/Neng ratio. If equal to -10, ratio is incorrect"
		SWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		-10.
		200.
    DISPLAY_IDENTIFIER Vxx_vs_n_rat 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_n_rat_fil
		"Vxx_vs_n_rat_fil : Filtered value of VehicleSpeed/Neng ratio. If equal to -10, ratio value is incoherent."
		UWORD
		zkbcymc_ixcjqia_ikunepd_ijp_a1a
		1
		100
		-10.
		200.
    DISPLAY_IDENTIFIER Vxx_vs_n_rat_fil 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vs_sat
		"Maximum value allowed for vehicle speed"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_vs_sat 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000da8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_1_2
		"Vxx_vs_thd_1_2"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_2_1
		"Vxx_vs_thd_2_1"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_2_3
		"Vxx_vs_thd_2_3"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_3_2
		"Vxx_vs_thd_3_2"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_3_4
		"Vxx_vs_thd_3_4"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_4_3
		"Vxx_vs_thd_4_3"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_4_5
		"Vxx_vs_thd_4_5"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_5_4
		"Vxx_vs_thd_5_4"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_5_6
		"Vxx_vs_thd_5_6"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_6_5
		"Vxx_vs_thd_6_5"
		UWORD
		VA_F_0v01_p0_10
		2
		100
		0
		655.35
    ECU_ADDRESS 0xd00010ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_vs_thd_t
		"Number of time steps for air temp correction"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_vs_thd_t 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_wpmp_tco_tcr_dly
		"Water temperature monitoring to command turbo water pump"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_wpmp_tco_tcr_dly 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00076b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_wpmp_tcr_dly
		"Turbo water pump delay command"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_wpmp_tcr_dly 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00076ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clatoou_xxxm3x_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		WarningWaterTemp
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER WarningWaterTemp 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002429 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		WheelSpeedRL
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER WheelSpeedRL 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00018a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		WheelSpeedRR
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER WheelSpeedRR 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00018a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[0].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006796 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[0].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006794 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[1].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000679a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[1].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006798 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[2].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000679e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[2].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000679c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[3].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[3].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[4].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[4].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[5].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[5].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[6].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[6].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[7].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[7].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[8].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[8].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[9].Vtx_ind_dyn
		""
		UWORD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		1
		100
		0.
		630.
    DISPLAY_IDENTIFIER Vtx_ind_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn[9].fm_dynamic_bitfield.Vtx_fail_dc_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Vtx_fail_dc_dyn_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006814 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006800 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006802 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006804 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006806 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006808 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000680a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000680c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006812 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006813 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006811 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006817 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00067c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006810 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006810 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[0].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006810 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006818 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006870 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000684c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000684e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006850 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006852 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006854 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006856 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006858 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000685a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000685c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000685e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006860 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006862 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006864 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006866 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006868 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000682e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006832 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006830 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006834 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006838 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006836 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000683a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000683e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000683c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006840 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006844 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006842 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006846 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000684a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006848 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000686e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000682c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006820 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006824 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006828 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000686f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000686d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006873 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000681c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000686c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000686c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[1].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000686c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006874 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000688a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000688e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000688c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006890 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006894 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006892 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006896 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000689a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006898 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000689c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000689e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006888 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000687c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006880 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006884 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006878 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[2].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006928 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006904 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006906 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006908 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000690a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000690c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000690e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006910 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006912 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006914 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006916 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006918 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000691a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000691c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000691e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006920 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006902 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006900 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006926 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006927 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006925 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000692b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00068d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006924 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006924 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[3].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006924 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000692c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006984 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006960 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006962 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006964 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006966 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006968 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000696a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000696c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000696e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006970 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006972 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006974 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006976 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006978 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000697a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000697c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006942 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006946 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006944 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006948 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000694c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000694a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000694e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006952 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006950 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006954 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006958 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006956 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000695a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000695e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000695c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006982 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006940 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006934 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006938 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000693c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006983 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006981 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006987 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006930 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Sbx_mfo_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006980 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].fm_dynamic_eprm_bitfield.Stx_obd_mreq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_obd_mreq_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006980 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[4].fm_dynamic_eprm_bitfield.Stx_pfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x02 
    DISPLAY_IDENTIFIER Sbx_pfo_dyn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006980 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_dist_fail_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_dist_fail_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006988 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_esd_siz_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_esd_siz_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_max_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[0]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_1_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[1]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_2_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[2]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_3_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[3]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_4_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_did_X_min_dyn[4]
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_did_5_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_esti_tqe_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000699e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_esti_tqe_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_esti_tqe_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_esti_tqe_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_n_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_n_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_n_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_n_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_tco_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_tco_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_tco_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_tco_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_vb_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_vb_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_vb_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vb_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_vs_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_vs_max_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_max_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ffm_vs_min_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ffm_vs_min_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_frq_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_frq_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_ind_dyn
		""
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_ind_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000699c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_km_cf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_cf_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006990 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_km_mf_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_mf_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006994 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_km_pass_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_km_pass_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006998 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_obd_clfctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_clfctr_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_obd_wctr_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_obd_wctr_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069dd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_pri_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_pri_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00069e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].Stx_tmp_dist_dyn
		""
		ULONG
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		4294967295.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_dyn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000698c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx.c' */
/begin MEASUREMENT
		fm_dyn_eprm[5].fm_dynamic_eprm_bitfield.Stx_mfo_dyn
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x04 
