    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_amp_cor_sta 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_fp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_fp1_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_fp1_amp_cor_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_amp_fac_rij
		"Factor of atmospheric pressure interpolation for quantity of pre-injection 1 during rij"
		MAP
		0x8004a2e2
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_amp_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_fms_fp1_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_fms_fp1_amp_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_fp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_fp1_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_fp1_amp_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_cold_tco_2p_rij
		"Quantity of pre-injection 1 with 2 pre-injection for cold coolant temperature during rij"
		MAP
		0x8004a0e2
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_cold_tco_2p_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_cold_tco_rij
		"Quantity of pre-injection 1 for cold coolant temperature during regular injection"
		MAP
		0x80049ee2
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_cold_tco_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_max_pr
		"Maximum quantity of pre-injection 1 during pft regeneration"
		MAP
		0x8004b69c
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_max_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_max_rij
		"Maximum quantity of pre-injection 1 during regular injection"
		MAP
		0x80049e1a
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_max_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_mv_tco_2p_rij
		"Quantity of pre-injection 1 with 2 pre-injection for medium coolant temperature during rij"
		MAP
		0x80049c1a
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_mv_tco_2p_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_mv_tco_rij
		"Quantity of pre-injection 1 for medium coolant temperature during regular injection"
		MAP
		0x80049a1a
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_mv_tco_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_tco_cor_pr
		"Coolant temperature correction for quantity of pre-injection 1 during pft regeneration"
		MAP
		0x8004b57c
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_tco_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_tia_cor_pr
		"Intake air temperature correction for quantity of pre-injection 1 during pft regeneration"
		MAP
		0x8004b45c
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_tia_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_tia_cor_rij
		"Intake air temperature correction for quantity of pre-injection 1 regular injection"
		MAP
		0x800498fa
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_tia_cor_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp1_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp1_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp1_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp1_tia_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp1_tia_fac_rij
		"Factor of intake air temperature interpolation for quantity of pre-injection 1during rij"
		MAP
		0x800498ca
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_fp1_tia_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_fp1_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_fp1_tia_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_fp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_fp1_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_fp1_tia_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_amp_cor_pr
		"Atmospheric pressure correction for quantity of pre-injection 2 during pft regeneration"
		MAP
		0x8004c144
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_amp_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_amp_cor_rij
		"Atmospheric pressure correction for quantity of pre-injection 2 regular injection"
		MAP
		0x8004afec
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_amp_cor_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_amp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_amp_cor_sta
		"Table of pre-injection 2 quantity correction during Starting Combustion Mode"
		MAP
		0x80068d7c
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_amp_cor_sta 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_amp_cor_sta 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_fp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_fp2_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_fp2_amp_cor_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_amp_fac_rij
		"Factor of atmospheric pressure interpolation for quantity of pre-injection 2 during rij"
		MAP
		0x8004afbc
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_amp_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_fms_fp2_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_fms_fp2_amp_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_fp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_fp2_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_fp2_amp_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_cold_tco_rij
		"Quantity of pre-injection 2 for cold coolant temperature during regular injection"
		MAP
		0x8004adbc
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_cold_tco_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_max_pr
		"Maximum quantity of pre-injection 2 during pft regeneration"
		MAP
		0x8004c07c
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_max_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_max_rij
		"Maximum quantity of pre-injection 2 during regular injection"
		MAP
		0x8004acf4
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_max_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_mv_tco_rij
		"Quantity of pre-injection 2 for medium coolant temperature during regular injection"
		MAP
		0x8004aaf4
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_mv_tco_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_tco_cor_pr
		"Coolant temperature correction for quantity of pre-injection 2 during pft regeneration"
		MAP
		0x8004bf5c
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_tco_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_tia_cor_pr
		"Intake air temperature correction for quantity of pre-injection 2 during pft regeneration"
		MAP
		0x8004be3c
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_tia_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_tia_cor_rij
		"Intake air temperature correction for quantity of pre-injection 2 regular injection"
		MAP
		0x8004a9d4
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_tia_cor_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fp2_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fp2_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fp2_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fp2_tia_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fp2_tia_fac_rij
		"Factor of intake air temperature interpolation for quantity of pre-injection 2 during rij"
		MAP
		0x8004a9a4
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_fp2_tia_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_fp2_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_fp2_tia_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_fp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_fp2_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_fp2_tia_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fpo_amp_cor_pr
		"Atmospheric pressure correction for quantity of post injection during pft regeneration"
		MAP
		0x8004cd84
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fpo_amp_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fpo_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fpo_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fpo_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fpo_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fpo_max_pr
		"Maximum quantity of post injection during pft regeneration"
		MAP
		0x8004ccbc
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fpo_max_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fpo_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fpo_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fpo_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fpo_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fpo_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fpo_tco_cor_pr
		"Coolant temperature correction for quantity of post injection during pft regeneration"
		MAP
		0x8004cb9c
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fpo_tco_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fpo_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fpo_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fpo_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fpo_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_fpo_tia_cor_pr
		"Intake air temperature correction for quantity of post injection during pft regeneration"
		MAP
		0x8004ca7c
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_fpo_tia_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_fpo_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_fpo_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_fpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_fpo_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_fpo_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_ms_dp_cor_pr
		"Interpolation table of CSF equivalent load correction for quantity of global injection during pft regeneration"
		MAP
		0x80044570
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_ms_dp_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_ms_dp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_ms_dp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_ms_dp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_ms_dp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_ms_dp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_amp_cut
		"Amtopheric pressure cut of pre injection"
		MAP
		0x8004c932
		RSA_RecordLayout_MAP_UBYTE
		4
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_amp_cut 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tco
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tco_fms_pinj_cut 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tia
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tia_fms_pinj_cut 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_bas_cut
		"Basic cut of pre injection"
		MAP
		0x8004c8f2
		RSA_RecordLayout_MAP_UBYTE
		4
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_bas_cut 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tco
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tco_fms_pinj_cut 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tia
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tia_fms_pinj_cut 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_comb_mod_cut
		"Combustion mode cut of pre injection"
		MAP
		0x8004c8b2
		RSA_RecordLayout_MAP_UBYTE
		4
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_comb_mod_cut 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tco
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tco_fms_pinj_cut 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tia
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tia_fms_pinj_cut 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_cut_1
		"The pre injection cut one"
		MAP
		0x8004c832
		RSA_RecordLayout_MAP_UWORD
		5
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_cut_1 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_pinj_cut_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_pinj_cut_1 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_pinj_cut_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_pinj_cut_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_pinj_cut_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_cut_2
		"The pre injection cut two"
		MAP
		0x8004c7b2
		RSA_RecordLayout_MAP_UWORD
		5
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_cut_2 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_pinj_cut_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_pinj_cut_2 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_pinj_cut_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_pinj_cut_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_pinj_cut_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_cut_3
		"The pre injection cut three"
		MAP
		0x8004c732
		RSA_RecordLayout_MAP_UWORD
		5
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_cut_3 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_pinj_cut_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_pinj_cut_3 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_pinj_cut_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_pinj_cut_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_pinj_cut_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_cut_4
		"The pre injection cut four"
		MAP
		0x8004c6b2
		RSA_RecordLayout_MAP_UWORD
		5
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_cut_4 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_pinj_cut_4 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_pinj_cut_4 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_pinj_cut_4 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_pinj_cut_4 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_pinj_cut_4 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_cut_5
		"The pre injection cut five"
		MAP
		0x8004c632
		RSA_RecordLayout_MAP_UWORD
		5
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_cut_5 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_pinj_cut_5 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_pinj_cut_5 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_pinj_cut_5 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_pinj_cut_5 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_pinj_cut_5 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_pinj_gear_cut
		"Gearbox ratio cut of pre injection"
		MAP
		0x8004c5f2
		RSA_RecordLayout_MAP_UBYTE
		4
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_pinj_gear_cut 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tco_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tco
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tco_fms_pinj_cut 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_tia_fms_pinj_cut */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_pinj_cut_tia
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			8
			1.
			8.
        AXIS_PTS_REF Ntb_tia_fms_pinj_cut 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_amp_cor_rij
		"Atmospheric pressure correction for separation of after injection during regular injection"
		MAP
		0x80069980
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_taf_amp_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_taf_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_taf_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_taf_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_taf_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_taf_amp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_amp_fac_rij
		"Factor of atmospheric pressure correction for separation of after injcetion during regular injection"
		MAP
		0x80069950
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_taf_amp_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_taf_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_fms_taf_amp_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_taf_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_taf_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_taf_amp_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_cold_tco_rij
		"separation of after injection for cold coolant temperature during regular injection"
		MAP
		0x80069750
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_taf_cold_tco_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_taf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_taf_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_taf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_taf_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_max_rij
		"Maximum separation of after injection during regular injection"
		MAP
		0x80069688
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_taf_max_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_taf_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_taf_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_taf_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_taf_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_taf_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_min_rij
		"Minimum separation of after injection during regular injection"
		MAP
		0x800695c0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_taf_min_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_taf_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_taf_min_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_taf_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_taf_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_taf_min_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_mv_tco_rij
		"separation of after injection for medium coolant temperature during regular injection"
		MAP
		0x800693c0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_taf_mv_tco_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_taf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_taf_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_taf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_taf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_taf_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_tia_cor_rij
		"Intake air temperature correction for separation of after injection during regular injection"
		MAP
		0x800692a0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_taf_tia_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_taf_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_taf_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_taf_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_taf_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_taf_tia_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_taf_tia_fac_rij
		"Factor of intake air temperature correction for separation of after injection during regular injecti"
		MAP
		0x80069270
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_taf_tia_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fms_taf_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fms_taf_tia_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_taf_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_taf_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_taf_tia_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tia_cor_pr
		"Interpolation table of intake air temperature correction for quantity of global injection during pft regeneration"
		MAP
		0x80044450
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_fms_tia_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tlp_amp_cor_pr
		"Atmospheric pressure correction for angle of late post injection during pft regeneration"
		MAP
		0x8004ef00
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tlp_amp_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tlp_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tlp_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tlp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tlp_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tlp_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tlp_max_pr
		"Maximum angle of late post injection during pft regeneration"
		MAP
		0x8004ee38
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tlp_max_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tlp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tlp_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tlp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tlp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tlp_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tlp_min_pr
		"Minimum angle of late post injection during pft regeneration"
		MAP
		0x8004ed70
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tlp_min_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tlp_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tlp_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tlp_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tlp_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tlp_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tlp_tco_cor_pr
		"Coolant temperature correction for angle of late post injection during pft regeneration"
		MAP
		0x8004ec50
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tlp_tco_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tlp_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tlp_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tlp_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tlp_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tlp_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tlp_tia_cor_pr
		"Intake air temperature correction for angle of late post injection during pft regeneration"
		MAP
		0x8004eb30
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tlp_tia_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tlp_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tlp_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tlp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tlp_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tlp_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_amp_cor_pr
		"Atmospheric pressure correction for separation of pre-injection 1 during pft regeneration"
		MAP
		0x80053810
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_amp_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_amp_cor_rij
		"Atmospheric pressure correction for separation of pre-injection 1 regular injection"
		MAP
		0x80051ade
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_amp_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_amp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_amp_fac_rij
		"Factor of atmospheric pressure interpolation for separation of pre-injection 1 during rij"
		MAP
		0x80051aae
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_amp_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_fms_tp1_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_fms_tp1_amp_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_tp1_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_tp1_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_tp1_amp_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_cold_tco_2p_rij
		"separation of pre-injection 1 with 2 pre-injection for cold coolant temperature during rij"
		MAP
		0x800518ae
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_cold_tco_2p_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_cold_tco_rij
		"separation of pre-injection 1 for cold coolant temperature during regular injection"
		MAP
		0x800516ae
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_cold_tco_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_max_pr
		"Maximum separation of pre-injection 1 during pft regeneration"
		MAP
		0x80053748
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_max_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_max_rij
		"Maximum separation of pre-injection 1 during regular injection"
		MAP
		0x800515e6
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_max_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_min_pr
		"Minimum separation of pre-injection 1 during pft regeneration"
		MAP
		0x80053680
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_min_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_min_rij
		"Minimum separation of pre-injection 1 dureing regular injection"
		MAP
		0x8005151e
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_min_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_min_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_min_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_mv_tco_2p_rij
		"separation of pre-injection 1 with 2 pre-injection for medium coolant temperature during rij"
		MAP
		0x8005131e
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_mv_tco_2p_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_mv_tco_rij
		"separation of pre-injection 1 for medium coolant temperature during regular injection"
		MAP
		0x8005111e
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_mv_tco_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_tco_cor_pr
		"Coolant temperature correction for separation of pre-injection 1 during pft regeneration"
		MAP
		0x80053560
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_tco_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_tia_cor_pr
		"Intake air temperature correction for separation of pre-injection 1 during pft regeneration"
		MAP
		0x80053440
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_tia_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_tia_cor_rij
		"Intake air temperature correction for separation of pre-injection 1 regular injection"
		MAP
		0x80050ffe
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_tia_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp1_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp1_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp1_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp1_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp1_tia_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp1_tia_fac_rij
		"Factor of intake air temperature interpolation for separation of pre-injection 1during rij"
		MAP
		0x80050fce
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_tp1_tia_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_tp1_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_tp1_tia_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_tp1_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_tp1_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_tp1_tia_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_amp_cor_pr
		"Atmospheric pressure correction for separation of pre-injection 2 during pft regeneration"
		MAP
		0x800542e8
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_amp_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_amp_cor_rij
		"Atmospheric pressure correction for separation of pre-injection 2 regular injection"
		MAP
		0x80052d60
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_amp_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_amp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_amp_fac_rij
		"Factor of atmospheric pressure interpolation for separation of pre-injection 2 during rij"
		MAP
		0x80052d30
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_amp_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_fms_tp2_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_fms_tp2_amp_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_tp2_amp_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_tp2_amp_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_tp2_amp_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_cold_tco_2p_rij
		"separation of pre-injection 2 with 2 pre-injection for cold coolant temperature during rij"
		MAP
		0x80052b30
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_cold_tco_2p_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_cold_tco_rij
		"separation of pre-injection 2 for cold coolant temperature during regular injection"
		MAP
		0x80052930
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_cold_tco_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_max_pr
		"Maximum separation of pre-injection 2 during pft regeneration"
		MAP
		0x80054220
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_max_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_max_rij
		"Maximum separation of pre-injection 2 during regular injection"
		MAP
		0x80052868
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_max_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_min_pr
		"Minimum separation of pre-injection 2 during pft regeneration"
		MAP
		0x80054158
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_min_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_min_rij
		"Minimum separation of pre-injection 2 during regular injection"
		MAP
		0x800527a0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_min_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_min_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_min_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_mv_tco_2p_rij
		"separation of pre-injection 2 with 2 pre-injection for medium coolant temperature during rij"
		MAP
		0x800525a0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_mv_tco_2p_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_2p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_2p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_2p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_mv_tco_rij
		"separation of pre-injection 2 for medium coolant temperature during regular injection"
		MAP
		0x800523a0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_mv_tco_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_tco_cor_pr
		"Coolant temperature correction for separation of pre-injection 2 during pft regeneration"
		MAP
		0x80054038
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_tco_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_tia_cor_pr
		"Intake air temperature correction for separation of pre-injection 2 during pft regeneration"
		MAP
		0x80053f18
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_tia_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_tia_cor_rij
		"Intake air temperature correction for separation of pre-injection 2 regular injection"
		MAP
		0x80052280
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_tia_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tp2_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tp2_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tp2_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tp2_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tp2_tia_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tp2_tia_fac_rij
		"Factor of intake air temperature interpolation for separation of pre-injection 2 during rij"
		MAP
		0x80052250
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_fms_tp2_tia_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_fms_tp2_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_fms_tp2_tia_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_fms_tp2_tia_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_fms_tp2_tia_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_fms_tp2_tia_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tpo_amp_cor_pr
		"Atmospheric pressure correction for angle of post injection during pft regeneration"
		MAP
		0x80054dc0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tpo_amp_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tpo_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tpo_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tpo_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tpo_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tpo_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tpo_max_pr
		"Maximum angle of post injection during pft regeneration"
		MAP
		0x80054cf8
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tpo_max_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tpo_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tpo_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tpo_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tpo_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tpo_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tpo_min_pr
		"Minimum angle of post injection during pft regeneration"
		MAP
		0x80054c30
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tpo_min_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tpo_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tpo_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tpo_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tpo_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tpo_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tpo_tco_cor_pr
		"Coolant temperature correction for angle of post injection during pft regeneration"
		MAP
		0x80054b10
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tpo_tco_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tpo_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tpo_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tpo_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tpo_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tpo_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_tpo_tia_cor_pr
		"Intake air temperature correction for angle of post injection during pft regeneration"
		MAP
		0x800549f0
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_fms_tpo_tia_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_tpo_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_tpo_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_tpo_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_tpo_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_tpo_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_fms_wish_tlp2
		"Late post injection 2 desired timing separation"
		MAP
		0x800691a6
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_fms_wish_tlp2 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_wish_tlp2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_wish_tlp2 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_wish_tlp2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_wish_tlp2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_wish_tlp2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_gear_n_tran_off_t
		"Time Threshold value for vnt transient desactivation"
		MAP
		0x80043698
		RSA_RecordLayout_MAP_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cmp_gear_n_tran_off_t 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tran_off_t */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tran_off_t */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tran_off_t */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tran_off_t */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tran_off_t */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear_df_tran
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_tran_off_t 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_tran_off_t */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_tran_off_t */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_tran_off_t */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_tran_off_t */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_tran_off_t */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_y_tran_off_t 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_gear_n_tran_off_thd
		"Threshold value for vnt transient desactivation"
		MAP
		0x80043644
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_gear_n_tran_off_thd 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tran_off_thd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear_df_tran
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_tran_off_thd 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_tran_off_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_tran_off_thd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_y_tran_off_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_gear_n_tran_on_thd
		"Threshold value for vnt transient activation"
		MAP
		0x800435f0
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_gear_n_tran_on_thd 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tran_on_thd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear_df_tran
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_tran_on_thd 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_tran_on_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_tran_on_thd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_y_tran_on_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_gear_n_tran_open_pwm
		"Pwm value during opening time after vnt transient saturation"
		MAP
		0x80043564
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_gear_n_tran_open_pwm 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tran_open_pwm */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear_df_tran
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_tran_open_pwm 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_tran_open_pwm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_tran_open_pwm */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_y_tran_open_pwm 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_gear_n_tran_open_t
		"Turn off delay duration time for opening after vnt transient activation"
		MAP
		0x800434d8
		RSA_RecordLayout_MAP_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		655.35
    DISPLAY_IDENTIFIER Cmp_gear_n_tran_open_t 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_tran_open_t */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_tran_open_t */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_tran_open_t */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_tran_open_t */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_tran_open_t */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear_df_tran
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_tran_open_t 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_tran_open_t */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_tran_open_t */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_tran_open_t */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_tran_open_t */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_tran_open_t */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_y_tran_open_t 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_is_i_err_tco_fac
		"Integral correction factor table dependant on static error and coolant temperature"
		MAP
		0x8005ac0c
		RSA_RecordLayout_MAP_UWORD
		2
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_is_i_err_tco_fac 
    FORMAT "%11.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_n_i_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_n_i_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_n_i_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_n_i_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_n_i_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dif_n_sp
			cvxuqsa_qeEanfd_gyuanCd_rCRa38a
			8
			-8192.
			8191.75
        AXIS_PTS_REF Ctb_is_n_i_dif 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_is_p_err_tco_fac
		"Proportionnal correction factor table dependant on static error and coolant temperature"
		MAP
		0x8005acfe
		RSA_RecordLayout_MAP_UWORD
		2
		wijukob_vbAeApa_hCDsnsa_n__a40a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_is_p_err_tco_fac 
    FORMAT "%11.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_n_p_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_n_p_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_n_p_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_n_p_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_n_p_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_dif_n_sp
			cvxuqsa_qeEanfd_gyuanCd_rCRa38a
			8
			-8192.
			8191.75
        AXIS_PTS_REF Ctb_is_n_p_dif 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_it_sat_cor_amp_pp
		"Map for thr sat correction depending on amp in rgn_prmt -ode"
		MAP
		0x80062be0
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_it_sat_cor_amp_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_amp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_amp_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_amp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_amp_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_it_sat_cor_tco_pp
		"Map for thr sat correction depending on tco in rgn_prmt mode"
		MAP
		0x80062b60
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_it_sat_cor_tco_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_tco_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_tco_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_tco_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_tco_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_it_sat_cor_tia_pp
		"Map for thr sat correction depending on tia in rgn_prmt m/de"
		MAP
		0x80062ae0
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_it_sat_cor_tia_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_tia_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_tia_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_tia_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_tia_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_it_sat_val_bas_pp
		"Map for thr sat setpoint for permanent regeneration mode."
		MAP
		0x800628e0
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_it_sat_val_bas_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_val_bas_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_it_sat_val_bas_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_it_sat_val_bas_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_it_sat_val_bas_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_it_sat_val_bas_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_map_fail_val
		"Map for manifold air pressure fail value calculation"
		MAP
		0x800576d2
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_map_fail_val 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_map_fail_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_map_fail_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_map_fail_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_map_fail_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_map_fail_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_map_fail_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_map_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_map_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_map_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_map_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_map_fail_fim_tot */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_fim_tot
			hcbCBdc_eypFcyc_nbBriqd_mt__1a0
			8
			0.
			100.
        AXIS_PTS_REF Ctb_map_fail_fim_tot 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_min_driv_tqe_map
		"Format the powertrain setpoint to disable the minimum driver engine torque"
		MAP
		0x800597d8
		RSA_RecordLayout_MAP_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_min_driv_tqe_map 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_min_driv_tqe_pwt_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_min_driv_tqe_pwt_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_min_driv_tqe_pwt_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_min_driv_tqe_pwt_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_min_driv_tqe_pwt_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_driv_pwt_sp
			qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
			17
			0.
			1.
        AXIS_PTS_REF Ctb_min_driv_tqe_pwt_sp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_ms_cor
		"Table of minimum particulate filter soot mass (corrected) depending on vehicle and injectors mileage"
		MAP
		0x800465b4
		RSA_RecordLayout_MAP_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ms_cor 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_vh_dist */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_vh_dist */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_vh_dist */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_vh_dist */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_vh_dist */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vh_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			4
			0.
			1048560.
        AXIS_PTS_REF Ctb_vh_dist 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_inj_dist */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_inj_dist */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_inj_dist */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_inj_dist */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_inj_dist */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_inj_dist_l_res
			kDgkitc_uFBiyid_xcsinbd_k__6na0
			4
			0.
			1048560.
        AXIS_PTS_REF Ctb_inj_dist 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_amp_ex_prs_sp_cor_pr
		"Basic atmospheric pressure correction of exhaust pressure setpoint in pft regeneration mode"
		MAP
		0x80060788
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_n_amp_ex_prs_sp_cor_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_ex_prs_sp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_ex_prs_sp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_amp_ex_prs_sp_cor_rij
		"Basic atmospheric pressure correction of exhaust pressure setpoint in regular injection mode"
		MAP
		0x80061064
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_n_amp_ex_prs_sp_cor_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_ex_prs_sp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_ex_prs_sp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_amp_ex_prs_sp_tkof_pr
		"Atmospheric pressure correction of exhaust pressure setpoint for take off assistance in pft regeneration mode"
		MAP
		0x800606e8
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_n_amp_ex_prs_sp_tkof_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_amp_tkof_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_ex_prs_sp_tkof_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_ex_prs_sp_tkof_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_amp_ex_prs_sp_tkof_rij
		"Atmospheric pressure correction of exhaust pressure setpoint for take off assistance in regular injection mode"
		MAP
		0x80060fc4
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_n_amp_ex_prs_sp_tkof_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_amp_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_amp_tkof_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_ex_prs_sp_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_ex_prs_sp_tkof_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_amp_tqi_max_cor_pr
		"Atmospheric correction on the maximum indicated torque, in regeneration mode"
		MAP
		0x8005b40c
		RSA_RecordLayout_MAP_UBYTE
		0.99609375
		Bnlvuab_ejuenvc_iFEorkc_n__2a8a
		0.5
		1.49609375
    DISPLAY_IDENTIFIER Cmp_n_amp_tqi_max_cor_pr 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_eng_amp_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			11
			0.
			20000.
        AXIS_PTS_REF Ctb_eng_amp_2 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_amp_tqi_max_cor_rij
		"Atmospheric correction on the maximum indicated torque, in normal mode"
		MAP
		0x8005b786
		RSA_RecordLayout_MAP_UBYTE
		0.99609375
		Bnlvuab_ejuenvc_iFEorkc_n__2a8a
		0.5
		1.49609375
    DISPLAY_IDENTIFIER Cmp_n_amp_tqi_max_cor_rij 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_eng_amp_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_eng_amp_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			11
			0.
			20000.
        AXIS_PTS_REF Ctb_eng_amp_2 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_amp_tqi_max_rij
		"Maximum indicated torque in normal mode (smoke criteria)"
		MAP
		0x8005b6f6
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_n_amp_tqi_max_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_eng_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_eng_amp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_max_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_cpr_rat_vnt_sge_t_pr
		"Activation time of anti_surge strategy on pr mode"
		MAP
		0x8005d398
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_n_cpr_rat_vnt_sge_t_pr 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_n_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_n_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_n_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_n_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_n_vnt_sge_t_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_n_vnt_sge_t_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_cpr_rat_pr
			lasreaa_cardnzb_hCDtpsa_n__a00a
			10
			0.
			5.
        AXIS_PTS_REF Ctb_y_cpr_rat_vnt_sge_t_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_cpr_rat_vnt_sge_t_rij
		"Activation time of anti_surge strategy on rij mode"
		MAP
		0x8005d656
		RSA_RecordLayout_MAP_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_n_cpr_rat_vnt_sge_t_rij 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_n_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_n_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_n_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_n_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_n_vnt_sge_t_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_n_vnt_sge_t_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_cpr_rat_vnt_sge_t_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_cpr_rat_rij
			lasreaa_cardnzb_hCDtpsa_n__a00a
			10
			0.
			5.
        AXIS_PTS_REF Ctb_y_cpr_rat_vnt_sge_t_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_maf_sp_emtv_psn_sp_pp
		"Map for egr valve position precontrol in rgn_prmt mode"
		MAP
		0x800621b4
		RSA_RecordLayout_MAP_UWORD
		100
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_maf_sp_emtv_psn_sp_pp 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_emtv_psn_sp_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_sp_lim
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_y_maf_sp_emtv_psn_sp_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_maf_sp_emtv_psn_sp_pr
		"Map for egr valve position precontrol in rgn mode"
		MAP
		0x800623f8
		RSA_RecordLayout_MAP_UWORD
		100
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_maf_sp_emtv_psn_sp_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_emtv_psn_sp_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_sp_lim
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_y_maf_sp_emtv_psn_sp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_maf_sp_emtv_psn_sp_rij
		"Map for egr valve position precontrol in rij mode"
		MAP
		0x8006263c
		RSA_RecordLayout_MAP_UWORD
		100
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_maf_sp_emtv_psn_sp_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_emtv_psn_sp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_emtv_psn_sp_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_emtv_psn_sp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_sp_lim
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_y_maf_sp_emtv_psn_sp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_map_tqi_max_pr
		"Maximum indicated torque in regeneration mode (temperature before turbine criteria)"
		MAP
		0x8005b31c
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_n_map_tqi_max_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_map */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_map_fil_max_tq
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_tqi_max_map 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_max_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_map_tqi_max_rij
		"Maximum indicated torque in normal mode (temperature before turbine criteria)"
		MAP
		0x8005b606
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_n_map_tqi_max_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_map */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_map */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_map_fil_max_tq
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_tqi_max_map 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_max_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_map_tqi_rij
		"Maximum indicated torque in normal mode"
		CURVE
		0x8005b5de
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_n_map_tqi_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_map_vnt_diag_tqi
		"Maximum indicated torque in case of negative regulation error"
		MAP
		0x8005b956
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_n_map_vnt_diag_tqi 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_max_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_vnt_dft_spg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_vnt_dft_spg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_vnt_dft_spg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_vnt_dft_spg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_vnt_dft_spg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_spg
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			10
			0.
			20000.
        AXIS_PTS_REF Ctb_tqi_vnt_dft_spg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_ms_tqi_max_cor_pr
		"torque correction in regeneration mode (temperature before turbine criteria)"
		MAP
		0x8005b25c
		RSA_RecordLayout_MAP_UWORD
		0.99609375
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		0.00390625
		1.
    DISPLAY_IDENTIFIER Cmp_n_ms_tqi_max_cor_pr 
    FORMAT "%10.6" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_ms_dp */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			8
			0.
			100.
        AXIS_PTS_REF Ctb_tqi_max_ms_dp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_max_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_ms_tqi_max_cor_rij
		"torque correction in normal mode (temperature before turbine criteria)"
		MAP
		0x8005b51e
		RSA_RecordLayout_MAP_UWORD
		0.99609375
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		0.00390625
		1.
    DISPLAY_IDENTIFIER Cmp_n_ms_tqi_max_cor_rij 
    FORMAT "%10.6" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_ms_dp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_ms_dp */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			8
			0.
			100.
        AXIS_PTS_REF Ctb_tqi_max_ms_dp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_max_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_fms_adv_sta
		"Coolant temperature and engine speed dependant Basic Advance table during Starting combustion mode"
		MAP
		0x8006adee
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_n_tco_fms_adv_sta 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_fms_adv_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_fms_adv_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_fms_adv_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_fms_adv_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_fms_adv_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tco_fms_adv_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_fms_adv_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_fms_adv_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_fms_adv_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_fms_adv_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_fms_adv_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_n_tco_fms_adv_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_fms_fp1_sta
		"Table of pre-injection 1 quantity during Starting Combustion Mode"
		MAP
		0x80068c52
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tco_fms_fp1_sta 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_fms_fp1_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_fms_fp1_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_fms_fp1_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_fms_fp1_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_fms_fp1_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tco_fms_fp1_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_fms_fp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_fms_fp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_fms_fp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_fms_fp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_fms_fp1_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_n_tco_fms_fp1_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_fms_fp2_sta
		"Table of pre-injection 2 quantity during Starting Combustion Mode"
		MAP
		0x80068d34
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tco_fms_fp2_sta 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_fms_fp2_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_fms_fp2_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_fms_fp2_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_fms_fp2_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_fms_fp2_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tco_fms_fp2_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_fms_fp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_fms_fp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_fms_fp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_fms_fp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_fms_fp2_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_n_tco_fms_fp2_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_min_tq_fmt
		"Corrective factor on minimum driver torque."
		MAP
		0x8005b030
		RSA_RecordLayout_MAP_UWORD
		1
		kFnyEcd_FayFsbb_lCDrlsa_n__a80a
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_n_tco_min_tq_fmt 
    FORMAT "%11.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_min_tqe_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_min_tqe_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_min_tqe_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_min_tqe_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_min_tqe_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_dif_tq
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_min_tqe_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_tco2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_rps_sp_sta
		"Rail pressure set point table during Starting Combustion Mode"
		MAP
		0x80068e6a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_n_tco_rps_sp_sta 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_rps_sp_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_rps_sp_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_rps_sp_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_rps_sp_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_rps_sp_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tco_rps_sp_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_rps_sp_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_rps_sp_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_rps_sp_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_rps_sp_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_rps_sp_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_n_tco_rps_sp_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_sta_tq
		"Starting Torque Table - coolant temperature and engine speed dependant"
		MAP
		0x8004189e
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_n_tco_sta_tq 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_tsp_tp1_sta
		"Table for separation of pre-injection 1 during Starting Combustion Mode"
		MAP
		0x8006af18
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_n_tco_tsp_tp1_sta 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_tsp_tp1_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_tsp_tp1_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_tsp_tp1_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_tsp_tp1_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_tsp_tp1_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tco_tsp_tp1_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_tsp_tp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_tsp_tp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_tsp_tp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_tsp_tp1_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_tsp_tp1_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_n_tco_tsp_tp1_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tco_tsp_tp2_sta
		"Table for separation of pre-injection 2 during Starting Combustion Mode"
		MAP
		0x8006affa
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_n_tco_tsp_tp2_sta 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_tsp_tp2_sta_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_tsp_tp2_sta_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_tsp_tp2_sta_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_tsp_tp2_sta_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_tsp_tp2_sta_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tco_tsp_tp2_sta_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tco_tsp_tp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tco_tsp_tp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tco_tsp_tp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tco_tsp_tp2_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tco_tsp_tp2_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_n_tco_tsp_tp2_sta_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tia_ex_prs_sp_cor_pr
		"Basic intake air temperature correction of exhaust pressure setpoint in pft regeneration mode"
		MAP
		0x800605e8
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_n_tia_ex_prs_sp_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_ex_prs_sp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_ex_prs_sp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_ex_prs_sp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tia_ex_prs_sp_cor_rij
		"Basic intake air temperature correction of exhaust pressure setpoint in regular injection mode"
		MAP
		0x80060ec4
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_n_tia_ex_prs_sp_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_ex_prs_sp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_ex_prs_sp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_ex_sp_rij
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_ex_prs_sp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tia_ex_prs_sp_tkof_pr
		"Intake air temperature correction of exhaust pressure setpoint for take off assistance in pft regeneration mode"
		MAP
		0x80060548
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_n_tia_ex_prs_sp_tkof_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_tia_tkof_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_ex_prs_sp_tkof_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_ex_prs_sp_tkof_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_ex_sp_pr
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_ex_prs_sp_tkof_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tia_ex_prs_sp_tkof_rij
		"Intake air temperature correction of exhaust pressure setpoint for take off assistance in regular injection mode"
		MAP
		0x80060e24
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_n_tia_ex_prs_sp_tkof_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_tia_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_tia_tkof_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_ex_prs_sp_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_ex_prs_sp_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_ex_sp_rij
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_ex_prs_sp_tkof_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tia_spg_sp_max_fac
		"Boost air pressure setpoint limitation factor depending on intake air temperature"
		MAP
		0x800437c8
		RSA_RecordLayout_MAP_UWORD
		2
		dfzFahb_jhnifha_BagaAvb__A_100a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_n_tia_spg_sp_max_fac 
    FORMAT "%6.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_spg_sp_max_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_spg_sp_max_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_spg_sp_max_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_spg_sp_max_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_spg_sp_max
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			10
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_spg_sp_max_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tia_vnt_stt_cor_pr
		"Map to correct o-l activation torque thresholds in pft regeneration mode."
		MAP
		0x8005ea64
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cmp_n_tia_vnt_stt_cor_pr 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_stt_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_stt_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_stt_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_stt_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			10
			-40.
			200.
        AXIS_PTS_REF Ctb_y_vnt_stt_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tia_vnt_stt_cor_rij
		"Map to correct o-l activation torque thresholds function of  engine speed and intake temperature"
		MAP
		0x8005ebb6
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cmp_n_tia_vnt_stt_cor_rij 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_stt_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_stt_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_stt_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_stt_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			10
			-40.
			200.
        AXIS_PTS_REF Ctb_y_vnt_stt_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_n_toil
		"Map of oil temperature in stabilised and standard conditions [90-92'C]"
		MAP
		0x80058562
		RSA_RecordLayout_MAP_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cmp_n_toil 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_rat_tgt
			wijukob_vbAeApa_hCDsnsa_n__a40a
			6
			0.
			1.
        AXIS_PTS_REF Ctb_tqi_rat 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n4 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n4 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n4 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_egr_byp_tco_hys_low
		"Map for the first threshold position of the component hysteresis"
		MAP
		0x8006009c
		RSA_RecordLayout_MAP_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_egr_byp_tco_hys_low 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_byp_tco_hys_low */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_egr_byp_tco_hys_low 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_egr_byp_tco_hys_low */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_egr_byp_tco_hys_low */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_egr_byp_tco_hys_low 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_egr_maf_reg_min_lim
		"Map of PI governor minimal output value"
		MAP
		0x80063c5c
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_egr_maf_reg_min_lim 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_egr_maf_reg_min_lim */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_egr_maf_reg_min_lim 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_egr_maf_reg_min_lim */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_egr_maf_reg_min_lim */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_egr_maf_reg_min_lim 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_emtv_sp_max_pp
		"MAP for EGR position saturation threshold in pp mode"
		MAP
		0x80061a0a
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_emtv_sp_max_pp 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_emtv_sp_max_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_emtv_sp_max_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_emtv_sp_max_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_emtv_sp_max_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_emtv_sp_max_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_emtv_sp_max_pr
		"MAP for EGR position saturation threshold in pr mode"
		MAP
		0x80061cfa
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_emtv_sp_max_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_emtv_sp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_emtv_sp_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_emtv_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_emtv_sp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_emtv_sp_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_emtv_sp_max_rij
		"MAP for EGR position saturation threshold in rij mode"
		MAP
		0x80061fea
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_emtv_sp_max_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_emtv_sp_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_emtv_sp_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_emtv_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_emtv_sp_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_emtv_sp_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_ex_prs_sp_bas_pr
		"Basic exhaust pressure set point  in pft regeneration mode"
		MAP
		0x80060348
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_ex_prs_sp_bas_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_bas_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_ex_prs_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_ex_prs_sp_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_ex_prs_sp_bas_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_ex_prs_sp_bas_rij
		"Basic exhaust pressure set point in regular injection mode"
		MAP
		0x80060c24
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_ex_prs_sp_bas_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_ex_prs_sp_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_ex_prs_sp_bas_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_ex_prs_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_ex_prs_sp_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_ex_prs_sp_bas_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_fms_efi_max_pr
		"Maximum exhaust injection's mass flow"
		MAP
		0x80044250
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tqi_fms_efi_max_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_efi_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_efi_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_efi_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_efi_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_fms_flp_max_pr
		"Interpolation table of maximum Late Post injection mass flow"
		MAP
		0x80044050
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tqi_fms_flp_max_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_fms_flp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_fms_flp_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_fms_flp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_fms_flp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_fms_flp_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_psn_max_pp
		"Map for maximal value of the itp in EGR regulation mode when rgn_prmt mode is on"
		MAP
		0x800618ea
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_psn_max_pp 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_psn_max_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_it_psn_max_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_it_psn_max_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_it_psn_max_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_it_psn_max_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_psn_max_pr
		"Map for maximal value of the itp in EGR regulation mode when rgn mode is on"
		MAP
		0x80061bda
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_psn_max_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_psn_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_it_psn_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_it_psn_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_it_psn_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_it_psn_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_psn_max_rij
		"Map for maximal value of the itp in EGR regulation mode when rij mode is on"
		MAP
		0x80061eca
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_psn_max_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_psn_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_it_psn_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_it_psn_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_it_psn_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_it_psn_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_cor_amp_pr
		"Map for thr sat correction depending on amp in rgn mode"
		MAP
		0x80063216
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_cor_amp_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_amp_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_cor_amp_rij
		"Map for thr sat correction depending on amp in rij mode"
		MAP
		0x8006384e
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_cor_amp_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_amp_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_amp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_cor_tco_pr
		"Map for thr sat correction depending on tco in rgn mode"
		MAP
		0x80063196
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_cor_tco_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_tco_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_tco_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_tco_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_tco_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_cor_tco_rij
		"Map for thr sat correction depending on tco in rij mode"
		MAP
		0x800637ce
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_cor_tco_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_tco_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_tco_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_cor_tia_pr
		"Map for thr sat correction depending on tia in rgn mode"
		MAP
		0x80063116
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_cor_tia_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_tia_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_cor_tia_rij
		"Map for thr sat correction depending on tia in rij mode"
		MAP
		0x8006374e
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_cor_tia_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_it_sat_cor_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_it_sat_cor_tia_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_it_sat_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_it_sat_cor_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_it_sat_cor_tia_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_val_bas_pr
		"Map for thr sat setpoint for regeneration mode"
		MAP
		0x80062f16
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_val_bas_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_val_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_it_sat_val_bas_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_it_sat_val_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_it_sat_val_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_it_sat_val_bas_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_it_sat_val_bas_rij
		"Map for thr sat setpoint in regular injection mode"
		MAP
		0x8006354e
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_it_sat_val_bas_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_it_sat_val_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_it_sat_val_bas_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_it_sat_val_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_it_sat_val_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_it_sat_val_bas_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_lpos_efi_exo_fac
		"Interpolation table for physical fuel flow exotherm adaptation from late post injection to 5th injector."
		MAP
		0x80043e50
		RSA_RecordLayout_MAP_UWORD
		65.535
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_n_tqi_lpos_efi_exo_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_lpos_efi_exo_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_lpos_efi_exo_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_lpos_efi_exo_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_lpos_efi_exo_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_lpos_efi_exo_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_amp_pp
		"Map for maf correction depending on amp in pp mode"
		MAP
		0x800654d2
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_amp_pp 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_amp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_amp_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_amp_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_amp_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_amp_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_amp_pr
		"Map for maf correction depending on amp in pr mode"
		MAP
		0x800662a6
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_amp_pr 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_amp_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_amp_rij
		"Map for maf correction depending on amp in rij mode"
		MAP
		0x80067964
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_amp_rij 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_amp_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_amp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsbcx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_byp_on
		"Map for correction of the basic maf setpoint when egr bypass is enabled"
		MAP
		0x80063f06
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_byp_on 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_cor_egr_byp_on */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_cor_egr_byp_on 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_cor_egr_byp_on */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_cor_egr_byp_on */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_cor_egr_byp_on 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tco_pp
		"Map for maf correction depending on tco in pp mode"
		MAP
		0x800652d2
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tco_pp 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tco_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tco_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tco_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tco_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tco_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tco_pr
		"Map for maf correction depending on tco in pr mode"
		MAP
		0x800660a6
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tco_pr 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tco_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tco_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tco_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tco_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tco_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tco_rij
		"Map for maf correction depending on tco in rij mode"
		MAP
		0x80067764
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tco_rij 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tco_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tco_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tia_pp
		"Map for maf correction depending on tia in pp mode"
		MAP
		0x800650d2
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tia_pp 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tia_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tia_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tia_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tia_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tia_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tia_pr
		"Map for maf correction depending on tia in pr mode"
		MAP
		0x80065ea6
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tia_pr 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tia_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tia_rij
		"Map for maf correction depending on tia in rij mode"
		MAP
		0x80067564
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tia_rij 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tia_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tia_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tkof_pp
		"Map for maf correction depending on take off in pp mode"
		MAP
		0x8006508a
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tkof_pp 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tkof_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tkof_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tkof_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tkof_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			6
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tkof_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_cor_tkof_rij
		"Map for maf correction depending on take off in rij mode."
		MAP
		0x8006751c
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_cor_tkof_rij 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_m_maf_cor_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_m_maf_cor_tkof_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_m_maf_cor_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_m_maf_cor_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			6
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_m_maf_cor_tkof_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_max_lim
		"Map for max limitation of the maf sp"
		MAP
		0x80063fb6
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_max_lim 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_max_lim */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_max_lim 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_max_lim */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_max_lim */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_max_lim 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_cor_prs_pp
		"Map for basic maf correction depending on pressure related to Pft in pp mode"
		MAP
		0x80064e8a
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_cor_prs_pp 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_cor_prs_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_cor_prs_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_cor_prs_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_cor_prs_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_cor_prs_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_cor_prs_pr
		"Map for basic maf correction depending on pressure related to Pft in pr mode"
		MAP
		0x80065ca6
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_cor_prs_pr 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_cor_prs_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_cor_prs_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_cor_prs_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_cor_prs_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_cor_prs_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_cor_prs_rij
		"Map for basic maf correction depending on pressure related to Pft in rij mode"
		MAP
		0x8006731c
		RSA_RecordLayout_MAP_UWORD
		6000
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		-3000.
		3000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_cor_prs_rij 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_cor_prs_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_cor_prs_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_cor_prs_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_cor_prs_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_cor_prs_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_1_pp
		"Map for mass air flow setpoint for gear 1 (or neutral or reverse gear) in pp mode."
		MAP
		0x80064c8a
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_1_pp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_1_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_1_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_1_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_1_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_1_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_1_rij
		"Map for mass air flow setpoint for gear 1 (or neutral or reverse gear) in rij mode"
		MAP
		0x8006711c
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_1_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_1_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_1_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_1_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_1_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_2_pp
		"Map for mass air flow setpoint for gear 2 in pp mode."
		MAP
		0x80064a8a
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_2_pp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_2_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_2_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_2_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_2_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_2_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_2_rij
		"Map for mass air flow setpoint for gear 2 in rij mode"
		MAP
		0x80066f1c
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_2_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_2_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_2_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_2_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_2_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_3_pp
		"Map for mass air flow setpoint for gear 3 in pp mode."
		MAP
		0x8006488a
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_3_pp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_3_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_3_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_3_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_3_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_3_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_3_rij
		"Map for mass air flow setpoint for gear 3 in rij mode"
		MAP
		0x80066d1c
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_3_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_3_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_3_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_3_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_3_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_3_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_4_pp
		"Map for mass air flow setpoint for gear 4 in pp mode."
		MAP
		0x8006468a
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_4_pp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_4_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_4_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_4_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_4_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_4_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_4_rij
		"Map for mass air flow setpoint for gear 4 in rij mode"
		MAP
		0x80066b1c
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_4_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_4_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_4_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_4_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_4_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_4_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_5_pp
		"Map for mass air flow setpoint for gear 5 in pp mode."
		MAP
		0x8006448a
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_5_pp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_5_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_5_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_5_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_5_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_5_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_5_rij
		"Map for mass air flow setpoint for gear 5 in rij mode"
		MAP
		0x8006691c
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_5_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_5_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_5_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_5_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_5_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_5_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_6_pp
		"Map for mass air flow setpoint for gear 6 in pp mode."
		MAP
		0x8006428a
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_6_pp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_6_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_6_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_6_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_6_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_egr_tqi
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_6_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_gear_6_rij
		"Map for mass air flow setpoint for gear 6 in rij mode"
		MAP
		0x8006671c
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_gear_6_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear_6_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_gear_6_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_gear_6_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_gear_6_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_gear_6_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_maf_sp_pr
		"Map for mass air flow setpoint for pr mode"
		MAP
		0x80065aa6
		RSA_RecordLayout_MAP_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		0.
		5000.
    DISPLAY_IDENTIFIER Cmp_n_tqi_maf_sp_pr 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_maf_sp_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_maf_sp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_maf_sp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_maf_sp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_fms_spc_max_cor
		"Interpolation table of maximum injected fuel mass flow correction"
		MAP
		0x800455e0
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_fms_spc_max_cor 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_fms_cor 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_fms_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_fms_spc_min_cor
		"Interpolation table of minimum injected fuel mass flow correction"
		MAP
		0x80045560
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_fms_spc_min_cor 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_fms_cor 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_fms_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_inj_fms_bas
		"Interpolation table of basic injected fuel mass flow settings"
		MAP
		0x80045360
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_inj_fms_bas 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_inj_fms_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_inj_fms_bas 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_inj_fms_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_inj_fms_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_inj_fms_bas 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_inj_fms_dg
		"Interpolation table of derivative gain for injected fuel mass flow controller"
		MAP
		0x800452e0
		RSA_RecordLayout_MAP_UWORD
		65.535
		DFotjDa_nlDlFCb_kaockea_mqk_ao0
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_inj_fms_dg 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_fms_dg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_fms_dg 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_fms_dg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_fms_dg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_fms_dg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_inj_fms_ig
		"Interpolation table of integral gain for injected fuel mass flow controller"
		MAP
		0x80045260
		RSA_RecordLayout_MAP_UWORD
		0.65535
		lhizBec_Egvjjka_qDAiwFa_mpk_10a
		0.
		0.65535
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_inj_fms_ig 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_fms_ig */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_fms_ig 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_fms_ig */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_fms_ig */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_fms_ig 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_inj_fms_pg
		"Interpolation table of proportional gain injected fuel mass flow controller"
		MAP
		0x800451e0
		RSA_RecordLayout_MAP_UWORD
		6.5535
		ihoBjcc_mwetedb_lefmhic_mC_R1o0
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_inj_fms_pg 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_fms_pg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_fms_pg 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_fms_pg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_fms_pg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_fms_pg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_bas
		"Interpolation table of variable CSF up temp with base setting depending on engine operating point"
		MAP
		0x80045160
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_bas 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_utp_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_utp_bas 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_utp_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_utp_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_utp_bas 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_bas_ftc
		"Interpolation table of filter time for CSF up temp with base setting depending on engine operating point"
		MAP
		0x800450e0
		RSA_RecordLayout_MAP_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_bas_ftc 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_utp_bas_ftc */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_utp_bas_ftc 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_utp_bas_ftc */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_utp_bas_ftc */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_utp_bas_ftc 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_inj_fms_fac
		"Interpolation table of injected fuel mass flow / CSF up temp gain"
		MAP
		0x80045060
		RSA_RecordLayout_MAP_UWORD
		6.5535
		ihoBjcc_mwetedb_lefmhic_mC_R1o0
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_inj_fms_fac 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_utp_inj_fms_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_utp_inj_fms_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_utp_inj_fms_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_utp_inj_fms_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_utp_inj_fms_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_neg_err
		"Interpolation table of maximum negative deviation of TTR controller"
		MAP
		0x80044cce
		RSA_RecordLayout_MAP_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_neg_err 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_neg_dev */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_neg_dev 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_neg_dev */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_neg_dev */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_neg_dev 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_pos_err
		"Interpolation table of maximum positive deviation of TTR controller"
		MAP
		0x80044c4e
		RSA_RecordLayout_MAP_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_pos_err 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_pos_dev */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_pos_dev 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_pos_dev */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_pos_dev */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_pos_dev 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_reg_on_stt
		"Interpolation table of CSF up temp regulation activation state depending on engine operating point"
		MAP
		0x80045890
		RSA_RecordLayout_MAP_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		1.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_reg_on_stt 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_utp_reg_on_stt */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_utp_reg_on_stt 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_utp_reg_on_stt */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_utp_reg_on_stt */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_utp_reg_on_stt 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_reg_ovs
		"Interpolation table of CSF up temp regulation overshoot depending on engine operating point"
		MAP
		0x80045b1a
		RSA_RecordLayout_MAP_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		-1200.
		1200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_reg_ovs 
    FORMAT "%7.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_utp_reg_ovs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_utp_reg_ovs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_utp_reg_ovs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_utp_reg_ovs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_utp_reg_ovs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_sp
		"Interpolation table of CSF up temp setpoint depending on engine operating point"
		MAP
		0x80045a9a
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_sp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_utp_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_utp_sp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_utp_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_utp_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_utp_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_pft_utp_sp_max
		"Interpolation table of maximum CSF up temp setpoint value depending on engine operating point"
		MAP
		0x80045a1a
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_pft_utp_sp_max 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_pft_utp_sp_max */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_pft_utp_sp_max 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_pft_utp_sp_max */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_pft_utp_sp_max */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_pft_utp_sp_max 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_tt_bas
		"Interpolation table of the DOC upstream temperature identifier for nominal engine calibration"
		MAP
		0x80044fe0
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_n_tqi_tt_bas 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tt_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tt_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tt_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tt_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tt_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tt_bas 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_tt_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_tt_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_tt_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_tt_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_tt_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_tt_bas 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_tt_bas_ftc
		"Interpolation table of filtering time constant of DOC upstream temperature"
		MAP
		0x80044f60
		RSA_RecordLayout_MAP_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cmp_n_tqi_tt_bas_ftc 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tt_bas_ftc */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tt_bas_ftc 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_tt_bas_ftc */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_tt_bas_ftc */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_tt_bas_ftc 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_tt_pft_utp_fac
		"Interpolation table of DOC upstream temperature - CSF upstream temperature ratio"
		MAP
		0x80044ee0
		RSA_RecordLayout_MAP_UWORD
		65.535
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Cmp_n_tqi_tt_pft_utp_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tt_pft_utp_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tt_pft_utp_fac 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_tt_pft_utp_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_tt_pft_utp_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_tt_pft_utp_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_n_tqi_vnt_emtv_psn_thd
		"Emtv position threshold to force i part initialisation when closing from this position"
		MAP
		0x8005eea0
		RSA_RecordLayout_MAP_UWORD
		100
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_n_tqi_vnt_emtv_psn_thd 
    FORMAT "%14.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_vnt_emtv_psn_thd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_vnt_emtv_psn_thd 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_vnt_emtv_psn_thd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_vnt_emtv_psn_thd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_vnt_emtv_psn_thd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_n_vs_ovh_tq_fac
		"overheat protection factor versus vehicle speed and engine speed"
		MAP
		0x8005b8da
		RSA_RecordLayout_MAP_UWORD
		0.99609375
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		0.00390625
		1.
    DISPLAY_IDENTIFIER Cmp_n_vs_ovh_tq_fac 
    FORMAT "%10.8" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ovh_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ovh_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			5
			0.
			16383.75
        AXIS_PTS_REF Ctb_ovh_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ovh_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ovh_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ovh_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ovh_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ovh_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			FfBqnda_Bdvwydd_aAwtuCb_khA_10a
			5
			0.
			255.
        AXIS_PTS_REF Ctb_ovh_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_ocd_flp
		"Table for calibration of post injection quantity"
		MAP
		0x80043ce4
		RSA_RecordLayout_MAP_UWORD
		100
		RB_CONV_AtCatDgn_1_100_mg_strk
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_ocd_flp 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ocd_n_mv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			RB_CONV_AtCatDgn_rpm
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_ocd_n_mv 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ocd_tqi_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			RB_CONV_AtCatDgn_32_Nm_0
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ocd_tqi_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_ocd_tlp
		"Table for calibration of post injection timing"
		MAP
		0x80043c64
		RSA_RecordLayout_MAP_UWORD
		720
		RB_CONV_AtCatDgn_002_deg_Crk
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_ocd_tlp 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ocd_n_mv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ocd_n_mv */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			RB_CONV_AtCatDgn_rpm
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_ocd_n_mv 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ocd_tqi_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ocd_tqi_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			RB_CONV_AtCatDgn_32_Nm_0
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_ocd_tqi_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_owe_toil_prev_sta
		"This map produce a number of engine turn in function of cranking oil temperature and engine stop"
		MAP
		0x8006b178
		RSA_RecordLayout_MAP_UWORD
		500000
		RB_CONV_10_trs
		0.0
		500000.0
    DISPLAY_IDENTIFIER Cmp_owe_toil_prev_sta 
