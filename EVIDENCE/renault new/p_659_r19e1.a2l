/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_is_d
		"Maxmimum saturation of derivative correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_max_is_d 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_is_i
		"Maximum torque value of idle speed regulator integral  correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_max_is_i 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001214 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_is_p
		"Maximum proportionnal torque correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_max_is_p 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001220 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_gbxlixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_mgb_tqe
		"Maximum gearbox available torque for mgb gearbox depending."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_mgb_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000777e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_n_inj
		"Maximum engine speed for fuel management"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_max_n_inj 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001252 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_n_nom
		"Maximum nominal engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_max_n_nom 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001256 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_n_ovn
		"Maximum engine speed for overspeed function"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_max_n_ovn 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001254 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_statlxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_pow_tqe
		"Limitation effective torque for power"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_pow_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_max_prot_spg_tqe
		"Maximum effective engine torque for supercharger protection"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_prot_spg_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007790 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_max_prot_tqe
		"Maximum effective engine torque for engine protection"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_prot_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007792 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nramsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_rams_n
		"Maximum engine speed allowed by the safety"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_max_rams_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000125a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_rams_tqe_1
		"Safety limited torque by level 1 limitation (low)"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_rams_tqe_1 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_rams_tqe_2
		"Safety limited torque by level 2 limitation (mean)"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_rams_tqe_2 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_rams_tqe_3
		"Safety limited vehicle speed converted in torque by level 3 limitation (strong)"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_rams_tqe_3 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_statlxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_stat_avl_tqe
		"Maximum absolute effective torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_max_stat_avl_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_ajsisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_max_stat_avl_tqi_ovn
		"Maximum absolute indicated torque with soft overspeed correction"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_max_stat_avl_tqi_ovn 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcoospt_cteaubc_data.c' */
/begin MEASUREMENT
		Vxx_mdf2_reg_dly
		"Delay value before enabling low temperature mode regulation for mdf2."
		UBYTE
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mdf2_reg_dly 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002117 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdf_min_dly_cnt
		"counter for the minimum duration of fan1 or fan2 activation"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_mdf_min_dly_cnt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001038 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdf_min_dly_dt
		"dt for the minimum duration of fan1 or fan2 activation"
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_mdf_min_dly_dt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000103a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_ac_acel_is_sp
		"Accelerated engine idle speed setpoint request for air conditionning from model"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_mdl_ac_acel_is_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007650 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_ac_pow
		"Air conditioning power received from model"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_mdl_ac_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000e60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxmd_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_alt_pow
		"Modelised alternator power calculated through lrotor"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_mdl_alt_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000765c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_driv_spt_fac
		"Model of driver sportivity factor, including 'slow' and 'fast' adaptation algorithms"
		UBYTE
		ltluECa_kDentwc_ulilrCa_roA_50a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_mdl_driv_spt_fac 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000234e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_ex_prs
		"Exhaust manifold pressure from model"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_mdl_ex_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007572 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_fmafmdx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_maf
		"Mass air flow from model"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_mdl_maf 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_maf_dyn
		"Intake air mass flow across the throttle valve estimated by AsMod in mg/cp"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_mdl_maf_dyn 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_maf_ic
		"The estimated air mass flow in cylinder in mg/str"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_mdl_maf_ic 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxmd_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_map
		"Manifold pressure value from model"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_mdl_map 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_exprsmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_pft_abv_down_prs
		"Estimated CSF absolute downstream pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_mdl_pft_abv_down_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000758c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_exprsmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_pft_rel_down_prs
		"Estimated CSF relative downstream pressure"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_mdl_pft_rel_down_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000758e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_ptcxxmd_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_ptc_pow
		"Modelised PTC power"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_mdl_ptc_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007b22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_tco
		"Engine coolant temperature (model)"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_mdl_tco 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000dda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_toil
		"Modelised oil temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_mdl_toil 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007636 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_tra_acel
		"Transverse acceleration calculated from rear wheel speed"
		SLONG
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_mdl_tra_acel 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0004a2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mdl_tra_acel_clc
		"Transversal acceleration calculated from rear wheel speed"
		SLONG
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_mdl_tra_acel_clc 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd0004a24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_up_it_temp
		"Estimated value of the upstream throttle temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_mdl_up_it_temp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000d8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_mdl_up_it_temp_raw
		"Raw estimated value of the upstream throttle temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_mdl_up_it_temp_raw 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0000da2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_agb_tqe
		"coupler torque losses"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_agb_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001286 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_avl_tqe
		"minimum available engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_avl_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001298 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_avl_tqe_raw
		"Minimum available engine torque before saturation with minimun driver engine torque."
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_avl_tqe_raw 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001288 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_bas_agb_tqe
		"minimum basic engine torque with AT torque losses"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_bas_agb_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000129a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_bas_tqe
		"minimum basic engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_bas_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000129c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_bas_tqe_raw
		"minimum basic engine torque without BVA constraints"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_bas_tqe_raw 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000128a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_driv_tqe
		"minimum driver engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_driv_tqe 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000129e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_driv_tqe_raw
		"Raw minimum driver engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_driv_tqe_raw 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000128c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_driv_tqe_wit_inj_cut
		"minimum driver engine torque with injection cut"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_driv_tqe_wit_inj_cut 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00012a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_dspl_arw_up_dly
		"Vxx_min_dspl_arw_up_dly"
		UBYTE
		VA_F_0v02_p0_4
		2
		100
		0
		5.1
    ECU_ADDRESS 0xd0002358 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_forc
		"Longitudinal force equivalent to a 0% accelerator pedal demand"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_min_forc 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00049ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_is_d
		"Minimum saturation of derivative correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_min_is_d 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd00011d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_is_i
		"Minimum torque value of idle speed regulator integral  correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_min_is_i 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000773c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_is_i_wio_blk
		"Minimum torque value of idle speed regulator integral  correction without the offset in case of blocked engine speed"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_min_is_i_wio_blk 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000773e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_is_p
		"Minimum proportionnal torque correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_min_is_p 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001222 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_is_tql
		"minimum hyperbolic engine torque"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_min_is_tql 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000128e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_min_vb_is_ofs
		"Electric balance protection idle speed setpoint offset"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_min_vb_is_ofs 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007758 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mmv_n_dif_drv
		"Moving mean value of derivative difference between engine and idle speed setpoint"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_mmv_n_dif_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00011d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_01_sub_val
		"Replacement value requested by Monitool to control identifier 01"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_moni_id_01_sub_val 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000d16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_10_sub_val
		"Replacement value requested by Monitool to control identifier 10"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_moni_id_10_sub_val 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0000d18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_11_sub_val
		"Replacement value requested by Monitool to control identifier 11"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_moni_id_11_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_13_sub_val
		"Replacement value requested by Monitool to control identifier 13"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_moni_id_13_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_14_sub_val
		"Replacement value requested by Monitool to control identifier 14"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_moni_id_14_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_18_sub_val
		"Replacement value requested by Monitool to control identifier 18"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_moni_id_18_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_1a_sub_val
		"Replacement value requested by Monitool to control identifier 1a"
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_1a_sub_val 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000d22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_1b_sub_val
		"Replacement value requested by Monitool to control identifier 1b"
		SWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_moni_id_1b_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_20_sub_val
		"Replacement value requested by Monitool to control identifier 20"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vxx_moni_id_20_sub_val 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001b0b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_21_sub_val
		"Replacement value requested by Monitool to control identifier 21"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_moni_id_21_sub_val 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000d26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_30_sub_val
		"Replacement value requested by Monitool to control identifier 30"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_30_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_31_sub_val
		"Replacement value requested by Monitool to control identifier 31"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_31_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_32_sub_val
		"Replacement value requested by Monitool to control identifier 32"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_32_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_33_sub_val
		"Replacement value requested by Monitool to control identifier 33"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_33_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_34_sub_val
		"Replacement value requested by Monitool to control identifier 34"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_34_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_35_sub_val
		"Replacement value requested by Monitool to control identifier 35"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_35_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_36_sub_val
		"Replacement value requested by Monitool to control identifier 36"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_moni_id_36_sub_val 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_37_sub_val
		"Replacement value requested by Monitool to control identifier 37"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_moni_id_37_sub_val 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000d36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_38_sub_val
		"Replacement value requested by Monitool to control identifier 38"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_moni_id_38_sub_val 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000d38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_39_sub_val
		"Replacement value requested by Monitool to control identifier 39"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_moni_id_39_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_3a_sub_val
		"Replacement value requested by Monitool to control identifier 3a"
		SWORD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_moni_id_3a_sub_val 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000d3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_3b_sub_val
		"Replacement value requested by Monitool to control identifier 3b"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_moni_id_3b_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_id_3c_sub_val
		"Replacement value requested by Monitool to control identifier 3c"
		SWORD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_moni_id_3c_sub_val 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0000d40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_min_is_n
		"Monitool idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_moni_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000774a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_nr_tot_id
		"Number of identifiers in the request"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_moni_nr_tot_id 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_moni_sf_spv
		"Monitool supervisor status byte"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_moni_sf_spv 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_msr_tqe_sp
		"MSR torque setting sent to torque arbitration"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_msr_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000e32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mute_stt
		"State of Mute for CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_mute_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001a9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mute_stt_ctr
		"Mute counter for validated CAN failure detection."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mute_stt_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mute_stt_ctr_mem_dec
		"Mute : current failures non-volatile counter (new value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mute_stt_ctr_mem_dec 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mute_stt_ctr_mem_prev
		"Mute : current failures non-volatile counter (previous value)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mute_stt_ctr_mem_prev 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mute_stt_diag
		"State of Mute failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mute_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_ac_acel_is_sp
		"Accelerated engine idle speed setpoint request for air conditionning from CAN"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_mux_ac_acel_is_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000cee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqacxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_ac_pow
		"air conditionning power received from CAN"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_mux_ac_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000cf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_clck
		"clock value for the last frame acquired on the mux"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vxx_mux_agb_clck 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001aa6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_csm_tq
		"Converter friction Torque acquired on MUX"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_mux_agb_csm_tq 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000cd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcspcin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_driv_spt_fac
		"Sportivity factor calculated by Automatic Transmission received on the CAN"
		UBYTE
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_mux_agb_driv_spt_fac 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd0001ef6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smat2in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_is_acel_sp
		"Automatic Transmission idle speed setpoint acceleration required received on CAN"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_mux_agb_is_acel_sp 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000cf2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_tqe_sp
		"Automatic transmission fast-acting torque setting acquired on the CAN"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_mux_agb_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_tqe_sp_raw
		"Automatic transmission fast-acting raw torque setting acquired on the CAN"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER Vxx_mux_agb_tqe_sp_raw 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000cda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_tqe_tgt_lim
		"Automatic transmission slow-acting torque setting acquired on the CAN"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_mux_agb_tqe_tgt_lim 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000cdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_agb_tqe_tgt_lim_raw
		"Automatic transmission slow-acting raw torque setting acquired on the CAN"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER Vxx_mux_agb_tqe_tgt_lim_raw 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_airb1
		"Byte n°1 of the AIRBAGCrash frame recieved on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mux_airb1 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002144 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_airb2
		"Byte n°2 of the AIRBAGCrash frame recieved on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mux_airb2 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002145 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqpalin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_alt_pow
		"Alternator power from CAN"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_mux_alt_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000d00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfadfin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_alt_pwm
		"Multiplexed alternator load"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_mux_alt_pwm 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0001b02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfpdain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_aod_vs
		"Accurate odometer coming to the CAN"
		SBYTE
		nqdxfta_EBcDtra_yuqaAka_cCR020a
		1
		100
		-60.
		60.
    DISPLAY_IDENTIFIER Vxx_mux_aod_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002171 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_asr_msr_clck
		"clock value for the last frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mux_asr_msr_clck 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ab2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_asr_tqe_sp
		"ASR setpoint torque acquired on the MUX"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_mux_asr_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000ce0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_asr_tqe_sp_raw
		"ASR setpoint torque acquired on the MUX (unscaled)"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER Vxx_mux_asr_tqe_sp_raw 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000ce2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_asr_tqe_tgt
		"ASR target torque acquired on the MUX"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_mux_asr_tqe_tgt 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_asr_tqe_tgt_raw
		"Raw unscaled ASR target torque"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER Vxx_mux_asr_tqe_tgt_raw 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000ce6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_dspl_vs
		"Displayed vehicle speed received on the CAN network"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_mux_dspl_vs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000678e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_eng_stop_req_ccu
		"Emergency engine stop request received on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mux_eng_stop_req_ccu 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001acc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_eng_stop_req_rgb
		"Engine stop requested by robotized gearbox received on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mux_eng_stop_req_rgb 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001acd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_eng_stop_req_ssg
		"Engine stop requested by SSG received on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_mux_eng_stop_req_ssg 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ace 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_frm_set_ref
		"Mux messaging set reference"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_mux_frm_set_ref 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000678c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbfulin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_fuel_lvl
		"Petrol tank reserve received on the CAN"
		UBYTE
		iajxBpc_mBoqiud_Eqnyxub_l_R0ooa
		1
		100
		0.
		80.
    DISPLAY_IDENTIFIER Vxx_mux_fuel_lvl 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000211d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfrwsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_lft_rwhs
		"Rear left wheel speed received on the CAN"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.34
    DISPLAY_IDENTIFIER Vxx_mux_lft_rwhs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mux_mil_req_1
		"MIL ignition state requested by MUX encoding"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_mux_mil_req_1 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002335 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mux_mil_req_2
		"Readiness state indication by MIL"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_mux_mil_req_2 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002336 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_msr_tqe_sp
		"MSR torque setting acquired on the MUX"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_mux_msr_tqe_sp 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0000ce8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_msr_tqe_sp_raw
		"Raw unscaled MSR torque setting"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER Vxx_mux_msr_tqe_sp_raw 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000cea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctbnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_prim_sha_spd
		"Primary shaft speed received on the CAN"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_mux_prim_sha_spd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000cec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfptcin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_ptc_pow
		"PTC power consumed received from CAN"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_mux_ptc_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006792 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfpdain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_raw_whl_angl
		"Steering wheel angle coming to the CAN"
		SWORD
		sFdchsc_zykwhra_iCEAEDa_q_16012
		1
		100
		-3276.7
		3276.7
    DISPLAY_IDENTIFIER Vxx_mux_raw_whl_angl 
    FORMAT "%7.1" 
    ECU_ADDRESS 0xd0000d04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqprgin_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_mux_rgb_pump
		"Robotized gearbox pump activation received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_mux_rgb_pump 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000214f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfrwsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_rgt_rwhs
		"Rear right wheel speed received on the CAN"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.34
    DISPLAY_IDENTIFIER Vxx_mux_rgt_rwhs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000d08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_sta_stt
		"Starter status received on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_mux_sta_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001acf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_sta_swi_act_ctr
		"Starter status received on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_mux_sta_swi_act_ctr 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002146 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tenvxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_tenv
		"External temperature received on the CAN"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_mux_tenv 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0006790 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mux_test_mil_dly
		"Current delay before readiness status check"
		UBYTE
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_mux_test_mil_dly 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd0002333 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mux_test_rdn_mil_dly
		"MIL flashing current delay when readiness are not completed"
		UBYTE
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_mux_test_rdn_mil_dly 
    FORMAT "%4.1" 
    ECU_ADDRESS 0xd0002334 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vftacin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_tra_acel
		"Transversal acceleration sensor received on the CAN"
		SLONG
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		1
		100
		-12.
		13.5
    DISPLAY_IDENTIFIER Vxx_mux_tra_acel 
    FORMAT "%8.4" 
    ECU_ADDRESS 0xd00049c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgdtvin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_vh_dist
		"Total vehicle distance received on the CAN"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_mux_vh_dist 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_mux_vs
		"Vehicle speed received on the CAN network"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_mux_vs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000cf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mv_1_2_gear_rat_tgt
		"Median value of gears ratio targets of the1st and the 2nd gears"
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_mv_1_2_gear_rat_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001914 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mv_2_3_gear_rat_tgt
		"Median value of gears ratio targets of the 2nd and the 3rd gears"
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_mv_2_3_gear_rat_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001916 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mv_3_4_gear_rat_tgt
		"Median value of gears ratio targets of the3rd and the 4th gears"
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_mv_3_4_gear_rat_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001918 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mv_4_5_gear_rat_tgt
		"Median value of gears ratio targets of the 4th and the 5th gears"
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_mv_4_5_gear_rat_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000191a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mv_5_6_gear_rat_tgt
		"Median value of gears ratio targets of the 5th and the 6th gears"
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_mv_5_6_gear_rat_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000191c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_derivxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mv_n_drv
		"derivate of engine speed after moving average"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_mv_n_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_mv_vb
		"Filtered battery voltage"
		UWORD
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		1
		100
		0.
		25000.
    DISPLAY_IDENTIFIER Vxx_mv_vb 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n
		"Engine Speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000e5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_cpr_rat_vnt_sge_t
		"Actvation time of anti-surging mode"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_n_cpr_rat_vnt_sge_t 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001356 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_decl
		"Engine speed threshold for the definition of overrun"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n_decl 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001582 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_dhil
		"Vxx_n_dhil"
		UWORD
		VA_F_0v25_p0_7
		2
		100
		0
		16383.75
    ECU_ADDRESS 0xd00010b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_dif_tq
		"Minimal saturation of filtered engine speed for the minimal torque calculation"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n_dif_tq 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001290 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_derivxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_drv
		"derivate of engine speed"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_n_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_drv_is
		"derivate of engine speed for idle speed"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_n_drv_is 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00011f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_drv_sub
		"Filtred derivate of engine speed for start engine state"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_n_drv_sub 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00011f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_gear
		"Vxx_n_gear"
		UWORD
		VA_F_0v25_p0_7
		2
		100
		0
		16383.75
    ECU_ADDRESS 0xd000109c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_gear_inc
		"Vxx_n_gear_inc"
		UWORD
		VA_F_0v25_p0_7
		2
		100
		0
		16383.75
    ECU_ADDRESS 0xd000109e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_mv
		"filtered engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n_mv 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000e56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_mv_min_driv_tqe
		"Filtered engine speed used for minimum driver torque calculation"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n_mv_min_driv_tqe 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001292 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_mv_min_driv_tqe_raw
		"Mean engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n_mv_min_driv_tqe_raw 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0001294 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_filspxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_mv_raw
		"filtered engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n_mv_raw 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000e58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_n_vld_min_is_n
		"Engine speed sensor failure idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_n_vld_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000774c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpcoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_diag_off_thd
		"Torque threshold to switch off regulation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_n_vnt_diag_off_thd 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0001428 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpcoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_diag_on_thd
		"Torque threshold to switch on regulation."
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_n_vnt_diag_on_thd 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000142a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_ex_reg_i_fac
		"correction factor of I part in case of exhaust pressure limitation"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_ex_reg_i_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001358 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpnpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_ex_reg_i_fac_npu
		"correction factor of I part in case of exhaust pressure limitation in npu mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_ex_reg_i_fac_npu 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_ex_reg_i_fac_pr
		"Correction factor of I part for exhaust pressure limitation in pr mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_ex_reg_i_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_ex_reg_i_fac_rij
		"Correction factor of I part for exhaust pressure limitation in rij mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_ex_reg_i_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00013e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_reg_i_fac
		"correction factor of I part"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_reg_i_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000135a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_reg_i_fac_npu
		"correction factor of I part for npu mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_reg_i_fac_npu 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001366 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_reg_i_fac_pr
		"correction factor of I part for pr mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_reg_i_fac_pr 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0001368 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_reg_i_fac_rij
		"correction factor of I part for rij mode"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		3.2
    DISPLAY_IDENTIFIER Vxx_n_vnt_reg_i_fac_rij 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000136a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_sge_off_thd
		"Value of the low threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_n_vnt_sge_off_thd 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000135c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_n_vnt_sge_on_thd
		"Value of the high threshold for anti-surging mode activation"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_n_vnt_sge_on_thd 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000135e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_no_cor_raw_ac_pow
		"Not corrected air conditioning power"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_no_cor_raw_ac_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001934 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_no_cor_raw_alt_pow
		"Not corrected alternator power"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_no_cor_raw_alt_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000e64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_no_seq_gear_sel
		"Vxx_no_seq_gear_sel"
		UBYTE
		VA_F_1_m1_24
		2
		100
		-1
		254
    ECU_ADDRESS 0xd0001d93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_loadval_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_obd_eal
		"Calculated Load Value for the scantool"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_obd_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000228e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007542 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_dlp_dly
		"Post injection duration"
		UBYTE
		RB_CONV_AtCatDgn_Time_01s
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_ocd_dlp_dly 
    ECU_ADDRESS 0xd0002040 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_dly_bfr_ena
		"Duration the engine speed and torque must be in steady state conditions before OBD DOC test is enabled"
		UWORD
		RB_CONV_AtCatDgn_Time_01s
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_ocd_dly_bfr_ena 
    ECU_ADDRESS 0xd00063ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_flp
		"Post injection quantity"
		UWORD
		RB_CONV_AtCatDgn_1_100_mg_strk
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_ocd_flp 
    ECU_ADDRESS 0xd00063b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_int_err_max_thd
		"Local variable for diagnosis maximum threshold for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_ocd_int_err_max_thd 
    ECU_ADDRESS 0xd00063dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_int_err_max_thd_clr
		"Cleared local variable for diagnosis maximum threshold for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_ocd_int_err_max_thd_clr 
    ECU_ADDRESS 0xd00063da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_int_err_min_thd
		"Local variable for diagnosis minimum threshold for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_ocd_int_err_min_thd 
    ECU_ADDRESS 0xd00063d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_int_err_min_thd_clr
		"Cleared local variable for diagnosis minimum threshold for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_ocd_int_err_min_thd_clr 
    ECU_ADDRESS 0xd00063d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_int_err_out
		"Local variable for diagnosis criterion for mod6"
		ULONG
		RB_CONV_AtCatDgn_8388608
		1
		100
		-83886.08
		83886.07
    DISPLAY_IDENTIFIER Vxx_ocd_int_err_out 
    ECU_ADDRESS 0xd0004f40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_int_err_out_clr
		"Cleared local variable for diagnosis criterion for mod6"
		SWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_ocd_int_err_out_clr 
    ECU_ADDRESS 0xd00063d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_mdl_esti_err
		"Estimation error ie difference between the exhaust gas temperature measured by the sensor and the exhaust gas temperature predicted by the model"
		UWORD
		RB_CONV_AtCatDgn_DegC_1200
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_ocd_mdl_esti_err 
    ECU_ADDRESS 0xd00063b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_t_comb_mod_ok
		"Time the automate waits for combustion mode 8 before it moves into Diagnostic End state"
		UBYTE
		RB_CONV_AtCatDgn_Time_01s
		1
		100
		0.
		25.5
    DISPLAY_IDENTIFIER Vxx_ocd_t_comb_mod_ok 
    ECU_ADDRESS 0xd000203f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_test_dly
		"Duration of the DOC OBD monitor test"
		UWORD
		RB_CONV_AtCatDgn_Time_01s
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_ocd_test_dly 
    ECU_ADDRESS 0xd00063c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_tlp
		"Post injection timing"
		UWORD
		RB_CONV_AtCatDgn_002_deg_Crk
		1
		100
		-360.
		360.
    DISPLAY_IDENTIFIER Vxx_ocd_tlp 
    ECU_ADDRESS 0xd00063ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ocd_vh_dist_frz_clr
		"Reinit of end diagnosis freezed value of total vehicle distance"
		ULONG
		RB_CONV_AtCatDgn_km_1
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_ocd_vh_dist_frz_clr 
    ECU_ADDRESS 0xd0004f3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ofs_ad_dly
		"Duration of the offset learning"
		UWORD
		RB_CONV_AtCatDgn_Time_01s
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_ofs_ad_dly 
    ECU_ADDRESS 0xd00063c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_oil_dil
		"Current oil dilution rate"
		UWORD
		RB_CONV_100_65535_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_oil_dil 
    ECU_ADDRESS 0xd0006786 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_oil_dil_rij_ofs
		"Offset of dilution rate for normal mode (stored in eeprom)"
		UWORD
		RB_CONV_100_65535_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_oil_dil_rij_ofs 
    ECU_ADDRESS 0xd0006788 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_oil_dil_rij_spd
		"oil dilution speed"
		UWORD
		RB_CONV_00000001_PrcperSec
		1
		100
		0.0
		0.00065535
    DISPLAY_IDENTIFIER Vxx_oil_dil_rij_spd 
    ECU_ADDRESS 0xd0006770 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_oil_dil_tco
		"Engine coolant temperature"
		UWORD
		RB_CONV_DegC
		1
		100
		-40.0
		200.0
    DISPLAY_IDENTIFIER Vxx_oil_dil_tco 
    ECU_ADDRESS 0xd0006772 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_oitmonx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_oit_psn_sp_2
		"Position setpoint before inversion cartography."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_oit_psn_sp_2 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007666 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_oitmonx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_oit_psn_sp_cmd
		"Position setpoint sent by the monitoring system."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_oit_psn_sp_cmd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007668 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_ol_sat_it_cmd
		"Output of the first slope switch : open loop or saturation command of the inlet throttle"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_ol_sat_it_cmd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000161a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ovh_prot_tq
		"Maximum indicated torque for overheat protection"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ovh_prot_tq 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000778e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ovn_tq_cor
		"final torque corrective applied on maximum torque in case of overspeed."
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ovn_tq_cor 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001242 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ovn_tq_cor_p_i
		"torque corrective output of the PI"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ovn_tq_cor_p_i 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0001248 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ovn_tq_int
		"torque corrective output of the integrator"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ovn_tq_int 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000124a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ovn_tq_prop
		"torque corrective output of the proportional"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_ovn_tq_prop 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000124c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_ant
		"Anticipation factor to converge to the  one by one  kilometer decrement"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_ant 
    ECU_ADDRESS 0xd00076c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_ant_dil
		"Anticipation factor to converge to the  one by one  kilometer decrement for dilution potential kilom"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_ant_dil 
    ECU_ADDRESS 0xd00076f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_cmp_toil
		"Value of the output of the  CMP_owe_toil_prev_sta"
		UWORD
		RB_CONV_10_trs
		1
		100
		0.0
		500000.0
    DISPLAY_IDENTIFIER Vxx_owe_cmp_toil 
    ECU_ADDRESS 0xd0007ad4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_ctp_dil
		"Value of the output of the   Ctp_owe_dil  table"
		UWORD
		RB_CONV_Res_001
		1
		100
		0.0
		10.0
    DISPLAY_IDENTIFIER Vxx_owe_ctp_dil 
    ECU_ADDRESS 0xd0007acc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_ctp_toil
		"Value of the output of the   Ctp_owe_toil  table"
		UWORD
		RB_CONV_Res_001
		1
		100
		0.0
		10.0
    DISPLAY_IDENTIFIER Vxx_owe_ctp_toil 
    ECU_ADDRESS 0xd0007ace 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_ctr4
		"Value of the fourth counter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_owe_ctr4 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007b0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_ctr5
		"Value of the fifth counter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_owe_ctr5 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007b10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_dil_intrp_fac
		"Interpolation factor between dilution and oxidation kilometer"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0.0
		1.0
    DISPLAY_IDENTIFIER Vxx_owe_dil_intrp_fac 
    ECU_ADDRESS 0xd00076f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_dil_wea_pot
		"Oil dilution wear potential"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0.0
		1.0
    DISPLAY_IDENTIFIER Vxx_owe_dil_wea_pot 
    ECU_ADDRESS 0xd00076f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_eng_rev_act_sum
		"Actual engine revolution sum for the oil wear estimation strategy"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vxx_owe_eng_rev_act_sum 
    ECU_ADDRESS 0xd00053f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_eng_rev_act_sum_mem
		"Memorized actual engine revolution sum for the oil wear estimation strategy"
		ULONG
		RB_CONV_1Trs
		1
		100
		0
		300000000
    DISPLAY_IDENTIFIER Vxx_owe_eng_rev_act_sum_mem 
    ECU_ADDRESS 0xd00053b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_fac_toil_act
		"Actual oil temperatrure factor"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		500000.0
    DISPLAY_IDENTIFIER Vxx_owe_fac_toil_act 
    ECU_ADDRESS 0xd00053dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_fac_toil_tot
		"Total oil temperature factor"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		500000.0
    DISPLAY_IDENTIFIER Vxx_owe_fac_toil_tot 
    ECU_ADDRESS 0xd00053e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_ini
		"Type of initialisation word"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0.0
		255.0
    DISPLAY_IDENTIFIER Vxx_owe_ini 
    ECU_ADDRESS 0xd0002421 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km1_prev
		"Previous oil kilometer value for the first reference point"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km1_prev 
    ECU_ADDRESS 0xd00076c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km2_prev
		"Previous oil kilometer value for the second reference point"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km2_prev 
    ECU_ADDRESS 0xd00076ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_oxi_dil
		"Remaining kilometers when interpolation is made between oxidation and dilution km"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_km_oxi_dil 
    ECU_ADDRESS 0xd00076f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_oxi_dil_zon_1
		"Intermediary remaining kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_km_oxi_dil_zon_1 
    ECU_ADDRESS 0xd00076f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_oxi_dil_zon_2
		"Intermediary remaining kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km_oxi_dil_zon_2 
    ECU_ADDRESS 0xd00076fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_oxi_dil_zon_3
		"Intermediary remaining kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_km_oxi_dil_zon_3 
    ECU_ADDRESS 0xd00076fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_pot
		"Potential kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_km_pot 
    ECU_ADDRESS 0xd0007ac0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_sat_max
		"Oil potential kilometer maximal saturation value"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_km_sat_max 
    ECU_ADDRESS 0xd00076be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_slop
		"Slop of the remainig kilometers"
		UWORD
		RB_CONV_003_Fac
		1
		100
		0
		196.605
    DISPLAY_IDENTIFIER Vxx_owe_km_slop 
    ECU_ADDRESS 0xd00076cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_slop_dil
		"Slop of the remainig dilution kilometers"
		UWORD
		RB_CONV_003_Fac
		1
		100
		0
		196.605
    DISPLAY_IDENTIFIER Vxx_owe_km_slop_dil 
    ECU_ADDRESS 0xd00076fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_var1
		"Smoothed kilometer intermediary variable"
		ULONG
		RB_CONV_distance_1m
		1
		100
		0
		65535000
    DISPLAY_IDENTIFIER Vxx_owe_km_var1 
    ECU_ADDRESS 0xd00051a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_var1_dil
		"Smoothed meter intermediary variable"
		ULONG
		RB_CONV_distance_1m
		1
		100
		0
		65535000
    DISPLAY_IDENTIFIER Vxx_owe_km_var1_dil 
    ECU_ADDRESS 0xd00051b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_var2
		"Smoothed kilometer intermediary variable"
		ULONG
		RB_CONV_distance_1m
		1
		100
		0
		65535000
    DISPLAY_IDENTIFIER Vxx_owe_km_var2 
    ECU_ADDRESS 0xd00051ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_var2_dil
		"Smoothed meter intermediary variable"
		ULONG
		RB_CONV_distance_1m
		1
		100
		0
		65535000
    DISPLAY_IDENTIFIER Vxx_owe_km_var2_dil 
    ECU_ADDRESS 0xd00051b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_var3
		"Smoothed kilometer intermediary variable"
		UWORD
		RB_CONV_distance_3m
		1
		100
		0
		196605
    DISPLAY_IDENTIFIER Vxx_owe_km_var3 
    ECU_ADDRESS 0xd00076e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_km_var3_dil
		"Smoothed meter intermediary variable"
		UWORD
		RB_CONV_distance_3m
		1
		100
		0
		196605
    DISPLAY_IDENTIFIER Vxx_owe_km_var3_dil 
    ECU_ADDRESS 0xd0007716 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_max_drn_km
		"Maximal travelled kilometer between oil drain"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_max_drn_km 
    ECU_ADDRESS 0xd0007ac2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_min_drn_km
		"Minimal travelled kilometer between oil drain"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		20000
    DISPLAY_IDENTIFIER Vxx_owe_min_drn_km 
    ECU_ADDRESS 0xd0007ac4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_n_aut
		"Number engine revolutions per time"
		ULONG
		RB_CONV_Res_0001
		1
		100
		0.0
		20.0
    DISPLAY_IDENTIFIER Vxx_owe_n_aut 
    ECU_ADDRESS 0xd00053e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_n_mnl_asd
		"Maximal number of engine revolutions"
		ULONG
		RB_CONV_1Trs
		1
		100
		0
		300000000
    DISPLAY_IDENTIFIER Vxx_owe_n_mnl_asd 
    ECU_ADDRESS 0xd00053d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_n_toil_dil_u32
		"Actual engine revolution sum (since the last  engine on time)"
		ULONG
		RB_CONV_Trs
		1
		100
		0.0
		109951162.0
    DISPLAY_IDENTIFIER Vxx_owe_n_toil_dil_u32 
    ECU_ADDRESS 0xd00053e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_oil_km_dil
		"Target oil dilution potential kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_oil_km_dil 
    ECU_ADDRESS 0xd0007700 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_oil_km_upd
		"Oil kilometer updated signal"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_oil_km_upd 
    ECU_ADDRESS 0xd0007702 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_oxy_dil_km_fac
		"Interpolation factor"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_oxy_dil_km_fac 
    ECU_ADDRESS 0xd0007704 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km
		"Oil potential kilometers calculated"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km 
    ECU_ADDRESS 0xd00076c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_clc
		"Oil potential kilometers calculated"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_clc 
    ECU_ADDRESS 0xd00076c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_clc_2
		"Oil potential kilometers calculated"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_clc_2 
    ECU_ADDRESS 0xd00076c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_pot_dil
		"Oil potential kilometers from the dilution rate"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_pot_dil 
    ECU_ADDRESS 0xd0007706 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_pot_oxy_dil
		"Oil potential kilometers from oil oxidation and dilution factor"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_pot_oxy_dil 
    ECU_ADDRESS 0xd00076ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_prev
		"Previous oil potential kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_prev 
    ECU_ADDRESS 0xd00076ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_prev_dil
		"Previous oil dilution potential kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_prev_dil 
    ECU_ADDRESS 0xd0007708 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_rnd
		"Rounded oil potential meters"
		ULONG
		RB_CONV_distance_1m
		1
		100
		0
		65535000
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_rnd 
    ECU_ADDRESS 0xd00051b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_pot_km_step
		"Potential kilometer  one by one  decremented"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_pot_km_step 
    ECU_ADDRESS 0xd00076d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_prev_drn_dist
		"Travelled distance from the last oil drain"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vxx_owe_prev_drn_dist 
    ECU_ADDRESS 0xd0007abe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_prev_drn_dist_prev
		"Previous rounded oil kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_prev_drn_dist_prev 
    ECU_ADDRESS 0xd00076d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_prev_drn_dist_prev_2
		"Previous rounded oil kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_prev_drn_dist_prev_2 
    ECU_ADDRESS 0xd000770a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_raw_pot_km
		"Raw oil potential kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_raw_pot_km 
    ECU_ADDRESS 0xd00076d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_raw_pot_km_dil
		"Raw oil dilution potential kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_raw_pot_km_dil 
    ECU_ADDRESS 0xd000770c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_raw_pot_km_dil_1
		"Intermediary remaining kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_raw_pot_km_dil_1 
    ECU_ADDRESS 0xd000770e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_raw_pot_km_prev
		"Previous raw oil potential kilometers"
		UWORD
		RB_CONV_Distance_1km
		1
		100
		0
		65535
    DISPLAY_IDENTIFIER Vxx_owe_raw_pot_km_prev 
    ECU_ADDRESS 0xd00076d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_sat_km_slop_dil
		"Saturated slop of the dilution remainig kilometers"
		UWORD
		RB_CONV_003_Fac
		1
		100
		0
		196.605
    DISPLAY_IDENTIFIER Vxx_owe_sat_km_slop_dil 
    ECU_ADDRESS 0xd0007710 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_toil_sta
		"Oil temperature for oil wear estimation strategy (with saturation) on engine cranking"
		UWORD
		RB_CONV_DegC
		1
		100
		-40
		200
    DISPLAY_IDENTIFIER Vxx_owe_toil_sta 
    ECU_ADDRESS 0xd0007ad0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_toil_tco
		"Oil temperature for oil wear estimation strategy (with saturation)"
		UWORD
		RB_CONV_DegC
		1
		100
		-40
		200
    DISPLAY_IDENTIFIER Vxx_owe_toil_tco 
    ECU_ADDRESS 0xd0007ad2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea1_prev
		"Previous oil wear when the first point is learned"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea1_prev 
    ECU_ADDRESS 0xd00076d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea2_prev
		"Previous oil wear when the second point is learned"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea2_prev 
    ECU_ADDRESS 0xd00076da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea_act
		"Actual oil wear"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea_act 
    ECU_ADDRESS 0xd00076dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea_act_dil
		"Actual oil dilution wear"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea_act_dil 
    ECU_ADDRESS 0xd0007712 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea_act_pot
		"Actual potential oil wear"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea_act_pot 
    ECU_ADDRESS 0xd00076de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea_act_prev
		"Previous actual potential oil wear"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea_act_prev 
    ECU_ADDRESS 0xd00076e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea_dil_dif
		"Oil dilution wear between the two points"
		UWORD
		RB_CONV_1_65535_wu
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_owe_wea_dil_dif 
    ECU_ADDRESS 0xd0007714 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea_spd
		"Oil wearing speed"
		UWORD
		RB_CONV_0000001_Fac
		1
		100
		0.0
		0.0065535
    DISPLAY_IDENTIFIER Vxx_owe_wea_spd 
    ECU_ADDRESS 0xd00076e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_owe_wea_spd_dil
		"Oil dilution wearing speed"
		ULONG
		RB_CONV_0001_65535_prc
		1
		100
		0.0
		0.006553499
    DISPLAY_IDENTIFIER Vxx_owe_wea_spd_dil 
    ECU_ADDRESS 0xd00051bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_patxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pat
		"After turbine pressure from model"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_pat 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007570 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_pdl_grd
		"Vxx_pdl_grd"
		SWORD
		VA_F_0v125_p0_20
		2
		100
		-4096
		4095.875
    ECU_ADDRESS 0xd00010a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_accel_is_sp
		"High idle speed request for a diagnosis regeneration"
		UWORD
		RB_CONV_rpm
		1
		100
		0.0
		16383.75
    DISPLAY_IDENTIFIER Vxx_pft_accel_is_sp 
    ECU_ADDRESS 0xd0006474 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_aftr_rgn_intv_dist_ms
		"Estimated value of soot mass when distance since last regeneration request will overrun the minimum distance between two rgn"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_aftr_rgn_intv_dist_ms 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006696 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_cln
		"Variable indicating particles filter status: =1 clean; =2 clogged or broken; =0 regeneration request"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		255
    DISPLAY_IDENTIFIER Vxx_pft_asd_cln 
    ECU_ADDRESS 0xd0002056 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_cln_prev
		"Variable indicating particles filter status: =1 clean; =2 clogged or broken; =0 regeneration request before initialisation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		255
    DISPLAY_IDENTIFIER Vxx_pft_asd_cln_prev 
    ECU_ADDRESS 0xd0002052 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_cool_t_ctr
		"Counter of time left in the cooling state"
		UWORD
		RB_CONV_Time_s
		1
		100
		0.0
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_asd_cool_t_ctr 
    ECU_ADDRESS 0xd000646a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_cool_t_lft_prct
		"Time percentage in cooling state"
		UBYTE
		RB_CONV_100_255_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_cool_t_lft_prct 
    ECU_ADDRESS 0xd000204f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_dp_aftr
		"Difference pressure after asd regeneration"
		SWORD
		RB_CONV_Pres_hpa
		1
		100
		-10000
		10000
    DISPLAY_IDENTIFIER Vxx_pft_asd_dp_aftr 
    ECU_ADDRESS 0xd000647a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_dp_bfr
		"Difference pressure before asd regeneration"
		SWORD
		RB_CONV_Pres_hpa
		1
		100
		-10000
		10000
    DISPLAY_IDENTIFIER Vxx_pft_asd_dp_bfr 
    ECU_ADDRESS 0xd000647c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_egaf_aftr
		"Corrected volumic exhaust gas flow measurement after an asd regeneration"
		UWORD
		RB_CONV_Vol
		1
		100
		0.0
		2000.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_egaf_aftr 
    ECU_ADDRESS 0xd0006476 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_egaf_bfr
		"Corrected volumic exhaust gas flow measurement before an asd regeneration"
		UWORD
		RB_CONV_Vol
		1
		100
		0.0
		2000.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_egaf_bfr 
    ECU_ADDRESS 0xd0006478 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_hot_t_ctr
		"Counter of time left in the hot state"
		UWORD
		RB_CONV_Time_s
		1
		100
		0.0
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_asd_hot_t_ctr 
    ECU_ADDRESS 0xd000646c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_hot_t_lft_prct
		"Time percentage in heating state"
		UBYTE
		RB_CONV_100_255_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_hot_t_lft_prct 
    ECU_ADDRESS 0xd0002050 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_inj_mod
		"Specific injection mode for an aftersale regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		15
    DISPLAY_IDENTIFIER Vxx_pft_asd_inj_mod 
    ECU_ADDRESS 0xd0002057 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_n_cool
		"Engine speed for CSF cooling after an aftersale regeneration"
		UWORD
		RB_CONV_rpm
		1
		100
		0.0
		16383.75
    DISPLAY_IDENTIFIER Vxx_pft_asd_n_cool 
    ECU_ADDRESS 0xd0006470 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_n_rgn
		"Engine speed for aftersale regeneration state"
		UWORD
		RB_CONV_rpm
		1
		100
		0.0
		16383.75
    DISPLAY_IDENTIFIER Vxx_pft_asd_n_rgn 
    ECU_ADDRESS 0xd0006472 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_rgn
		"Indicates Successfull regeneration or its failure reason"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		255
    DISPLAY_IDENTIFIER Vxx_pft_asd_rgn 
    ECU_ADDRESS 0xd0002058 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_rgn_prev
		"Indicates Successfull regeneration or its failure reason before initialisation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		255
    DISPLAY_IDENTIFIER Vxx_pft_asd_rgn_prev 
    ECU_ADDRESS 0xd0002053 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_rgn_t_ctr
		"Counter of time left in after sale regeneration"
		UWORD
		RB_CONV_Time_s
		1
		100
		0.0
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_asd_rgn_t_ctr 
    ECU_ADDRESS 0xd000646e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_rgn_t_lft_prct
		"Time percentage in regeneration state"
		UBYTE
		RB_CONV_100_255_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_rgn_t_lft_prct 
    ECU_ADDRESS 0xd0002051 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_rgn_var_utp_ctr
		"Counter for pft regeneration during asd regeneration"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_asd_rgn_var_utp_ctr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000645a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_asd_t_lft_prct
		"Time percentage of the after sale regeneration"
		UBYTE
		RB_CONV_100_255_Prc
		1
		100
		0
		100.0
    DISPLAY_IDENTIFIER Vxx_pft_asd_t_lft_prct 
    ECU_ADDRESS 0xd0002059 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_msswixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_bal_ms_sim
		"Balanced simulated soot mass"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_bal_ms_sim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000658a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_bfr_cold_ms_tgt_dist
		"Estimated distance before the soot mass target corresponding to the cold condition regeneration mass threshold"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_bfr_cold_ms_tgt_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006698 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_bfr_max_ms_tgt_dist
		"Estimated distance before the maximum soot mass target"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_bfr_max_ms_tgt_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000669a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_cal_cpy1
		"Calorific capacity of the CSF substratum"
		UWORD
		tdkuuvc_hyypuEb_FBkqozb_JpA_o00
		1
		100
		600.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_cal_cpy1 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006532 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_cal_cpy2
		"Calorific capacity of the CSF substratum"
		UWORD
		tdkuuvc_hyypuEb_FBkqozb_JpA_o00
		1
		100
		600.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_cal_cpy2 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006534 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_cal_cpy3
		"Calorific capacity of the CSF substratum"
		UWORD
		tdkuuvc_hyypuEb_FBkqozb_JpA_o00
		1
		100
		600.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_cal_cpy3 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006536 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_cata_hot_t_ctr
		"Timer for temporization in catalyst_heating state"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_cata_hot_t_ctr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007904 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_chk_temp_t_ctr
		"Timer for temporization in check_temperature state"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_chk_temp_t_ctr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007920 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_cold_thd_ms_tgt
		"Soot mass target used when we want to remain under the cold condition mass threshold"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_cold_thd_ms_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000669c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_comb_bfr_entp1
		"CSF soot combustion enthalpy for the first ehr of the CSF before loop"
		UWORD
		DgucdCc_iavwbAc_acFyxka_J_A_1oa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_comb_bfr_entp1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006538 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_comb_bfr_entp2
		"CSF soot combustion enthalpy for the second ehr of the CSF before loop"
		UWORD
		DgucdCc_iavwbAc_acFyxka_J_A_1oa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_comb_bfr_entp2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000653a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_comb_bfr_entp3
		"CSF soot combustion enthalpy for the third ehr of the CSF before loop"
		UWORD
		DgucdCc_iavwbAc_acFyxka_J_A_1oa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_comb_bfr_entp3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000653c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_comb_entp1
		"CSF soot combustion enthalpy for the first ehr of the CSF"
		UWORD
		DgucdCc_iavwbAc_acFyxka_J_A_1oa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_comb_entp1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000653e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_comb_entp2
		"CSF soot combustion enthalpy for the second ehr of the CSF"
		UWORD
		DgucdCc_iavwbAc_acFyxka_J_A_1oa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_comb_entp2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006540 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_comb_entp3
		"CSF soot combustion enthalpy for the third ehr of the CSF"
		UWORD
		DgucdCc_iavwbAc_acFyxka_J_A_1oa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_comb_entp3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006542 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ctr_rgn_err_cold_ini
		"Indicates the number of regeneration failures in cold oportunity since the last sucess initial value"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_cold_ini 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007928 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ctr_rgn_err_hot_ini
		"Indicates the number of regeneration failures in hot oportunity since the last sucess initial value"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_hot_ini 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000792a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ctr_rgn_err_ini
		"Indicates the number of regeneration failures since the last sucess initial value"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_ini 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000792c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ctr_rgn_err_med_ini
		"Indicates the number of regeneration failures in medium oportunity since the last sucess initial value"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_med_ini 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000792e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ctr_rgn_err_raw
		"Indicates the number of regeneration failures since the last sucess before min distance reseting counters"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ctr_rgn_err_raw 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007930 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_delta_temp_fil
		"Delta of temperature between upstream and downstream."
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_delta_temp_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006528 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_fil
		"Filtered value for differential pressure"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_fil 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006482 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_fil_frst
		"Filtered value of differential pressure with small time constant"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_fil_frst 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006484 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_fil_frst_lkg
		"Filtered value of differential pressure with small time constant for overload particulate filter"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_fil_frst_lkg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_fil_lkg
		"Filtered value for differential pressure for overload particulate filter"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_fil_lkg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_fil_sq
		"Square value of the differential pressure"
		ULONG
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_fil_sq 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004f6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_fil_sq_lkg
		"Square value of the differential pressure for overload particulate filter"
		ULONG
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_fil_sq_lkg 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004f88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_rat_vrnc
		"Normalized variance of the average differential pressure"
		UWORD
		rErCnwa_xcoFdya_Bqeaoqb_n__400a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_rat_vrnc 
    FORMAT "%8.6" 
    ECU_ADDRESS 0xd0006486 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_rat_vrnc_lkg
		"Normalized variance of the average differential pressure for overload particulate filter"
		UWORD
		rErCnwa_xcoFdya_Bqeaoqb_n__400a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_rat_vrnc_lkg 
    FORMAT "%8.6" 
    ECU_ADDRESS 0xd00064ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_vrnc_fil
		"Filtered square value of differential pressure variance"
		ULONG
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_vrnc_fil 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004f70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_vrnc_fil_lkg
		"Filtered square value of differential pressure variance for overload particulate filter"
		ULONG
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_vrnc_fil_lkg 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004f8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_vrnc_sq
		"Square value of differential pressure variance"
		ULONG
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_vrnc_sq 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004f74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_dp_vrnc_sq_lkg
		"Square value of differential pressure variance for overload particulate filter"
		ULONG
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_diag_dp_vrnc_sq_lkg 
    FORMAT "%10.0" 
    ECU_ADDRESS 0xd0004f90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_egaf_fil
		"Filtered volumic exhaust gas flow for CSF diagnosis"
		UWORD
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_egaf_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006488 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_egaf_fil3
		"Class of volumic exhaust gas flow for CSF diagnosis"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_diag_egaf_fil3 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000205f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_egaf_fil_lkg
		"Filtered volumic exhaust gas flow for CSF diagnosis in overload particulate filter"
		UWORD
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_egaf_fil_lkg 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_egaf_fil_prev
		"Previous value of filtered volumic exhaust gas flow"
		UWORD
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_egaf_fil_prev 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000648a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_err_ctr_mod6
		"Diagnosis criteria for mod6"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_diag_err_ctr_mod6 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000647e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_err_max_mod6
		"Diagnosis threshold for mod6"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_diag_err_max_mod6 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006480 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_mv_zon_1
		"CSF differential pressure mean value on Zone 1"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_mv_zon_1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000649a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_mv_zon_2
		"CSF differential pressure mean value on Zone 2"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_mv_zon_2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000649c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_mv_zon_3
		"CSF differential pressure mean value on Zone 3"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_mv_zon_3 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000649e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_mv_zon_4
		"CSF differential pressure mean value on Zone 4"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_mv_zon_4 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_ovl_ctr
		"Accumulator value to detect overloaded filter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_diag_ovl_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_ovl_diag_done_ctr
		"Accumulator value to detect overloaded CSF diagnosis done"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_diag_ovl_diag_done_ctr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_rat_err
		"Pressure ratio for broken filter"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_pft_diag_rat_err 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000648c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_rat_ovl
		"Pressure ratio for overload filter"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_pft_diag_rat_ovl 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd00064d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_src_nok_t_ctr
		"Accumulated value of time passed in NOK SRC conditions."
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_diag_src_nok_t_ctr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_src_ok_t_ctr
		"Accumulated value of time passed in OK SRC conditions."
		UWORD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_diag_src_ok_t_ctr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_sum_nr_zon_1
		"Number of necessary point to validate mean calculation on Zone 1"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_sum_nr_zon_1 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00064a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_sum_nr_zon_2
		"Number of necessary point to validate mean calculation on Zone 2"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_sum_nr_zon_2 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00064a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_sum_nr_zon_3
		"Number of necessary point to validate mean calculation on Zone 3"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_sum_nr_zon_3 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00064a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_diag_sum_nr_zon_4
		"Number of necessary point to validate mean calculation on Zone 4"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1000.
    DISPLAY_IDENTIFIER Vxx_pft_diag_sum_nr_zon_4 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00064a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dil_spd
		"oil dilution speed"
		UWORD
		RB_CONV_000001_PrcperSec
		1
		100
		0.0
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_dil_spd 
    ECU_ADDRESS 0xd0006782 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dirt_max
		"Maximum threshold for OBD Clogged Diagnosis on mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_dirt_max 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dirt_min
		"Minimum threshold for OBD Clogged Diagnosis on mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_dirt_min 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dirt_val
		"Diagnosis criterion for Clogged CSF Diagnosis on OBD mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_dirt_val 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_inj_dist_1
		"Distance correction dep of injector's mileage on threshold for hot conditions."
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_inj_dist_1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006644 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_inj_dist_2
		"Distance correction dep of injector's mileage on threshold for cold conditions."
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_inj_dist_2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006646 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_inj_dist_3
		"Distance correction dep of vehicle distance on threshold for maximum conditions."
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_inj_dist_3 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006648 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_inj_dist_4
		"Distance threshold correction function of injector's mileage for medium conditions"
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_inj_dist_4 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000664a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_inj_dist_5
		"Distance threshold correction function of injector's mileage for limp home conditions"
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_inj_dist_5 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000664c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_tia_1
		"Distance threshold correction dep of intake temperature average value for hot conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_tia_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000664e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_tia_2
		"Distance threshold correction dep of intake temperature average value for cold conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_tia_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006650 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_tia_3
		"Distance threshold correction dep of intake temperature average value for maximum conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_tia_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006652 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_tia_4
		"Distance threshold correction dep of intake temperature average value for medium conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_tia_4 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006654 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_tia_5
		"Distance threshold correction dep of intake temperature average value forlimp home conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_tia_5 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006656 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_vh_tot_1
		"Distance correction dep of vehicle distance on threshold for hot conditions."
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_vh_tot_1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006658 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_vh_tot_2
		"Distance correction dep of vehicle distance on threshold for cold conditions."
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_vh_tot_2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000665a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_vh_tot_3
		"Distance correction dep of vehicle distance on threshold for maximum conditions."
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_vh_tot_3 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000665c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_vh_tot_4
		"Distance threshold correction function of vehicle mileage for medium conditions"
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_vh_tot_4 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000665e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_cor_vh_tot_5
		"Distance threshold correction function of vehicle mileage for limp home conditions"
		UWORD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		1
		100
		-32768.
		32767.
    DISPLAY_IDENTIFIER Vxx_pft_dist_cor_vh_tot_5 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006660 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_efy_prct
		"CSF efficiency of storage soot emissions dependent on the vehicle driven distance"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_dist_efy_prct 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00075a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_load_frst_ini
		"Vehicle mileage just after a successful regeneration initial value"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_dist_load_frst_ini 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0005348 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_load_frst_raw
		"Indicates the vehicle mileage just after a successful regeneration before reseting counters"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_dist_load_frst_raw 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd000534c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_load_min
		"Minimum distance to allow regeneration"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_load_min 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000658e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_load_min_spd_req
		"Minimum distance to allow speed request after a regeneration success"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_load_min_spd_req 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006596 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_min_rgn_err_thd
		"Minimum distance threshold to allow cold regeneration after x regeneration failures"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_min_rgn_err_thd 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006662 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_5
		"Distance threshold in case of failures to calculate the soot mass(dep of CSF efficiency)"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_5 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006664 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_cold
		"Distance threshold for cold conditions (dep of CSF efficiency)"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_cold 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000662a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_hot
		"Distance threshold for hot conditions (dep of CSF efficiency )"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_hot 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000662c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_med
		"Distance threshold for medium regeneration conditions (dep of CSF efficiency)"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_med 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000662e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_mini
		"Distance threshold for mini conditions (dep of CSF efficiency)"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_mini 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006666 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_raw_1
		"distance raw value dep of csf efficiency threshold for hot conditions"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_raw_1 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006668 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_raw_2
		"distance raw value dep of csf efficiency threshold for cold conditions"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_raw_2 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000666a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_raw_3
		"distance raw value dep of csf efficiency threshold for maximum conditions"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_raw_3 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000666c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dist_rgn_raw_4
		"distance raw value dep of csf efficiency threshold for medium conditions"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_dist_rgn_raw_4 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000666e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_exprsmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_down_prs_esti
		"Estimated CSF absolute downstream pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_pft_down_prs_esti 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007590 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dp
		"Particulate differential pressure"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_dp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007588 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dp_load_fil
		"Filtered differential pressure for soot estimation"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_dp_load_fil 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000758a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtempcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dtp
		"CSF downstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_dtp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000760a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtempcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dtp_fil
		"filtered CSF downstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_dtp_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000760c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_dtp_in
		"CSF downstream temperature for CSF up temp regulation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_dtp_in 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006444 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_efv_ff
		"Effective fuel mass flow desired into exhaust line"
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_efi_efv_ff 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007672 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_efv_ff_clc
		"Effective fuel mass flow computed"
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_efi_efv_ff_clc 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007676 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_ff
		"Fuel mass flow injected in exhaust line"
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_efi_ff 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_ff_cmd
		"Real fuel mass flow injected into the exhaust line"
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_efi_ff_cmd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007674 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_ff_cmd_ind
		"Index of real fuel mass flow injected into the exhaust line"
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_efi_ff_cmd_ind 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007678 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_ff_cmd_tmp_ind
		"Real fuel mass flow injected into the exhaust line."
		UWORD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_efi_ff_cmd_tmp_ind 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000767a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_fuel_rel_prs
		"Relative pressure of fuel injected in exhaust line (with regard to CSF up pressure) with time filter"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_pft_efi_fuel_rel_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000767c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_prs_pwm_cor
		"Correction for efi injector cycling opening percentage depending on efi fuel relative pres"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_efi_prs_pwm_cor 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000767e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_pwm_ind
		"Effective pwm desired into exhaust line"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efi_pwm_ind 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0007680 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_pwm_prct
		"Cycling opening percentage of the fuel injector in exhaust line"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efi_pwm_prct 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001004 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_pwm_prct_ind
		"Effective fuel mass flow computed."
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efi_pwm_prct_ind 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0007682 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_pwm_prct_ind_cor
		"Effective fuel mass flow computed."
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efi_pwm_prct_ind_cor 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0007684 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efi_pwm_rel
		"Cycling opening percentage required"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efi_pwm_rel 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0007686 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efy
		"CSF efficiency of storage soot emissions for efficiency interval calculation."
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efy 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006510 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efy_intv_rat
		"position between 2 pressure maps"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_pft_efy_intv_rat 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006512 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efy_prct
		"CSF efficiency of soot emissions storage."
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efy_prct 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000759e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efy_prct_comb
		"Local CSF efficiency of soot emissions storage"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efy_prct_comb 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efy_prct_reg
		"Local CSF soot storage efficiency"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efy_prct_reg 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006446 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_efy_prct_thd
		"Local CSF efficiency of soot emissions storage"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_efy_prct_thd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006670 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf
		"Exhaust gas air flow"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_egaf 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000757a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_cor
		"Corrected volumic exhaust gas flow"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_egaf_cor 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000757c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_dev_ms
		"Volumic flow derivative for soot estimation"
		UWORD
		ykuBijd_yAhnlEa_ffapzdb_ih_Raa0
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_egaf_dev_ms 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006514 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_err_mem
		"Last air flow in CSF for broken filter diagnosis release"
		UWORD
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_egaf_err_mem 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000648e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_ind_lkg
		"Class of volumic exhaust gas flow for CSF diagnosis in overload particule filter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_egaf_ind_lkg 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000206f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_load_fil
		"Filtered volumic exhaust gas flow"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_egaf_load_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000757e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_nr_zon
		"Zone number"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		11.
    DISPLAY_IDENTIFIER Vxx_pft_egaf_nr_zon 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000207c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_ovl_mem
		"Last air flow in CSF filter for overload diagnosis release"
		UWORD
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_egaf_ovl_mem 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_sot_esti
		"Combustion speed depending on particle filter temperatures and O2 concentration"
		UWORD
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_egaf_sot_esti 
    FORMAT "%6.5" 
    ECU_ADDRESS 0xd000652a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_egaf_tt_efi_int
		"Exhaust fuel injector thermal convection"
		UWORD
		ykmzBoa_nqupBma_Ffvbarc_m_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_egaf_tt_efi_int 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007604 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_clc_dtp1
		"Estimated downstream temperature of the CSF first ehr"
		ULONG
		umuqzbb_erxywEd_fpyrnod_KA_0n00
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_clc_dtp1 
    FORMAT "%8.3" 
    ECU_ADDRESS 0xd0004fec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_clc_dtp1_dly
		"Corrected CSF upstream temperature"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_clc_dtp1_dly 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006544 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_clc_dtp2
		"Estimated downstream temperature of the CSF second ehr"
		ULONG
		umuqzbb_erxywEd_fpyrnod_KA_0n00
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_clc_dtp2 
    FORMAT "%8.3" 
    ECU_ADDRESS 0xd0004ff0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_clc_dtp2_dly
		"Estimated downstream temperature of the CSF first ehr"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_clc_dtp2_dly 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006546 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_clc_dtp3
		"Estimated downstream temperature of the CSF third ehr"
		ULONG
		umuqzbb_erxywEd_fpyrnod_KA_0n00
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_clc_dtp3 
    FORMAT "%8.3" 
    ECU_ADDRESS 0xd0004ff4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_clc_dtp3_dly
		"Estimated downstream temperature of the CSF second ehr"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_clc_dtp3_dly 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006548 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_clc_dtp_ini
		"Initialisation of the downstream temperatures of all the CSF ehr"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_clc_dtp_ini 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000654a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ex_gas_mol_esti1
		"Number of exhaust gas moles in the first ehr of the CSF at each step time"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ex_gas_mol_esti1 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000654c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ex_gas_mol_esti2
		"Number of exhaust gas moles in the second ehr of the CSF at each step time"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ex_gas_mol_esti2 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd000654e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ex_gas_mol_esti3
		"Number of exhaust gas moles in the third ehr of the CSF at each step time"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ex_gas_mol_esti3 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006550 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ext_ar
		"Particle soot filter elementary homogeneous reactor weight"
		UWORD
		tysfkbc_CCoqjod_hCDmFFa_mCRa00a
		1
		100
		0.
		21.845
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ext_ar 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006552 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ms_esti1
		"First ehr of the CSF soot mass estimated during the regeneration"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ms_esti1 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd0004ff8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ms_esti2
		"Second ehr of the CSF soot mass estimated during the regeneration"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ms_esti2 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd0004ffc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ms_esti3
		"Third ehr of the CSF soot mass estimated during the regeneration"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ms_esti3 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd0005000 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ms_mol_dec_esti1
		"Estimated number of soot moles burned each step time for the first ehr"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ms_mol_dec_esti1 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006554 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ms_mol_dec_esti2
		"Estimated number of soot moles burned each step time for second ehr"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ms_mol_dec_esti2 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006556 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_ms_mol_dec_esti3
		"Estimated number of soot moles burned each step time for third ehr"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_ms_mol_dec_esti3 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006558 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_o2_fac_sot_esti1
		"Estimation of O2 concentration at the end of the first ehr of the particule filter"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_o2_fac_sot_esti1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000655a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_o2_fac_sot_esti2
		"Estimation of O2 concentration at the end of the second ehr of the particule filter"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_o2_fac_sot_esti2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000655c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_o2_fac_sot_esti3
		"Estimation of O2 concentration at the end of the third ehr of the particule filter"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_ehr_o2_fac_sot_esti3 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000655e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_o2_mol_esti1
		"Number of oxygen moles in the first ehr of the CSF at each step time"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_o2_mol_esti1 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006560 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_o2_mol_esti2
		"Number of oxygen moles in the second ehr of the CSF at each step time"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_o2_mol_esti2 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006562 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_o2_mol_esti3
		"Number of oxygen moles in the third ehr of the CSF at each step time"
		UWORD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_o2_mol_esti3 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006564 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_rgn_spd1
		"Estimated CSF soot regeneration speed in the first ehr of the csf"
		UWORD
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_rgn_spd1 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0006566 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_rgn_spd2
		"Estimated CSF soot regeneration speed in the second ehr of the csf"
		UWORD
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_rgn_spd2 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0006568 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_rgn_spd3
		"Estimated CSF soot regeneration speed in the third ehr of the csf"
		UWORD
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_ehr_rgn_spd3 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd000656a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ehr_wht
		"Particle soot filter elementary homogeneous reactor weight"
		UWORD
		tlquvwc_clelwCd_hCDzbFa_kCRa00a
		1
		100
		0.
		21.845
    DISPLAY_IDENTIFIER Vxx_pft_ehr_wht 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000656c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_eng_act_t_ctr
		"Active engine time counter"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_eng_act_t_ctr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007a34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_eva_sat
		"actual saturation value for oil evaporation process"
		UWORD
		RB_CONV_100_65535_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_pft_eva_sat 
    ECU_ADDRESS 0xd0006774 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_eva_sat_rat
		"Saturation ratio for oil evaporation"
		UWORD
		RB_CONV_0001_FACT
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vxx_pft_eva_sat_rat 
    ECU_ADDRESS 0xd0006776 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ex_gaz_cal_cpy1
		"Calorific capacity of the exhaust gas in the first ehr of the CSF"
		UWORD
		urDAtDb_lBAgnob_yDjBhub_JpA0o00
		1
		100
		1000.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_ex_gaz_cal_cpy1 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000656e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ex_gaz_cal_cpy2
		"Calorific capacity of the exhaust gas in the second ehr of the CSF"
		UWORD
		urDAtDb_lBAgnob_yDjBhub_JpA0o00
		1
		100
		1000.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_ex_gaz_cal_cpy2 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006570 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ex_gaz_cal_cpy3
		"Calorific capacity of the exhaust gas in the third ehr of the CSF"
		UWORD
		urDAtDb_lBAgnob_yDjBhub_JpA0o00
		1
		100
		1000.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_ex_gaz_cal_cpy3 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006572 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ext_cnvt_fac
		"Coefficient of external convection for the ehr of the CSF"
		UWORD
		awthFuc_dFDnrqd_ufrCFpb_Js__aa0
		1
		100
		0.
		65.
    DISPLAY_IDENTIFIER Vxx_pft_ext_cnvt_fac 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006574 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ext_temp
		"CSF external temperature"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		323.
    DISPLAY_IDENTIFIER Vxx_pft_ext_temp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006576 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_fim_driv
		"filtered value of fuel consumption for driving conditions"
		UWORD
		uztFExb_owBhqra_ykamwda_l__000a
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_fim_driv 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_flp_cor_oil_dil
		"Late post injection correction for oil dilution"
		SWORD
		RB_CONV_0001_FACT
		1
		100
		-3.2768
		3.2767
    DISPLAY_IDENTIFIER Vxx_pft_flp_cor_oil_dil 
    ECU_ADDRESS 0xd0006784 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_flp_pr_rat_oil_dil
		"Late post injection ration for oil dilution correction"
		UWORD
		RB_CONV_0001_FACT
		1
		100
		0.0
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_flp_pr_rat_oil_dil 
    ECU_ADDRESS 0xd0006778 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_hot_cold_dist_intv_ovs
		"Distance driven since begin of overshoot of the greatest learnt distance interval between hot or med or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_hot_cold_dist_intv_ovs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006602 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_hot_cold_req_dist_intv
		"Required distance interval to find a hot or medium or cold opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_hot_cold_req_dist_intv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_hot_dist_intv_ovs
		"Distance driven since begin of overshoot of the greatest learnt distance interval between hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_hot_dist_intv_ovs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006604 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_hot_med_dist_intv_ovs
		"Distance driven since begin of overshoot of the greatest learnt distance interval between hot or med opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_hot_med_dist_intv_ovs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006606 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_hot_med_req_dist_intv
		"Required distance interval to find a hot or medium opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_hot_med_req_dist_intv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_hot_req_dist_intv
		"Required distance interval to find a hot opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_hot_req_dist_intv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006608 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_bas
		"Current injected fuel mass flow basic setting considering engine operating point"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_bas 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006410 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_der_cor
		"Derivative correction of injected fuel mass flow"
		SLONG
		nrailqb_DCAAqvc_zltBgmb_mt__0a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_der_cor 
    FORMAT "%12.3" 
    ECU_ADDRESS 0xd0004f58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_dg
		"Derivative gain of injected fuel mass flow correction in regeneration mode"
		UWORD
		DFotjDa_nlDlFCb_kaockea_mqk_ao0
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_dg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0006412 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_ig
		"Integral gain of injected fuel mass flow correction in regeneration mode"
		UWORD
		lhizBec_Egvjjka_qDAiwFa_mpk_10a
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_ig 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0006414 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_int_cor
		"Integral correction of injected fuel mass flow"
		SLONG
		FlqkuDc_ublzpob_Cisqkrb_mtA_0o0
		1
		100
		-50.
		50.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_int_cor 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0004f5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_p_cor
		"Proportional correction of injected fuel mass flow"
		SLONG
		FlqkuDc_ublzpob_Cisqkrb_mtA_0o0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_p_cor 
    FORMAT "%12.5" 
    ECU_ADDRESS 0xd0004f60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_pg
		"Proportional gain of injected fuel mass flow correction in regeneration mode"
		UWORD
		ihoBjcc_mwetedb_lefmhic_mC_R1o0
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_pg 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006416 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_sat_rgn
		"Saturated injected fuel mass flow correction during regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_sat_rgn 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0006418 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_spc_cor
		"Global PID correction of injected fuel mass flow"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_spc_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000641a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_spc_cor_rgn
		"Mass flow PID correction during regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_spc_cor_rgn 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd0006408 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_inj_fms_spc_sat_rgn
		"Saturation overtaking of the unlimited injected fuel mass flow correction during regeneration"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_inj_fms_spc_sat_rgn 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000641c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_iter_nr
		"Number of mass model iteration"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_iter_nr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_iter_step
		"Iteration step for soot mass evolution"
		UBYTE
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		2.55
    DISPLAY_IDENTIFIER Vxx_pft_iter_step 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd000207d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_last_hot_cold_dist
		"Distance driven since last hot or medium or cold opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_last_hot_cold_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007938 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_last_hot_dist
		"Distance driven since last hot opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_last_hot_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000793a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_last_hot_med_dist
		"Distance driven since last hot or medium opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_last_hot_med_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000793c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_load_spd_dft
		"default soot load speed"
		UBYTE
		tqfnykb_zrjpzpb_cvihkvb_gC_o00a
		1
		100
		0.002
		0.35
    DISPLAY_IDENTIFIER Vxx_pft_load_spd_dft 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002098 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_malf_dp_fil
		"Filtered value for differential pressure."
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_malf_dp_fil 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_malf_egaf_fil
		"Filtered value for corrected volumic exhaust gas flow."
		UWORD
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_malf_egaf_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00064ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_malf_egaf_ind
		"Volumic exhaust gas flow class."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		40.
    DISPLAY_IDENTIFIER Vxx_pft_malf_egaf_ind 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002065 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_malf_mv_zon_1
		"CSF differential pressure average value on Zone 1"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_malf_mv_zon_1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_malf_mv_zon_2
		"CSF differential pressure average value on Zone 2"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_malf_mv_zon_2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_malf_mv_zon_3
		"CSF differential pressure average value on Zone 3"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_malf_mv_zon_3 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_malf_mv_zon_4
		"CSF differential pressure average value on Zone 4"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_malf_mv_zon_4 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_max_ms_tgt
		"Maximum soot mass target"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_max_ms_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006694 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_max_nr_ms_sp_zon
		"Number of point for average"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_max_nr_ms_sp_zon 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000207e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_max_rgn_t
		"Maximum regeneration time"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_max_rgn_t 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007a24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_med_cdn_tgt_dist
		"Minimum remaining distance with CSF regeneration condition target = Medium"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_med_cdn_tgt_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000790a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_med_cold_cdn_tgt_dist
		"Minimum remaining distance with CSF regeneration condition target = Medium or Cold"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_med_cold_cdn_tgt_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000790c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_ptissxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_min_is_n
		"Particule filter idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_pft_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007776 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_min_ms_spd_req_err
		"Particulate filter minimum soot mass to activate the speed request if rgn failure exceeded"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_min_ms_spd_req_err 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006672 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_min_mv_ms
		"Number of used zone"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_min_mv_ms 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000207f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cmp_agb_req
		"Soot mass stored at the regeneration start, to compare the mass decrease for auto gearbox req"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cmp_agb_req 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_msswixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor
		"Particulate filter soot mass (corrected)"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006588 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_ehr
		"Particulate filter soot mass (corrected) corrected in kilogramme and homogeneously distributed for each reactor"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_ehr 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd0005004 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_inj_dist_3
		"Soot mass correction dep of injector's mileage on threshold for max conditions."
		SWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		-250.
		250.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_inj_dist_3 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006674 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_tia_1
		"Soot mass threshold correction dep of intake temperature average value for hot conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_tia_1 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006676 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_tia_2
		"Soot mass threshold correction dep of intake temperature average value for cold conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_tia_2 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0006678 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_tia_3
		"Soot mass threshold correction dep of intake temperature average value for max conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_tia_3 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000667a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_tia_4
		"Soot mass threshold correction dep of intake temperature average value for medium conditions"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_tia_4 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd000667c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_vh_dist_1
		"Soot mass correction dep of vehicle distance on threshold for hot conditions."
		SWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		-250.
		250.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_vh_dist_1 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000667e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_vh_dist_2
		"Soot mass correction dep of vehicle distance on threshold for cold conditions."
		SWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		-250.
		250.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_vh_dist_2 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006680 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_vh_dist_3
		"Soot mass correction dep of vehicle distance on threshold for max conditions."
		SWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		-250.
		250.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_vh_dist_3 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006682 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_vh_dist_4
		"Soot mass correction dep of vehicle distance on threshold for medium conditions."
		SWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		-250.
		250.
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_vh_dist_4 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006684 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_cor_wio_ofs
		"Particulate filter soot mass (corrected) without cold start conditions offset."
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_cor_wio_ofs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006516 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_dp_dp_fil
		"Filtered CSF differential pressure information for ms backpressure calculation"
		UWORD
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_ms_dp_dp_fil 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007592 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_dp_egaf_cor
		"Corrected exhaust gas air flow"
		UWORD
		movAqed_DtteCgd_cloonha_Bh__10a
		1
		100
		0.
		2000.
    DISPLAY_IDENTIFIER Vxx_pft_ms_dp_egaf_cor 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007594 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_dp_ini
		"Initial value for soot mass PT1 filtering (read from eeprom)"
		UWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_dp_ini 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007596 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_dp_raw
		"Raw value of soot mass for differential pressure estimation"
		UWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_dp_raw 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007598 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_dp_reg
		"Local CSF equivalent load"
		UWORD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_dp_reg 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0006448 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_esti
		"CSF soot mass estimated during the regeneration"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_esti 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000652e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_esti_ini
		"Estimated soot mass in each elementary homogeneous reactor at the beginning of soot combustion in CSF"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ms_esti_ini 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd0005008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_in
		"Estimated soot mass left in CSF : strategy's input"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_in 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000644a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_lft
		"Estimated soot mass left in CSF"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_lft 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006582 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_lft_ini
		"Initial value of soot mass still stored when regeneration request state is left"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_lft_ini 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006584 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_lft_ini_cor
		"initial value of soot mass still stored when regeneration request state is left for ehr"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ms_lft_ini_cor 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd000500c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_lft_mdl
		"Non reseted estimated soot mass left in CSF"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_lft_mdl 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006524 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_new_pft_ofs
		"Mass offset due to green effect"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_new_pft_ofs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006518 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_ofs_clc_t
		"Time for soot mass offset computation for cold start conditions since the last key on."
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_ms_ofs_clc_t 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000651a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_ofs_clc_t_cor
		"Time for soot mass offset computation for cold start conditions since the last key on."
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_ms_ofs_clc_t_cor 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_ofs_corr
		"Corrected soot mass offset for cold start conditions."
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_ofs_corr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000651c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_ofs_fac_rgn
		"Correction factor to compute soot mass offset during regeneration"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_pft_ms_ofs_fac_rgn 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd000651e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_ofs_fac_rgn_lft
		"Correction factor to compute soot mass offset during regeneration with computation using mass from combustion model"
		UWORD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vxx_pft_ms_ofs_fac_rgn_lft 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd0006520 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_ofs_sta
		"Estimated soot mass offset for cold start conditions stored at the end og charging state."
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_ofs_sta 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006522 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_prs
		"Particulate filter soot mass (corrected)"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_prs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00064de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_prs_ehr
		"Particulate filter soot mass (ms_prs) corrected in kilogramme and homogeneously distributed for each reactor"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ms_prs_ehr 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd0005010 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_cold
		"Estimated soot mass threshold for cold conditions (dep of CSF efficiency)"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_cold 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006630 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_forc
		"Estimated soot mass threshold for forced regeneration (dep of CSF efficiency)"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_forc 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006686 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_hot
		"Estimated soot mass threshold for hot conditions (dep of CSF efficiency)"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_hot 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006632 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_med
		"Estimated soot mass threshold for medium thermal regeneration conditions (dep of CSF efficiency)"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_med 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006634 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_mini
		"Estimated soot mass threshold for mini conditions  (dep of CSF efficacity)"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_mini 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006688 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_raw_1
		"Soot mass threshold raw value for hot conditions"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_raw_1 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000668a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_raw_2
		"Soot mass threshold raw value for cold conditions"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_raw_2 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000668c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_raw_3
		"Soot mass threshold raw value for maximum conditions"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_raw_3 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000668e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_rgn_raw_4
		"Soot mass threshold raw value for medium conditions"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_rgn_raw_4 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006690 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_miofxxx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_sim
		"Simulated soot mass charged in CSF"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_sim 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006580 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_sim_ehr
		"Particulate filter soot mass (ms_sim) corrected in kilogramme and homogeneously distributed for each reactor"
		ULONG
		zvldabd_plckxob_dwyrutb_k__00o0
		1
		100
		0.
		0.065535
    DISPLAY_IDENTIFIER Vxx_pft_ms_sim_ehr 
    FORMAT "%12.10" 
    ECU_ADDRESS 0xd0005014 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_sim_sta
		"Simulated soot mass charged in CSF stored at the regeneration start"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_sim_sta 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006590 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_sta
		"Memory of soot mass at exit of charging state"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_ms_sta 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006592 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_sta_asd
		"Initial ssot mass value at ASD regeneration start used for CSF up temp variable set point"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_sta_asd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000645c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_ms_wait_cdn
		"Particulate filter soot mass (corrected) threshold to activate waiting mode"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_ms_wait_cdn 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006618 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_mv_pos_sot_load_spd
		"Average positive soot load speed"
		UBYTE
		tqfnykb_zrjpzpb_cvihkvb_gC_o00a
		1
		100
		0.002
		0.35
    DISPLAY_IDENTIFIER Vxx_pft_mv_pos_sot_load_spd 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0002095 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_n_tqi_oil_csm
		"Oil consumption due to engine speed and torque set point"
		UWORD
		qdgunob_kBlEwyb_bgBrBgd_k__00a0
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_n_tqi_oil_csm 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd000762c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_no_lk_dyn_val
		"OBD memorized failure status for Broken CSF diagnostic"
		SBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		-128.
		127.
    DISPLAY_IDENTIFIER Vxx_pft_no_lk_dyn_val 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002060 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nok_cge_max_ini
		"Initial value of minimum threshold for Malfunctioning CSF Diagnosis on mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_nok_cge_max_ini 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nok_cge_min
		"Minimum threshold for Malfunctioning CSF Diagnosis on mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_nok_cge_min 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006492 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nok_cge_val_ini
		"Initial value of diagnosis criterion for Malfunctioning CSF Diagnosis on mod6"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_pft_nok_cge_val_ini 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00064b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nr_driv_cdn
		"Type of driving condition : 0 = regeneration ; 1 = noregeneration"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_pft_nr_driv_cdn 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002080 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nr_efy_intv
		"Efficiency interval of Cmp_pft_dp_egaf"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vxx_pft_nr_efy_intv 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002081 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nxt_hot_cold_req_dist
		"Required distance from now on to find a hot or medium or cold opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_nxt_hot_cold_req_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nxt_hot_med_req_dist
		"Required distance from now on to find a hot or medium opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_nxt_hot_med_req_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006600 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_nxt_hot_req_dist
		"Required distance from now on to find a hot opportunity"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_nxt_hot_req_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000660a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_o2facxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_o2_fac_sot_esti
		"Estimation of O2 concentration"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_o2_fac_sot_esti 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000759a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_oil_ash_wht
		"Ash mass stored in the catalytic soot filter"
		UWORD
		Dweusab_Abjlppc_wagagja_kCRa00a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_oil_ash_wht 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd00075a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_oil_dil_dec
		"oil dilution decrement"
		UWORD
		RB_CONV_0000001_PrcperSec
		1
		100
		0.0
		0.0065535
    DISPLAY_IDENTIFIER Vxx_pft_oil_dil_dec 
    ECU_ADDRESS 0xd000677a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_oil_dil_dev
		"difference between actual dilution rate and saturation value"
		UWORD
		RB_CONV_100_65535_Prc
		1
		100
		0.0
		100.0
    DISPLAY_IDENTIFIER Vxx_pft_oil_dil_dev 
    ECU_ADDRESS 0xd000677c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_oil_dil_inc
		"oil dilution increment"
		UWORD
		RB_CONV_0000001_Prc
		1
		100
		0.0
		0.0065535
    DISPLAY_IDENTIFIER Vxx_pft_oil_dil_inc 
    ECU_ADDRESS 0xd0006780 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_oil_efy_prct
		"CSF efficiency of storage soot emissions dependent on the engine oil consumption"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_oil_efy_prct 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00075a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_oil_eva_kin_fac
		"Kinetic factor for oil dilution evaporatio"
		UWORD
		RB_CONV_00001_PerSec
		1
		100
		0.0
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_oil_eva_kin_fac 
    ECU_ADDRESS 0xd000677e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_per_hot_cold_req_dist
		"Required distance from now on to find a hot, med or cold opportunity if we are confident in learnt dist intervals between such opp"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_per_hot_cold_req_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000660c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_per_hot_cold_req_intv
		"Required distance interval to find a hot, med or cold opportunity if we are confident in learnt distance intervals between such opp"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_per_hot_cold_req_intv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000660e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_per_hot_med_req_dist
		"Required distance from now on to find a hot or med opportunity if we are confident in learnt distance intervals between such opp"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_per_hot_med_req_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006610 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_per_hot_med_req_intv
		"Required distance interval to find a hot or medium opportunity if we are confident in learnt distance intervals between such opp"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_per_hot_med_req_intv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006612 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_per_hot_req_dist
		"Required distance from now on to find a hot opportunity if we are confident in learnt distance intervals between hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_per_hot_req_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006614 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_per_hot_req_intv
		"Required distance interval to find a hot opportunity if we are confident in learnt distance intervals between hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_per_hot_req_intv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006616 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_reac_entp1
		"CSF soot combustion chemicalreaction enthalpy for the first ehr"
		UWORD
		lxAelrc_vppcEuc_udFlEud_Jo__00a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_pft_reac_entp1 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0006578 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_reac_entp2
		"CSF soot combustion chemicalreaction enthalpy for the second ehr"
		UWORD
		lxAelrc_vppcEuc_udFlEud_Jo__00a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_pft_reac_entp2 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000657a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_reac_entp3
		"CSF soot combustion chemicalreaction enthalpy for the third ehr"
		UWORD
		lxAelrc_vppcEuc_udFlEud_Jo__00a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_pft_reac_entp3 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000657c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_agb_t
		"Time since the regeneration start detection for automatic gearbox request for regeneration"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_rgn_agb_t 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00066a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_err_max_cold_cnd
		"Maximum counter value to activate waiting mode in cold conditions"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_err_max_cold_cnd 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00020d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_err_vh_dist_forc
		"Distance threshold for forced regeneration in case of failure (dep of CSF efficiency )"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_err_vh_dist_forc 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006692 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_intv_req_dist
		"Remaining distance before distance since last regeneration request overruns the minimum distance between two regenerations"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_intv_req_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000669e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_mod_nr
		"Memory of engine state (cold or hot or mini or med) at exit of charging state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_mod_nr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002091 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnsucx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_ok_nr
		"Number of successful regeneration."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_pft_rgn_ok_nr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00020cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_req_t_ctr
		"Counter for the time spent in the regeneration request state"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_rgn_req_t_ctr 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007a1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rgn_stop_ms_abv_thd
		"Absolute threshold on estimated combusted soot mass for regeneration end detection"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_rgn_stop_ms_abv_thd 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0006586 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_o2facxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_rich_esti
		"Estimation of richness"
		UBYTE
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		1
		100
		0.
		2.55
    DISPLAY_IDENTIFIER Vxx_pft_rich_esti 
    FORMAT "%4.2" 
    ECU_ADDRESS 0xd00022ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_sat_pr
		"saturation deviation (mass flow)"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_sat_pr 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000a7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_spd_drv_fil
		"Filtered vehicle speed for driving conditions."
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_spd_drv_fil 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007a38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_sys_clc_dtp
		"CSF downstream temperature calculated in combustion model"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_sys_clc_dtp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006530 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_sys_egaf
		"Exhaust gas air mass flow for estimation of downstream pressure and temperature models."
		UWORD
		mdsqBzb_nhvunBc_cgBrBwc_k__00a0
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_pft_sys_egaf 
    FORMAT "%8.6" 
    ECU_ADDRESS 0xd0007580 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_t_ofs
		"Timer offset to count time since last regeneration"
		UWORD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_t_ofs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007a26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_temp_fac_sot_esti
		"Internal CSF temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_temp_fac_sot_esti 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000652c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_tia_cor_mv_clc
		"Intake air temperature computed average value of loading state used for PFT threshold adaptation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_cor_mv_clc 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd00075b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_tia_cor_mv_str
		"Stored average value of intake air temperature in charging state"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_cor_mv_str 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd00075b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_tia_cor_sta
		"Total distance driven since last regeneration update at the Ecu init stored in eeprom"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_cor_sta 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd00075b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_tia_mv
		"Intake air temperature average value of loading state used for PFT threshold adaptation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_mv 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd00075ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_tia_mv_lh
		"Intake air temperature average value of loading state used for PFT threshold adaptation (strategy data)"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_mv_lh 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0006598 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_tia_mv_out
		"Local intake air temperature average value of loading state used for PFT threshold adaptation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_mv_out 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000661a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_tia_mv_thd
		""
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_pft_tia_mv_thd 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0006636 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_toil_clc
		"Recalculated oil temperature"
		UWORD
		RB_CONV_DegC
		1
		100
		-40
		200
    DISPLAY_IDENTIFIER Vxx_pft_toil_clc 
    ECU_ADDRESS 0xd000678a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_uprscsx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_up_prs
		"CSF upstream pressure information"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_pft_up_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00075bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_uprscsx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_up_prs_fil
		"CSF filtered upstream pressure"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_pft_up_prs_fil 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00075be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utempcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp
		"CSF upstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007612 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_cor
		"Corrected CSF upstream temperature"
		UWORD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		1
		100
		233.
		1473.
    DISPLAY_IDENTIFIER Vxx_pft_utp_cor 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000657e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_cor_sp
		"Setpoint value of CSF upstream temperature regulator"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_cor_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006450 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_driv
		"filtered value of CSF upstream temperature for driving conditions"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_driv 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007a3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_esti
		"Inert catalyst model prediction of the exhaust gas temperature downstream of the catalyst"
		UWORD
		RB_CONV_AtCatDgn_DegC
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_esti 
    ECU_ADDRESS 0xd00063bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_esti_dly
		"Inert catalyst model prediction of the exhaust gas temperature delayed"
		UWORD
		RB_CONV_AtCatDgn_DegC
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_esti_dly 
    ECU_ADDRESS 0xd00063be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utempcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_fil
		"Filtered CSF upstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007614 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_fms_bas
		"CSF up temp for basic engine settings in regeneration mode"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_fms_bas 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000641e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_fms_bas_ftc
		"Filtering time constant of CSF up temp"
		UWORD
		isbAByd_airlCCb_devbarc_s_R0ooa
		1
		100
		0.
		6553.5
    DISPLAY_IDENTIFIER Vxx_pft_utp_fms_bas_ftc 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006420 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_inj_fms_bas
		"Fuel mass flow basic setting considering engine operating point"
		UWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_utp_inj_fms_bas 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000640a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_inj_fms_fac
		"CSF up temp / injected fuel mass flow gain"
		UWORD
		ihoBjcc_mwetedb_lefmhic_mC_R1o0
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_utp_inj_fms_fac 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006422 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_inj_fms_prectl_cor
		"Pre control correction of injected fuel mass flow"
		SWORD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_utp_inj_fms_prectl_cor 
    FORMAT "%7.2" 
    ECU_ADDRESS 0xd000640c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utempcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_load_fil
		"CSF filtered upstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_load_fil 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007616 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_max_sp
		"Maximum CSF upstream temperature setpoint"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_max_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000645e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_mv
		"CSF upstream temperature mean value"
		ULONG
		fkydtnb_xBgCwha_blhnpEd_q__0a00
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_mv 
    FORMAT "%11.4" 
    ECU_ADDRESS 0xd0004f0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_ofs_ad
		"Integrated value of the error"
		ULONG
		RB_CONV_AtCatDgn_8388608
		1
		100
		-83886.08
		83886.07
    DISPLAY_IDENTIFIER Vxx_pft_utp_ofs_ad 
    ECU_ADDRESS 0xd0004f44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_reg
		"Local CSF upstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_reg 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000644c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_reg_loop_dev
		"Loop deviation of the ttr regulator"
		SWORD
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_reg_loop_dev 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006452 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_reg_ovs
		"Maximum CSF up temp regulation overshoot"
		SWORD
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		1
		100
		-1200.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_reg_ovs 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006460 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_sp
		"CSF upstream temperature set point"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006454 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_sp_cor
		"CSF up temp set point environmental correction"
		UWORD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		1
		100
		0.
		6.5535
    DISPLAY_IDENTIFIER Vxx_pft_utp_sp_cor 
    FORMAT "%6.4" 
    ECU_ADDRESS 0xd0006462 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_sp_max
		"Maximum CSF up temp set point"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_sp_max 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006464 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_sp_raw
		"CSF upstream temperature set point before variation evaluation"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_sp_raw 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006466 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_utp_var_sp
		"Variable CSF up temp set point"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_pft_utp_var_sp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0006456 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftdist_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_vh_dist
		"Driven distance since new soot filter"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftdist_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_vh_dist_l_res
		"Low resolution driven distance since new soot filter"
		UWORD
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		1
		100
		0.
		1048560.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_l_res 
    FORMAT "%7.0" 
    ECU_ADDRESS 0xd000759c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_vh_dist_m_acry_sta
		"Intake air temperature computed average value of loading state used for PFT threshold adaptation"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_m_acry_sta 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_vh_dist_oil_csm
		"Oil consumption correction factor due to vehicle mileage"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_oil_csm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000762e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_vh_dist_rgn
		"Vehicle distance driven since last regeneration"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_rgn 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006594 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_vh_dist_rgn_tia_mv
		"Total distance driven since last regeneration update at the Ecu init"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Vxx_pft_vh_dist_rgn_tia_mv 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlvsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_vs_fil
		"Filtered vehicle speed"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_pft_vs_fil 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007afc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_pft_wait_req_min_ms
		"Minimum soot mass necessary to enable waiting mode activation request"
		UWORD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_pft_wait_req_min_ms 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00066a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_pow_r
		"Vxx_pow_r"
		SWORD
		VA_F_10_p0_11
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd00010e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_pow_r_fil
		"Vxx_pow_r_fil"
		SWORD
		VA_F_10_p0_11
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd00010f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_pow_r_raw
		"Vxx_pow_r_raw"
		SWORD
		VA_F_10_p0_11
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd00010f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_pow_r_req_down
		"Vxx_pow_r_req_down"
		SWORD
		VA_F_10_p0_17
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd0001098 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_pow_r_req_up
		"Vxx_pow_r_req_up"
		SWORD
		VA_F_10_p0_17
		2
		100
		-327680
		327670
    ECU_ADDRESS 0xd000109a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_slicoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_prim_sha_n_rat
		"Primary shaft speed/Engine speed ratio"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.9921875
    DISPLAY_IDENTIFIER Vxx_prim_sha_n_rat 
    FORMAT "%8.6" 
    ECU_ADDRESS 0xd0001c86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_tbspdcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_prim_sha_spd
		"Primary shaft speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_prim_sha_spd 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0000df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_prs_dft_min_is_n
		"Manifold pressure sensor failure idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_prs_dft_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000774e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ptc_max_pow_ena
		"PTC maximum power allowed"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_ptc_max_pow_ena 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00077be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ptc_min_is_n
		"PTC idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_ptc_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000775a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_ptcpocs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ptc_pow
		"PTC power consumed"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_ptc_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000765e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_ptq
		"Value of the pumping torque"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_ptq 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_pwst_min_is_n
		"Power steering idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_pwst_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007774 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_rat_tgt
		"Gear ratio target of the current possible gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_rat_tgt 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000191e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_raw_ac_pow
		"Air conditioning power not taking into account compressor state"
		UWORD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_raw_ac_pow 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0001932 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_arbitxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_raw_arb_no_agb_tqe
		"target torque request wihout agb request"
		UWORD
		uyoDvwa_FycErrc_bzelawd_N__310a
		1
		100
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Vxx_raw_arb_no_agb_tqe 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00011ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_raw_map
		"Manifold pressure value before filter"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_raw_map 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_raw_n_dif_drv
		"Derivative of difference between engine speed and idle speed setpoint by report to the time"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_raw_n_dif_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00011d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_derivxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_raw_n_drv
		"raw derivate of engine speed"
		SWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		-8192.
		8191.
    DISPLAY_IDENTIFIER Vxx_raw_n_drv 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000e54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_raw_sens_pft_rel_up_prs_cor
		"PFT relative pressure corrected value measurement"
		UWORD
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_raw_sens_pft_rel_up_prs_cor 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00075a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_raw_sta_tq
		"Raw Starting Torque"
		UWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		0.
		2047.96875
    DISPLAY_IDENTIFIER Vxx_raw_sta_tq 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00009ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_raw_ups_lamb
		"Upstream proportional sensor lambda value before filtering"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-32.768
		32.767
    DISPLAY_IDENTIFIER Vxx_raw_ups_lamb 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd0000dca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_raw_ups_lamb_clc
		"Calculated lambda before filtering"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-32.768
		32.767
    DISPLAY_IDENTIFIER Vxx_raw_ups_lamb_clc 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd0000dcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_raw_ups_rich
		"Upstream proportional sensor richness before filtering"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_raw_ups_rich 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000dce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_raw_ups_rich_clc
		"Calculated richness before filtering"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_raw_ups_rich_clc 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000dd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_rel_err
		"Relative error of the speeds of rear wheels"
		SWORD
		ihlElic_Eatfvkd_DxdrElb_n_o7300
		1
		100
		-0.450002
		0.450002
    DISPLAY_IDENTIFIER Vxx_rel_err 
    FORMAT "%9.6" 
    ECU_ADDRESS 0xd0000e7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_rel_err_mv
		"Relative error of the radiuses of rear wheels"
		SWORD
		ihlElic_Eatfvkd_DxdrElb_n_o7300
		1
		100
		-0.450002
		0.450002
    DISPLAY_IDENTIFIER Vxx_rel_err_mv 
    FORMAT "%9.6" 
    ECU_ADDRESS 0xd0000e80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_rel_err_mv_dly
		"Rel_error_avg value delayed from one sample time"
		SWORD
		ihlElic_Eatfvkd_DxdrElb_n_o7300
		1
		100
		-0.450002
		0.450002
    DISPLAY_IDENTIFIER Vxx_rel_err_mv_dly 
    FORMAT "%9.6" 
    ECU_ADDRESS 0xd0000e82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rfar_rich_calc
		"Relative fuel air ratio"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_rfar_rich_calc 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000dd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_rwsxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_rgt_rwhs
		"Rear right wheel speed"
		UWORD
		uEardjb_BFoibqb_vkamstb_khA_00a
		1
		100
		0.
		655.34
    DISPLAY_IDENTIFIER Vxx_rgt_rwhs 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_amp_cor_pr
		"Atmospheric pressure correction for rail pressure during pr"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_amp_cor_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_amp_fac_pr
		"Slow process of atmospheric pressure factor's correction for rail pressure during pr"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_rps_amp_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_amp_tco_cor_rij
		"Atmospheric pressure correction for rail pressure"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_amp_tco_cor_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_amp_tco_fac_rij
		"Slow process of atmospheric pressure factor's correction for rail pressure"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_rps_amp_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_bas_pr
		"Basic rail pressure during pr"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_bas_pr 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000bec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_bas_prs_rij
		"Basic rail pressure"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_bas_prs_rij 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000bfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cold_tco_rij
		"Rail pressure for cold coolant temperature"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_cold_tco_rij 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000c00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cor_pr
		"Correction for rail pressure during ppr"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_cor_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cor_rij
		"correction for rail pressure"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_cor_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000c02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cor_sp_npu
		"Rail pressure set point during Nox rgn"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_cor_sp_npu 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cor_sp_pr
		"Rail pressure set point during pr"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_cor_sp_pr 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000be6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cor_sp_rij
		"Rail pressure set point during regular injection"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_cor_sp_rij 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000bf8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_xxwiont_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cor_sp_spu
		"Rail pressure set point during spu"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_cor_sp_spu 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000c0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_cor_sp_sta
		"Rail pressure set point during Starting Combustion Mode"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_cor_sp_sta 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00017b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_dp_rail_prs
		"Delta rail pressure : difference between rail pressure corrected and rail pressure limited by the gr"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_dp_rail_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00017b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_lim_abs
		"Rail pressure setpoint limitation absolute"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_lim_abs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00017b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_lim_tfu
		"Rail pressure setpoint decrease by fuel temperature"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_lim_tfu 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00017b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_mv_tco_rij
		"Rail pressure for medium coolant temperature"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_mv_tco_rij 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0000c04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_rail_prs_no_lim
		"No limited rail pressure"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_rail_prs_no_lim 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00017b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_rail_prs_raw
		"Rail pressure raw, output of rail pressure multi port switch"
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_rail_prs_raw 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00017ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_rail_prs_sp
		""
		UWORD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		1
		100
		0.
		4500.
    DISPLAY_IDENTIFIER Vxx_rps_rail_prs_sp 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd00017bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_tco_cor_pr
		"Coolant temperature correction for rail pressure during pr"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_tco_cor_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000bf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_tco_fac_pr
		"Slow process of coolant temperature factor's correction for rail pressure during pr"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_rps_tco_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bf2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_tco_fac_rij
		"Coolant temperature factor for interpollation 3D"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_rps_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_tia_cor_pr
		"Intake air temperature correction for rail pressure during pr"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_tia_cor_pr 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_tia_fac_pr
		"Slow process of intake air temperature factor's correction for rail pressure during pr"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_rps_tia_fac_pr 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000bf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_tia_tco_cor_rij
		"Intake air temperature correction for rail pressure"
		UWORD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		1
		100
		-2000.
		2000.
    DISPLAY_IDENTIFIER Vxx_rps_tia_tco_cor_rij 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000c08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rps_tia_tco_fac_rij
		"Slow process of intake air temperature factor's correction for rail pressure"
		UWORD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		1
		100
		-5.
		5.
    DISPLAY_IDENTIFIER Vxx_rps_tia_tco_fac_rij 
    FORMAT "%5.2" 
    ECU_ADDRESS 0xd0000c0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007544 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0002286 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000228d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007546 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002287 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002288 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_mv_ad_fac
		"Stored Mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0002289 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007548 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000754a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000228a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000754c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000228b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000228c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_run_vh_min_is_n
		"Running vehicule idle speed setpoint"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_run_vh_min_is_n 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00009a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rup_dif
		"Difference pressure to apply on the PFT relative pressure for adaptation"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_rup_dif 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00075aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rup_dif_raw
		"Raw Difference pressure to apply on the PFT relative pressure for adaptation"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_rup_dif_raw 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00075ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rup_lkg_pft_sys_egaf_fil
		"Filtered exhaust gas air mass flow"
		UWORD
		mdsqBzb_nhvunBc_cgBrBwc_k__00a0
		1
		100
		0.
		0.65535
    DISPLAY_IDENTIFIER Vxx_rup_lkg_pft_sys_egaf_fil 
    FORMAT "%8.6" 
    ECU_ADDRESS 0xd00075ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rup_lkg_raw_sens_rup_fil
		"Filtered PFT relative pressure from sensor"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_rup_lkg_raw_sens_rup_fil 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00075b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_rupc_hpf_rup
		"PFT relative pressure filtered value measurement"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_rupc_hpf_rup 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00075b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_rwhs_diff
		"Difference between the speeds of rear wheels"
		SWORD
		lvAAcdc_BCAqbxd_kCDnrhc_m__000a
		1
		100
		-32.768
		32.767
    DISPLAY_IDENTIFIER Vxx_rwhs_diff 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd0000e84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_rwhs_sum
		"Sum of the speeds of rear wheels"
		UWORD
		iyavyEb_EuAdyma_ysgmsda_m__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vxx_rwhs_sum 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0000e86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vxx_sdl_ecu_stt_diag
		"State of Speed and Distance Limiter Control Unit failure detection for Mux Network frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sdl_ecu_stt_diag 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001a7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciacc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciacc_noaccxx_data.c' */
/begin MEASUREMENT
		Vxx_sdl_forc_sp
		"Driving force requested by speed and distance limiter."
		UWORD
		mbowslc_inojbha_jnBnagc_N__010a
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER VXX_SDL_FORC_SP 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007b14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sdl_pwt_sp
		"Powertrain setpoint (%) requested by SDL (Speed and distance limiter function located in ACC)"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_sdl_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0000944 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfsr_stbxxx_data.c' */
/begin MEASUREMENT
		Vxx_sens_alt_fil_pwm
		"filtered wire frame alternator load"
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_sens_alt_fil_pwm 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00022ff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_doc1_utp
		"measured temperature before oxydation 1"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_sens_doc1_utp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd00075c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_ex_prs
		"Exhaust manifold pressure from sensor"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_sens_ex_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007578 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_maf
		"Mass air flow from sensor"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_sens_maf 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007568 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_maf_puls_cor
		"Corrected mass air flow from sensor"
		UWORD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		1
		100
		0.
		5000.
    DISPLAY_IDENTIFIER Vxx_sens_maf_puls_cor 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000756a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_map
		"Manifold pressure from sensor"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_sens_map 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_uprsabv_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_abv_up_prs
		""
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_sens_pft_abv_up_prs 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000dc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftdpsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_dp
		"CSF differential pressure sensor acquisition"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_sens_pft_dp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000db6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_dp_in
		"Local system difference pressure"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_sens_pft_dp_in 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006490 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtpdiag_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_dtp
		"CSF downstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_sens_pft_dtp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000760e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_malf_dp_in
		"Local system difference pressure for malfunction diagnosis"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_sens_pft_malf_dp_in 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00064ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_ovl_prs_in
		"Local system pressure."
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_sens_pft_ovl_prs_in 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0000a8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_rel_up_prs
		"CSF upstream relative pressure from sensor"
		SWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		-10000.
		10000.
    DISPLAY_IDENTIFIER Vxx_sens_pft_rel_up_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00075a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_pft_utp
		"CSF upstream temperature"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_sens_pft_utp 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd000761a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_spg
		"Boost pressure measurement value from sensor"
		UWORD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		1
		100
		0.
		20000.
    DISPLAY_IDENTIFIER Vxx_sens_spg 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0000d78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_tbt
		"measured temperature before turbine"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		1200.
    DISPLAY_IDENTIFIER Vxx_sens_tbt 
    FORMAT "%6.1" 
    ECU_ADDRESS 0xd0007620 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sens_tco
		"Engine coolant temperature (sensor)"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_sens_tco 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007628 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sens_tco_frz
		"Frozen engine coolant temperature in case of detected failure (sensor)"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_sens_tco_frz 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000762a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilubc_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sens_toil
		"Oil temperature from sensor"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_sens_toil 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd0007630 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_up_it_temp
		"Upstream throttle temperature measurement value"
		UWORD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		1
		100
		-40.
		200.
    DISPLAY_IDENTIFIER Vxx_sens_up_it_temp 
    FORMAT "%5.1" 
    ECU_ADDRESS 0xd000756e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_ups_lamb
		"Lambda value from upstream proportional sensor"
		SWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		-32.768
		32.767
    DISPLAY_IDENTIFIER Vxx_sens_ups_lamb 
    FORMAT "%7.3" 
    ECU_ADDRESS 0xd0000dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vxx_sens_ups_rich
		"Richness from upstream proportional sensor"
		UWORD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vxx_sens_ups_rich 
    FORMAT "%5.3" 
    ECU_ADDRESS 0xd0000dd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_sitmonx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_sit_psn_sp_2
		"Position setpoint before inversion cartography."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_sit_psn_sp_2 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0000ffe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_sitmonx_stbxxd_data.c' */
/begin MEASUREMENT
		Vxx_sit_psn_sp_cmd
		"Position setpoint sent by the monitoring system."
		SWORD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_sit_psn_sp_cmd 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0001000 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_slarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sl_forc_sp
		"Driving force requested by Speed Limiter"
		SLONG
		akxoDid_fubczib_zregbrc_N_R05oa
		1
		100
		-20000.
		111068.
    DISPLAY_IDENTIFIER Vxx_sl_forc_sp 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0004998 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sl_pwt_sp
		"Powertrain setpoint (%) requested by Speed Limiter"
		UWORD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vxx_sl_pwt_sp 
    FORMAT "%7.5" 
    ECU_ADDRESS 0xd0000946 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_brk_buf
		"Buffer of the 16 last seconds of the brake status"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_sli_brk_buf 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007718 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_clu_buf
		"Buffer of the 16 last seconds of the clutch status"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_sli_clu_buf 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000771a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_cru_stt_buf
		"Buffer of the 16 last seconds of the cruise control status"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_sli_cru_stt_buf 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000771c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[0]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[0] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002337 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[10]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[10] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002341 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[11]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[11] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002342 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[12]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[12] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002343 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[13]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[13] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002344 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[14]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[14] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002345 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[15]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[15] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002346 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vxx_sli_vs_buf[1]
		"Buffer of the 16 last seconds of the vehicle speed"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_sli_vs_buf[1] 
    FORMAT "%3.0" 
