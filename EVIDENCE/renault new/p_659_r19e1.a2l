			Vxx_pft_dist_cor_inj_dist_1
			Vxx_pft_dist_cor_inj_dist_2
			Vxx_pft_dist_cor_inj_dist_3
			Vxx_pft_dist_cor_inj_dist_4
			Vxx_pft_dist_cor_tia_1
			Vxx_pft_dist_cor_tia_2
			Vxx_pft_dist_cor_tia_3
			Vxx_pft_dist_cor_tia_4
			Vxx_pft_dist_cor_vh_tot_1
			Vxx_pft_dist_cor_vh_tot_2
			Vxx_pft_dist_cor_vh_tot_3
			Vxx_pft_dist_cor_vh_tot_4
			Vxx_pft_dist_min_rgn_err_thd
			Vxx_pft_dist_rgn_5
			Vxx_pft_dist_rgn_cold
			Vxx_pft_dist_rgn_hot
			Vxx_pft_dist_rgn_med
			Vxx_pft_dist_rgn_mini
			Vxx_pft_dist_rgn_raw_1
			Vxx_pft_dist_rgn_raw_2
			Vxx_pft_dist_rgn_raw_3
			Vxx_pft_dist_rgn_raw_4
			Vxx_pft_min_ms_spd_req_err
			Vxx_pft_ms_cor_inj_dist_3
			Vxx_pft_ms_cor_tia_1
			Vxx_pft_ms_cor_tia_2
			Vxx_pft_ms_cor_tia_3
			Vxx_pft_ms_cor_tia_4
			Vxx_pft_ms_cor_vh_dist_1
			Vxx_pft_ms_cor_vh_dist_2
			Vxx_pft_ms_cor_vh_dist_3
			Vxx_pft_ms_cor_vh_dist_4
			Vxx_pft_ms_rgn_cold
			Vxx_pft_ms_rgn_forc
			Vxx_pft_ms_rgn_hot
			Vxx_pft_ms_rgn_med
			Vxx_pft_ms_rgn_mini
			Vxx_pft_ms_rgn_raw_1
			Vxx_pft_ms_rgn_raw_2
			Vxx_pft_ms_rgn_raw_3
			Vxx_pft_ms_rgn_raw_4
			Vxx_pft_rgn_err_vh_dist_forc
			Vxx_pft_efy_prct_thd
			Vxx_pft_rgn_err_max_cold_cnd
			Vxx_pft_tia_mv_thd
			Vxx_pft_dist_cor_inj_dist_5
			Vxx_pft_dist_cor_tia_5
			Vxx_pft_dist_cor_vh_tot_5
			Vbx_pft_cold_rgn_ena
			Vbx_pft_hot_rgn_ena
			Vbx_pft_med_rgn_ena
			Vbx_pft_max_ctr_rgn_err_cold
			Vbx_pft_max_ctr_rgn_err_hot
			Vbx_pft_max_ctr_rgn_err_med
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Waitreq
		""
	/begin DEF_CHARACTERISTIC
			Ctp_pft_vh_dist_cold_ms_tgt
			Ctp_pft_vh_dist_max_ms_tgt
			Ctp_pft_dist_wait_req_min_ms
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_dist_load_min_rgn_forb
			Vbx_pft_ms_thd_clc
			Vbx_pft_wait_mod_act_req
			Vsx_pft_wait_req_stt
			Vxx_pft_aftr_rgn_intv_dist_ms
			Vxx_pft_bfr_cold_ms_tgt_dist
			Vxx_pft_bfr_max_ms_tgt_dist
			Vxx_pft_cold_thd_ms_tgt
			Vxx_pft_max_ms_tgt
			Vxx_pft_rgn_intv_req_dist
			Vxx_pft_wait_req_min_ms
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/begin FUNCTION
		AtSpvArb
		""
	/begin OUT_MEASUREMENT
			AtSpvArb_NVM.Vxx_pft_dfl_vh_dist_aut_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			AtSpvArb_Combreq
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/begin FUNCTION
		AtSpvArb_Combreq
		""
	/* ASAP2::Database : delete 'Csx_comb_mod_req_egt_stb' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Cbx_egt_mnl_sel
			Cbx_min_lvl_rgn_ena_swi
			Cbx_pft_agb_req_ena
			Cbx_pft_eng_sp_max_ena
			Cbx_pft_eng_sp_max_ena2
			Cbx_pft_map_wait_cdn_vld
			Cbx_pft_tco_wait_cdn_vld
			Cbx_pft_wait_cdn_egr_cut
			Csx_egt_comb_mod_mnl
			Csx_pft_eng_sp_max
			Csx_pft_stt_agb_msk
			Ctb_pft_eng_sp_agb_req
			Cxx_pft_cmp_agb_req_t
			Cxx_pft_ms_cmp_rat_max
			Cxx_pft_ms_cmp_rat_min
			Cxx_pft_ms_lft_rat_agb_req
			Cxx_pft_ms_lft_rat_max
			Cxx_pft_ms_lft_rat_min
			Ctd_mon_efy_agb_req
			Ctd_mon_t_agb_req
			Ctd_ms_lft_agb_min
			Cbx_pft_efi_inj_rgn_ena
			Cbx_pft_lim_dir_eng_stop_act
			Cbx_pft_rgn_wio_dp_mod
			Cbx_pft_wait_cdn_min_lvl
			Cbx_pft_wait_cdn_not_pft
			Csx_pft_stt_mask_0
			Csx_pft_stt_mask_16
			Csx_pft_stt_mask_24
			Csx_pft_stt_mask_32
			Csx_pft_stt_mask_8
			Cxx_pft_dfl_vh_dist_min_aut
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_comb_bas_mod
			Vbx_pft_comb_cat_heat_req
			Vbx_pft_comb_rgn_req
			Vbx_pft_comb_wait_cdn_req
			Vxx_pft_ms_cmp_agb_req
			Vxx_pft_rgn_agb_t
			Vbx_pft_eng_sp_nok
			Vbx_pft_lim_dir_pft
			Vbx_pft_rgn_ena_lim_dir
			Vbx_pft_rgn_ena_not_pft
			Vbx_rgn_off_aut
			Vbx_rgn_on_aut
			Vbx_wait_cdn_temp
			Vbx_pft_rgn_ena_min_lvl
			Vbx_pft_rgn_ena_wait_cdn
			Vbx_wait_cdn_on
			Vsx_comb_mod_req_egt
			Vbx_pft_comb_mod_act
			Vsx_pft_low_load_spd_vld
			Vsx_egt_tq_lim_vld
			Vsx_pft_rgn_wio_dp_vld
			Vbx_pft_rgn_ena
			Vbx_pft_agb_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/begin FUNCTION
		AtSpvExc
		""
	/begin OUT_MEASUREMENT
			AtSpvExc_NVM.Vxx_pft_utp_eng_sp_NVM
			AtSpvExc_NVM.Vxx_pft_fim_sp_NVM
			AtSpvExc_NVM.Vxx_pft_spd_vh_sp_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			AtSpvExc_Engpopx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/begin FUNCTION
		AtSpvExc_Engpopx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_tia_cold_cdn
			Ctb_pft_tia_forc_rgn
			Ctb_pft_tia_hot_cdn
			Ctb_pft_tia_med_cdn
			Ctp_pft_tia_cold_cdn
			Ctp_pft_tia_forc_rgn
			Ctp_pft_tia_hot_cdn
			Ctp_pft_tia_med_cdn
			Cbx_pft_swi_sp_fil
			Cxx_pft_fim_thd_cold_0
			Cxx_pft_fim_thd_cold_1
			Cxx_pft_fim_thd_driv_0
			Cxx_pft_fim_thd_driv_1
			Cxx_pft_fim_thd_driv_2
			Cxx_pft_fim_thd_driv_rgn_forc
			Cxx_pft_fim_thd_forc_rgn
			Cxx_pft_fim_thd_hot_0
			Cxx_pft_fim_thd_hot_1
			Cxx_pft_fim_thd_med_0
			Cxx_pft_fim_thd_med_1
			Cxx_pft_load_min_t_rgn_forc
			Cxx_pft_min_spd_thd_cold_cdn
			Cxx_pft_min_spd_thd_hot_cdn
			Cxx_pft_min_spd_thd_med_cdn
			Cxx_pft_spd_thd_driv
			Cxx_pft_spd_thd_driv_rgn_forc
			Cxx_pft_t_fim_driv_fil
			Cxx_pft_t_fim_fil
			Cxx_pft_t_spd_driv_fil
			Cxx_pft_t_spd_veh_fil
			Cxx_pft_t_temp_fil
			Cxx_pft_t_utp_fil
			Cxx_pft_tco_thd_driv_cdn
			Cxx_pft_temp_thd_cold_0
			Cxx_pft_temp_thd_hot_0
			Cxx_pft_temp_thd_med_0
			Cxx_pft_utp_thd_cold_cdn
			Cxx_pft_utp_thd_driv_cdn
			Cxx_pft_utp_thd_hot_cdn
			Cxx_pft_utp_thd_med_cdn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_eng_cold_cdn
			Vbx_pft_eng_hot_cdn
			Vbx_pft_eng_med_cdn
			Vxx_pft_eng_act_t_ctr
			Vxx_pft_fim_driv
			Vxx_pft_spd_drv_fil
			Vxx_pft_utp_driv
			Vbx_pft_driv
			Vbx_pft_eng_sp_forc_rgn
			Vsx_pft_eng_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt
		""
	/begin SUB_FUNCTION
			CbCorTbt_Fposatx
			CbCorTbt_Regfacx
			CbCorTbt_Sch100x
			CbCorTbt_Tbtrprx
			CbCorTbt_Tbtrrij
			CbCorTbt_Tbtrxxx
			CbCorTbt_Advsatx
			CbCorTbt_Fmisatx
			CbCorTbt_Regactx
			CbCorTbt_Sloponx
			CbCorTbt_Spunfil
			CbCorTbt_Tqisatx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Advsatx
		""
	/begin OUT_MEASUREMENT
			Vbx_tbt_adv_min_slop_on
			Vxx_tbt_adv_max_cor
			Vxx_tbt_adv_min_cor
			Vbx_tbt_adv_max_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Fmisatx
		""
	/begin OUT_MEASUREMENT
			Vbx_tbt_fim_main_min_slop_on
			Vbx_tbt_fim_main_max_slop_on
			Vxx_tbt_fim_main_max_cor
			Vxx_tbt_fim_main_min_cor
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Fposatx
		""
	/begin OUT_MEASUREMENT
			Vbx_tbt_fpo_max_slop_on
			Vbx_tbt_fpo_min_slop_on
			Vxx_tbt_fpo_max_cor
			Vxx_tbt_fpo_min_cor
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Regactx
		""
	/begin OUT_MEASUREMENT
			Vbx_tbt_reg_on_aftr_swi
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Regfacx
		""
	/begin OUT_MEASUREMENT
			Vxx_tbt_dg_fac
			Vxx_tbt_ig_fac
			Vxx_tbt_pg_fac
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Sch100x
		""
	/begin DEF_CHARACTERISTIC
			Cbx_tbt_act_off
	/end DEF_CHARACTERISTIC
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Sloponx
		""
	/begin OUT_MEASUREMENT
			Vbx_tbt_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Spunfil
		""
	/begin OUT_MEASUREMENT
			Vbx_tbt_sp_slop_on
			Vxx_tbt_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Tbtrprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tbt_act_n_pr
			Ctb_tbt_act_tqi_pr
			Ctb_tbt_adv_cor_amp_pr
			Ctb_tbt_adv_cor_bas_n_pr
			Ctb_tbt_adv_cor_bas_tqi_pr
			Ctb_tbt_adv_cor_n_pr
			Ctb_tbt_adv_cor_tia_pr
			Ctb_tbt_adv_cor_tqi_pr
			Ctb_tbt_dg_fac_err_pr
			Ctb_tbt_fim_main_cor_n_pr
			Ctb_tbt_fim_main_cor_tqi_pr
			Ctb_tbt_fpo_cor_amp_pr
			Ctb_tbt_fpo_cor_bas_n_pr
			Ctb_tbt_fpo_cor_bas_tqi_pr
			Ctb_tbt_fpo_cor_n_pr
			Ctb_tbt_fpo_cor_tia_pr
			Ctb_tbt_fpo_cor_tqi_pr
			Ctb_tbt_ig_fac_err
			Ctb_tbt_max_tqi_cor_n_pr
			Ctb_tbt_max_tqi_cor_tqi_pr
			Ctb_tbt_pg_fac_err
			Ctb_tbt_pid_fac_n
			Ctb_tbt_pid_fac_tqi
			Ctb_tbt_sp_amp_n_pr
			Ctb_tbt_sp_amp_pr
			Ctb_tbt_sp_amp_tqi_pr
			Ctb_tbt_sp_min_max_n_pr
			Ctb_tbt_sp_ms_n_pr
			Ctb_tbt_sp_ms_pr
			Ctb_tbt_sp_ms_tqi_pr
			Ctb_tbt_sp_n_pr
			Ctb_tbt_sp_tia_n_pr
			Ctb_tbt_sp_tia_pr
			Ctb_tbt_sp_tia_tqi_pr
			Ctb_tbt_sp_tqi_pr
			Cmp_tbt_act_reg_pr
			Cmp_tbt_adv_max_amp_cor_pr
			Cmp_tbt_adv_max_cor_pr
			Cmp_tbt_adv_max_tia_cor_pr
			Cmp_tbt_adv_min_amp_cor_pr
			Cmp_tbt_adv_min_cor_pr
			Cmp_tbt_adv_min_tia_cor_pr
			Cmp_tbt_dg_fac_pr
			Cmp_tbt_fim_main_max_pr
			Cmp_tbt_fim_main_min_pr
			Cmp_tbt_fim_main_ovt_pr
			Cmp_tbt_fpo_max_amp_cor_pr
			Cmp_tbt_fpo_max_cor_pr
			Cmp_tbt_fpo_max_tia_cor_pr
			Cmp_tbt_fpo_min_amp_cor_pr
			Cmp_tbt_fpo_min_cor_pr
			Cmp_tbt_fpo_min_tia_cor_pr
			Cmp_tbt_ig_fac_pr
			Cmp_tbt_max_tqi_min_cor_pr
			Cmp_tbt_pg_fac_pr
			Cmp_tbt_sp_amp_pr
			Cmp_tbt_sp_ms_pr
			Cmp_tbt_sp_pr
			Cmp_tbt_sp_tia_pr
			Ctp_tbt_adv_max_amp_fac_pr
			Ctp_tbt_adv_max_tia_fac_pr
			Ctp_tbt_adv_min_amp_fac_pr
			Ctp_tbt_adv_min_tia_fac_pr
			Ctp_tbt_err_dg_pr
			Ctp_tbt_err_ig_pr
			Ctp_tbt_err_pg_pr
			Ctp_tbt_fpo_max_amp_fac_pr
			Ctp_tbt_fpo_max_tia_fac_pr
			Ctp_tbt_fpo_min_amp_fac_pr
			Ctp_tbt_fpo_min_tia_fac_pr
			Ctp_tbt_sp_fac_amp_pr
			Ctp_tbt_sp_fac_ms_pr
			Ctp_tbt_sp_fac_tia_pr
			Ctp_tbt_sp_max_n_pr
			Ctp_tbt_sp_min_n_pr
			Cxx_tbt_act_thd_pr
			Cxx_tbt_cut_thd_pr
			Cxx_tbt_err_min_pr
			Cxx_tbt_fpo_max_cor_pft_asd_rgn
			Cxx_tbt_fpo_min_cor_pft_asd_rgn
			Cxx_tbt_sp_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tbt_err_ulim_dif_pr
			Vbx_df_tbt_reg_neg_pr
			Vbx_tbt_reg_on_pr
			Vxx_tbt_adv_max_cor_pr
			Vxx_tbt_adv_min_cor_pr
			Vxx_tbt_dg_fac_pr
			Vxx_tbt_fim_main_max_cor_pr
			Vxx_tbt_fim_main_min_cor_pr
			Vxx_tbt_fpo_max_cor_pr
			Vxx_tbt_fpo_min_cor_pr
			Vxx_tbt_ig_fac_pr
			Vxx_tbt_max_tqi_min_cor_pr
			Vxx_tbt_pg_fac_pr
			Vxx_tbt_sp_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Tbtrrij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tbt_act_amp_n_rij
			Ctb_tbt_act_amp_rij
			Ctb_tbt_act_amp_tqi_rij
			Ctb_tbt_act_n_rij
			Ctb_tbt_act_tqi_rij
			Ctb_tbt_dg_fac_err_rij
			Ctb_tbt_dg_fac_n
			Ctb_tbt_fim_main_cor_n_rij
			Ctb_tbt_fim_main_cor_tqi_rij
			Ctb_tbt_max_tqi_cor_n_rij
			Ctb_tbt_max_tqi_cor_tqi_rij
			Ctb_tbt_sp_min_max_n
			Ctb_tbt_sp_ms_amp_n_rij
			Ctb_tbt_sp_ms_amp_tqi_rij
			Ctb_tbt_sp_n_rij
			Ctb_tbt_sp_tia_n_rij
			Ctb_tbt_sp_tia_rij
			Ctb_tbt_sp_tia_tqi_rij
			Ctb_tbt_sp_tqi_rij
			Ctb_tbt_sp_ms
			Ctb_tbt_amp
			Cxx_tbt_act_thd_rij
			Cxx_tbt_cut_thd_rij
			Cxx_tbt_err_min_rij
			Cmp_tbt_act_amp_rij
			Cmp_tbt_act_reg_rij
			Cmp_tbt_fim_main_max_rij
			Cmp_tbt_fim_main_min_rij
			Cmp_tbt_fim_main_ovt_rij
			Cmp_tbt_max_tqi_min_cor_rij
			Cmp_tbt_sp_ms_amp_fac_rij
			Cmp_tbt_sp_ms_amp_rij
			Cmp_tbt_sp_rij
			Cmp_tbt_sp_tia_rij
			Ctp_tbt_act_amp_fac_rij
			Ctp_tbt_dg_fac_rij
			Ctp_tbt_err_dg_rij
			Ctp_tbt_err_ig_rij
			Ctp_tbt_err_pg_rij
			Ctp_tbt_ig_fac_rij
			Ctp_tbt_pg_fac_rij
			Ctp_tbt_sp_fac_tia_rij
			Ctp_tbt_sp_max_n_rij
			Ctp_tbt_sp_min_n_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_tbt_reg_neg_rij
			Vbx_tbt_reg_on_rij
			Vxx_tbt_dg_fac_rij
			Vxx_tbt_err_ulim_dif_rij
			Vxx_tbt_fim_main_max_cor_rij
			Vxx_tbt_fim_main_min_cor_rij
			Vxx_tbt_ig_fac_rij
			Vxx_tbt_max_tqi_min_cor_rij
			Vxx_tbt_pg_fac_rij
			Vxx_tbt_sp_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Tbtrxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_tbt_reg_apl_up
			Cxx_dfdec_tbt_reg_neg_err
			Cxx_dfinc_tbt_reg_apl_up
			Cxx_dfinc_tbt_reg_neg_err
			Cxx_tbt_act_err_thd
			Cxx_tbt_act_reg_dly
			Cxx_tbt_adv_fac
			Cxx_tbt_dg_t_fil
			Cxx_tbt_err_max
			Cxx_tbt_err_min
			Cxx_tbt_fim_main_fac
			Cxx_tbt_fpo_fac
			Cxx_tbt_ig_reg_ini
			Cxx_tbt_pid_reg_max_pr
			Cxx_tbt_pid_reg_max_rij
			Cxx_tbt_pid_reg_min_pr
			Cxx_tbt_pid_reg_min_rij
			Cxx_tbt_pid_slop_neg
			Cxx_tbt_pid_slop_pos
			Cxx_tbt_reg_apl_up
			Cxx_tbt_sp_max
			Cxx_tbt_sp_min
			Cxx_tbt_sp_t_fil_down
			Cxx_tbt_sp_t_fil_up
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_tbt_adv_cor_frz
			Vbx_tbt_ig_reg_frz
			Vbx_tbt_reg_on
			Vxx_tbt_dg_reg_out
			Vxx_tbt_err
			Vxx_tbt_ig_reg
			Vxx_tbt_ig_reg_out
			Vxx_tbt_pg_reg_out
			Vxx_tbt_pid_out
			Vxx_tbt_pid_reg
			Vxx_tbt_sp_fil
			Vxx_ttr_diff_cmd_sat
			Vbx_tbt_pid_slop_on
			Vsx_tbt_reg_vld
			Vxx_tbt_adv_cor
			Vxx_tbt_err_ulim
			Vxx_tbt_fim_main_cor
			Vxx_tbt_fpo_cor
			Vxx_tbt_max_tqi_cor
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin FUNCTION
		CbCorTbt_Tqisatx
		""
	/begin OUT_MEASUREMENT
			Vbx_tbt_max_tqi_min_slop_on
			Vxx_tbt_max_tqi_min_cor
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck
		""
	/begin SUB_FUNCTION
			CbFfwSck_Actinjx
			CbFfwSck_Aftersc
			CbFfwSck_Lpostsc
			CbFfwSck_Mainscx
			CbFfwSck_Pinj1sc
			CbFfwSck_Pinj2sc
			CbFfwSck_Postscx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck_Actinjx
		""
	/begin OUT_MEASUREMENT
			Vsx_fms_shf_inj
			Vsx_fms_act_inj
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck_Aftersc
		""
	/begin DEF_CHARACTERISTIC
			Cxx_fms_faf_min_hys
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_act_aftr
			Vbx_fms_aftr_shf
			Vbx_fms_faf_main_ok
			Vbx_fms_faf_min_ok
			Vbx_fms_faf_ok
			Vbx_fms_faf_shf
			Vbx_fms_faf_shf_main
			Vxx_fms_esti_ti_aftr
			Vxx_fms_esti_ti_wish_main_aftr
			Vxx_fms_esti_wish_main_aftr
			Vxx_fms_faf
			Vxx_fms_wish_faf_lim
			Vxx_fms_wish_min_faf
			Vxx_fms_esti_main_aftr
			Vbx_fms_faf_inj_nr_ok
			Vbx_fms_ti_aftr_min_ok
			Vxx_fms_esti_main_wio_aftr
			Vxx_fms_fim_min_aftr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck_Lpostsc
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_lpos_acum_dsb_pr
			Cbx_fms_lpos_acum_dsb_ocd
			Cxx_fms_flp_min_hys
			Cxx_fms_flp1_min_hys
			Cxx_fms_flp2_min_hys
			Cxx_fms_flp2_wish_l
			Cxx_fms_flp1_rat
			Ctb_n_fms_flp2_wish_h
			Ctb_tqi_fms_flp2_wish_h
			Cmp_fms_flp2_wish_h
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_flp_min_ok
			Vbx_fms_flp_shf
			Vbx_fms_lpos_shf
			Vbx_fms_ti_lpos_min_ok
			Vbx_fms_ti_lpos1_min_ok
			Vbx_fms_ti_lpos2_min_ok
			Vbx_fms_wish_flp2
			Vxx_fms_wish_flp_acum
			Vxx_fms_wish_flp_lim
			Vxx_fms_wish_flp_lim_old
			Vxx_fms_fim_min_lpost
			Vxx_fms_fim_min_lpost1
			Vxx_fms_fim_min_lpost2
			Vxx_fms_wish_flp1
			Vxx_fms_wish_flp2
			Vbx_fms_flp1_min_ok
			Vbx_fms_flp2_min_ok
			Vbx_fms_flp2_ok
			Vbx_fms_flp2_inj_nr_ok
			Vbx_fms_flp_inj_nr_ok
			Vxx_fms_flp_split_rat
			Vbx_fms_act_lpos1
			Vbx_fms_act_lpos2
			Vbx_fms_lpos1_shf
			Vbx_fms_flp_ok
			Vxx_fms_esti_ti_lpos
			Vxx_fms_esti_ti_lpos1
			Vxx_fms_esti_ti_lpos2
			Vxx_fms_flp
			Vxx_fms_flp1
			Vxx_fms_flp2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck_Mainscx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_fms_main_fim_min_hys
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_act_main
			Vbx_fms_fim_main_min_ok
			Vbx_fms_ti_main_min_ok
			Vxx_fms_esti_ti_main
			Vxx_fms_fim_main
			Vbx_nul_efv_inj
			Vxx_fms_fim_min_main
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck_Pinj1sc
		""
	/begin DEF_CHARACTERISTIC
			Cxx_fms_fp1_min_hys
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_act_pinj1
			Vbx_fms_fp1_main_ok
			Vbx_fms_fp1_min_ok
			Vbx_fms_fp1_ok
			Vbx_fms_fp1_shf
			Vbx_fms_pinj1_shf
			Vbx_fms_ti_pinj1_min_ok
			Vxx_fms_esti_ti_pinj1
			Vxx_fms_fim_min_pinj1
			Vxx_fms_wish_min_fp1
			Vxx_fms_fp1
			Vbx_fms_fp1_inj_nr_ok
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck_Pinj2sc
		""
	/begin DEF_CHARACTERISTIC
			Cxx_fms_fp2_min_hys
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_act_pinj2
			Vbx_fms_fp2_inj_nr_ok
			Vbx_fms_fp2_main_ok
			Vbx_fms_fp2_min_ok
			Vbx_fms_fp2_ok
			Vbx_fms_fp2_shf
			Vbx_fms_pinj2_shf
			Vxx_fms_esti_ti_pinj2
			Vxx_fms_fim_min_pinj2
			Vxx_fms_wish_min_fp2
			Vxx_inj_cmd_max_nr
			Vxx_fms_fp2
			Vbx_fms_ti_pinj2_min_ok
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin FUNCTION
		CbFfwSck_Postscx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_fms_fpo_min_hys
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_fpo_main_ok
			Vbx_fms_fpo_min_ok
			Vbx_fms_fpo_shf
			Vbx_fms_fpo_lamb_ok
			Vbx_main_post_inj_sat_min
			Vbx_fms_fpo_shf_main
			Vbx_fms_ti_post_min_ok
			Vbx_fms_wish_max_post_ok
			Vxx_fms_esti_wish_main_post
			Vxx_fms_fim_min_post
			Vxx_fms_wish_fpo_lim
			Vxx_fms_wish_min_fpo
			Vbx_fms_fpo_inj_nr_ok
			Vxx_fms_esti_main_wio_post
			Vbx_fms_act_post
			Vbx_fms_fpo_ok
			Vbx_fms_post_shf
			Vxx_fms_esti_ti_post
			Vxx_fms_esti_ti_wish_main_post
			Vxx_fms_fpo
			Vxx_fms_esti_main_post
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp
		""
	/begin SUB_FUNCTION
			CbFfwTsp_Afterxx
			CbFfwTsp_Aftrrij
			CbFfwTsp_Lpostxx
			CbFfwTsp_Mainxxx
			CbFfwTsp_Pin1rij
			CbFfwTsp_Pin2rij
			CbFfwTsp_Pinj1pr
			CbFfwTsp_Pinj1xx
			CbFfwTsp_Pinj2pr
			CbFfwTsp_Pinj2xx
			CbFfwTsp_Postprx
			CbFfwTsp_Postxxx
			CbFfwTsp_Xxwiont
			CbFfwTsp_Pin1sta
			CbFfwTsp_Injctxx
			CbFfwTsp_Pinjcut
			CbFfwTsp_Pin2sta
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Afterxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_faf_bch_mod
			Cxx_fms_faf_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_faf_slop_on
			Vxx_fms_wish_faf
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Aftrrij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_fms_faf_tco_fac_rij
			Ctb_fms_faf_tia_fac_rij
			Ctb_n_fms_faf_amp_cor_rij
			Ctb_n_fms_faf_max_rij
			Ctb_n_fms_faf_tia_cor_rij
			Ctb_tco_fms_faf_amp_fac_rij
			Ctb_tco_fms_faf_tia_fac_rij
			Ctb_tqi_fms_faf_amp_cor_rij
			Ctb_tqi_fms_faf_max_rij
			Ctb_tqi_fms_faf_tia_cor_rij
			Cmp_fms_bas_faf_rij
			Cmp_fms_faf_amp_cor_rij
			Cmp_fms_faf_amp_fac_rij
			Cmp_fms_faf_cold_tco_rij
			Cmp_fms_faf_max_rij
			Cmp_fms_faf_mv_tco_rij
			Cmp_fms_faf_tia_cor_rij
			Cmp_fms_faf_tia_fac_rij
			Ctp_fms_faf_tco_fac_rij
			Ctb_fms_faf_amp_fac_rij
			Ctb_n_fms_faf_rij
			Ctb_tqi_fms_faf_rij
			Cxx_fms_faf_gear_h_bas_rij
			Cxx_fms_faf_gear_h_cold_rij
			Cxx_fms_faf_gear_h_mv_rij
			Cxx_fms_faf_gear_hys_rij
			Cxx_fms_faf_gear_l_bas_rij
			Cxx_fms_faf_gear_l_cold_rij
			Cxx_fms_faf_gear_l_mv_rij
			Cxx_fms_faf_n_h_bas_rij
			Cxx_fms_faf_n_h_cold_rij
			Cxx_fms_faf_n_h_mv_rij
			Cxx_fms_faf_n_hys_rij
			Cxx_fms_faf_n_l_bas_rij
			Cxx_fms_faf_n_l_cold_rij
			Cxx_fms_faf_n_l_mv_rij
			Cxx_fms_faf_tqi_h_bas_rij
			Cxx_fms_faf_tqi_h_cold_rij
			Cxx_fms_faf_tqi_h_mv_rij
			Cxx_fms_faf_tqi_hys_rij
			Cxx_fms_faf_tqi_l_bas_rij
			Cxx_fms_faf_tqi_l_cold_rij
			Cxx_fms_faf_tqi_l_mv_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_faf_rij
			Vxx_fms_cor_faf_rij
			Vxx_fms_faf_amp_cor_rij
			Vxx_fms_faf_amp_fac_rij
			Vxx_fms_faf_cold_tco_rij
			Vxx_fms_faf_cor_rij
			Vxx_fms_faf_mv_tco_rij
			Vxx_fms_faf_tco_fac_rij
			Vxx_fms_faf_tia_cor_rij
			Vxx_fms_faf_tia_fac_rij
			Vbx_fms_faf_ok_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Injctxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_cyl_nr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_inj_avl_nr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Lpostxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_flp_bch_mod
			Cxx_fms_flp_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_flp_slop_on
			Vxx_fms_wish_flp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Mainxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_fma_bch_mod
			Cxx_fms_fma_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_fim_main_shf
			Vxx_fms_aftr_efy
			Vxx_fms_post_efy
			Vxx_fms_wish_fim_main
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pin1rij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_fms_fp1_amp_fac_rij
			Ctb_fms_fp1_tco_fac_rij
			Ctb_n_fms_fp1_amp_cor_rij
			Ctb_n_fms_fp1_max_rij
			Ctb_n_fms_fp1_tia_cor_rij
			Ctb_tco_fms_fp1_amp_fac_rij
			Ctb_tco_fms_fp1_tia_fac_rij
			Ctb_tia_fms_fp1_tia_fac_rij
			Ctb_tqi_fms_fp1_amp_cor_rij
			Ctb_tqi_fms_fp1_max_rij
			Ctb_tqi_fms_fp1_tia_cor_rij
			Cmp_fms_bas_fp1_2p_rij
			Cmp_fms_bas_fp1_rij
			Cmp_fms_fp1_amp_cor_rij
			Cmp_fms_fp1_amp_fac_rij
			Cmp_fms_fp1_cold_tco_2p_rij
			Cmp_fms_fp1_cold_tco_rij
			Cmp_fms_fp1_max_rij
			Cmp_fms_fp1_mv_tco_2p_rij
			Cmp_fms_fp1_mv_tco_rij
			Cmp_fms_fp1_tia_cor_rij
			Cmp_fms_fp1_tia_fac_rij
			Ctp_fms_fp1_tco_fac_rij
			Ctb_n_fms_fp1_rij
			Ctb_n_fms_fp1_2p_rij
			Ctb_tqi_fms_fp1_2p_rij
			Ctb_tqi_fms_fp1_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_fp1_rij
			Vxx_fms_cor_fp1_rij
			Vxx_fms_fp1_amp_cor_rij
			Vxx_fms_fp1_amp_fac_rij
			Vxx_fms_fp1_cor_rij
			Vxx_fms_fp1_mv_tco_rij
			Vxx_fms_fp1_tco_fac_rij
			Vxx_fms_fp1_tia_cor_rij
			Vxx_fms_fp1_tia_fac_rij
			Vxx_fms_fp1_cold_tco_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pin1sta
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_tco_fms_fp1_sta_n
			Ctb_n_tco_fms_fp1_sta_tco
			Cmp_n_tco_fms_fp1_sta
			Ctb_fms_fp1_amp_fac_sta
			Ctp_fms_fp1_amp_fac_sta
			Ctb_n_fms_fp1_amp_cor_sta
			Ctb_tco_fms_fp1_amp_cor_sta
			Cmp_fms_fp1_amp_cor_sta
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_cor_fp1_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pin2rij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_fms_fp2_amp_fac_rij
			Ctb_fms_fp2_tco_fac_rij
			Ctb_n_fms_fp2_amp_cor_rij
			Ctb_n_fms_fp2_max_rij
			Ctb_n_fms_fp2_tia_cor_rij
			Ctb_tco_fms_fp2_amp_fac_rij
			Ctb_tco_fms_fp2_tia_fac_rij
			Ctb_tia_fms_fp2_tia_fac_rij
			Ctb_tqi_fms_fp2_amp_cor_rij
			Ctb_tqi_fms_fp2_max_rij
			Ctb_tqi_fms_fp2_tia_cor_rij
			Cmp_fms_bas_fp2_rij
			Cmp_fms_fp2_amp_cor_rij
			Cmp_fms_fp2_amp_fac_rij
			Cmp_fms_fp2_cold_tco_rij
			Cmp_fms_fp2_max_rij
			Cmp_fms_fp2_mv_tco_rij
			Cmp_fms_fp2_tia_cor_rij
			Cmp_fms_fp2_tia_fac_rij
			Ctp_fms_fp2_tco_fac_rij
			Ctb_n_fms_fp2_rij
			Ctb_tqi_fms_fp2_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_fp2_rij
			Vxx_fms_cor_fp2_rij
			Vxx_fms_fp2_amp_cor_rij
			Vxx_fms_fp2_amp_fac_rij
			Vxx_fms_fp2_cold_tco_rij
			Vxx_fms_fp2_cor_rij
			Vxx_fms_fp2_mv_tco_rij
			Vxx_fms_fp2_tco_fac_rij
			Vxx_fms_fp2_tia_cor_rij
			Vxx_fms_fp2_tia_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pin2sta
		""
	/begin DEF_CHARACTERISTIC
			Ctb_fms_fp2_amp_fac_sta
			Ctb_n_fms_fp2_amp_cor_sta
			Ctb_n_tco_fms_fp2_sta_n
			Ctb_n_tco_fms_fp2_sta_tco
			Ctb_tco_fms_fp2_amp_cor_sta
			Cmp_fms_fp2_amp_cor_sta
			Cmp_n_tco_fms_fp2_sta
			Ctp_fms_fp2_amp_fac_sta
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_cor_fp2_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pinj1pr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_fms_bas_fp1_2p_pr
			Ctb_n_fms_bas_fp1_pr
			Ctb_n_fms_fp1_amp_cor_pr
			Ctb_n_fms_fp1_max_pr
			Ctb_n_fms_fp1_tco_cor_pr
			Ctb_n_fms_fp1_tia_cor_pr
			Ctb_tqi_fms_bas_fp1_2p_pr
			Ctb_tqi_fms_bas_fp1_pr
			Ctb_tqi_fms_fp1_amp_cor_pr
			Ctb_tqi_fms_fp1_max_pr
			Ctb_tqi_fms_fp1_tco_cor_pr
			Ctb_tqi_fms_fp1_tia_cor_pr
			Cmp_fms_bas_fp1_2p_pr
			Cmp_fms_bas_fp1_pr
			Cmp_fms_fp1_amp_cor_pr
			Cmp_fms_fp1_max_pr
			Cmp_fms_fp1_tco_cor_pr
			Cmp_fms_fp1_tia_cor_pr
			Ctb_fms_fp1_amp_fac_pr
			Ctb_fms_fp1_tco_fac_pr
			Ctb_fms_fp1_tia_fac_pr
			Ctp_fms_fp1_amp_fac_pr
			Ctp_fms_fp1_tco_fac_pr
			Ctp_fms_fp1_tia_fac_pr
			Cxx_fms_cor_fp1_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_fp1_pr
			Vxx_fms_fp1_amp_cor_pr
			Vxx_fms_fp1_amp_fac_pr
			Vxx_fms_fp1_cor_pr
			Vxx_fms_fp1_tco_cor_pr
			Vxx_fms_fp1_tco_fac_pr
			Vxx_fms_fp1_tia_cor_pr
			Vxx_fms_fp1_tia_fac_pr
			Vxx_fms_cor_fp1_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pinj1xx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_fp1_bch_mod
			Cxx_fms_fp1_bch_mod_val
			Cxx_fms_fp1_fim_main_rat
			Cxx_fms_fp1_fim_main_rat_2p
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_fp1_slop_on
			Vxx_fms_wish_fp1
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pinj2pr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_fms_bas_fp2_pr
			Ctb_n_fms_fp2_amp_cor_pr
			Ctb_n_fms_fp2_max_pr
			Ctb_n_fms_fp2_tco_cor_pr
			Ctb_n_fms_fp2_tia_cor_pr
			Ctb_tqi_fms_bas_fp2_pr
			Ctb_tqi_fms_fp2_amp_cor_pr
			Ctb_tqi_fms_fp2_max_pr
			Ctb_tqi_fms_fp2_tco_cor_pr
			Ctb_tqi_fms_fp2_tia_cor_pr
			Cmp_fms_bas_fp2_pr
			Cmp_fms_fp2_amp_cor_pr
			Cmp_fms_fp2_max_pr
			Cmp_fms_fp2_tco_cor_pr
			Cmp_fms_fp2_tia_cor_pr
			Ctb_fms_fp2_amp_fac_pr
			Ctb_fms_fp2_tco_fac_pr
			Ctb_fms_fp2_tia_fac_pr
			Ctp_fms_fp2_amp_fac_pr
			Ctp_fms_fp2_tco_fac_pr
			Ctp_fms_fp2_tia_fac_pr
			Cxx_fms_cor_fp2_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_fp2_pr
			Vxx_fms_fp2_amp_cor_pr
			Vxx_fms_fp2_amp_fac_pr
			Vxx_fms_fp2_cor_pr
			Vxx_fms_fp2_tco_cor_pr
			Vxx_fms_fp2_tco_fac_pr
			Vxx_fms_fp2_tia_cor_pr
			Vxx_fms_fp2_tia_fac_pr
			Vxx_fms_cor_fp2_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pinj2xx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_fp2_bch_mod
			Cxx_fms_fp2_bch_mod_val
			Cxx_fms_fp2_fim_main_rat
			Cbx_fms_bch_mod
			Cbx_fms_cor_off
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_fp2_slop_on
			Vxx_fms_wish_fp2
			Vbx_fms_bch_mod
			Vbx_fms_cor_off
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Pinjcut
		""
	/begin DEF_CHARACTERISTIC
			Ntb_tco_fms_pinj_cut
			Ntb_tia_fms_pinj_cut
			Ctb_n_fms_pinj_cut_1
			Ctb_n_fms_pinj_cut_2
			Ctb_n_fms_pinj_cut_3
			Ctb_n_fms_pinj_cut_4
			Ctb_n_fms_pinj_cut_5
			Ctb_tco_fms_pinj_cut
			Ctb_tia_fms_pinj_cut
			Ctb_tqi_fms_pinj_cut_1
			Ctb_tqi_fms_pinj_cut_2
			Ctb_tqi_fms_pinj_cut_3
			Ctb_tqi_fms_pinj_cut_4
			Ctb_tqi_fms_pinj_cut_5
			Cxx_fms_pinj_cut_amp1
			Cxx_fms_pinj_cut_amp2
			Cxx_fms_pinj_cut_gear1
			Cxx_fms_pinj_cut_gear2
			Cxx_fms_pinj_cut_n_tqi_hys1
			Cxx_fms_pinj_cut_n_tqi_hys2
			Cxx_fms_pinj_cut_tco_hys1
			Cxx_fms_pinj_cut_tco_hys2
			Cxx_fms_pinj_cut_tia_hys1
			Cxx_fms_pinj_cut_tia_hys2
			Ctp_tco_fms_pinj_cut
			Ctp_tia_fms_pinj_cut
			Cmp_fms_pinj_bas_cut
			Cmp_fms_pinj_amp_cut
			Cmp_fms_pinj_gear_cut
			Cmp_fms_pinj_comb_mod_cut
			Cmp_fms_pinj_cut_1
			Cmp_fms_pinj_cut_2
			Cmp_fms_pinj_cut_3
			Cmp_fms_pinj_cut_4
			Cmp_fms_pinj_cut_5
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_pinj1_ok
			Vbx_fms_pinj2_ok
			Vbx_fms_no_pinj
			Vxx_fms_pinj
			Vxx_fms_pinj_nbr
			Vxx_fms_pinj_nbr_old
			Vxx_fms_pinj_new
			Vxx_fms_pinj_old
			Vxx_fms_pinj_amp_cut
			Vxx_fms_pinj_bas_cut
			Vxx_fms_pinj_comb_mod_cut
			Vxx_fms_pinj_cut_5
			Vxx_fms_pinj_gear_cut
			Vbx_fms_fp2_tr_on
			Vbx_fms_fp1_tr_on
			Vxx_fms_pinj_cut_1
			Vxx_fms_pinj_cut_2
			Vxx_fms_pinj_cut_3
			Vxx_fms_pinj_cut_4
			Vxx_fms_pinj_cut_tco
			Vxx_fms_pinj_cut_tia
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Postprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_fms_bas_fpo_pr
			Ctb_n_fms_fpo_amp_cor_pr
			Ctb_n_fms_fpo_max_pr
			Ctb_n_fms_fpo_tco_cor_pr
			Ctb_n_fms_fpo_tia_cor_pr
			Ctb_tqi_fms_bas_fpo_pr
			Ctb_tqi_fms_fpo_amp_cor_pr
			Ctb_tqi_fms_fpo_max_pr
			Ctb_tqi_fms_fpo_tco_cor_pr
			Ctb_tqi_fms_fpo_tia_cor_pr
			Cmp_fms_bas_fpo_pr
			Cmp_fms_fpo_amp_cor_pr
			Cmp_fms_fpo_max_pr
			Cmp_fms_fpo_tco_cor_pr
			Cmp_fms_fpo_tia_cor_pr
			Ctb_fms_fpo_amp_fac_pr
			Ctb_fms_fpo_tco_fac_pr
			Ctb_fms_fpo_tia_fac_pr
			Ctp_fms_fpo_amp_fac_pr
			Ctp_fms_fpo_tco_fac_pr
			Ctp_fms_fpo_tia_fac_pr
			Cxx_fms_cor_fpo_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_fpo_pr
			Vxx_fms_fpo_amp_cor_pr
			Vxx_fms_fpo_amp_fac_pr
			Vxx_fms_fpo_cor_pr
			Vxx_fms_fpo_tco_cor_pr
			Vxx_fms_fpo_tco_fac_pr
			Vxx_fms_fpo_tia_cor_pr
			Vxx_fms_fpo_tia_fac_pr
			Vxx_fms_cor_fpo_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Postxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_fpo_bch_mod
			Cxx_fms_fpo_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_fpo_slop_on
			Vxx_fms_wish_fpo
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin FUNCTION
		CbFfwTsp_Xxwiont
		""
	/begin OUT_MEASUREMENT
			Vxx_fms_cor_faf_npu
			Vxx_fms_cor_faf_spu
			Vxx_fms_cor_fp1_npu
			Vxx_fms_cor_fp1_spu
			Vxx_fms_cor_fp2_npu
			Vxx_fms_cor_fp2_spu
			Vxx_fms_cor_fpo_npu
			Vxx_fms_cor_fpo_spu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin FUNCTION
		CbRapSpt
		""
	/begin SUB_FUNCTION
			CbRapSpt_Rpsprxx
			CbRapSpt_Rpsrijx
			CbRapSpt_Rpsstax
			CbRapSpt_Rpsxxxx
			CbRapSpt_Xxwiont
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin FUNCTION
		CbRapSpt_Rpsprxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_rps_amp_fac_pr
			Ctb_n_rps_0p_pr
			Ctb_n_rps_1p_pr
			Ctb_n_rps_amp_cor_pr
			Ctb_n_rps_max_pr
			Ctb_n_rps_min_pr
			Ctb_n_rps_tco_cor_pr
			Ctb_n_rps_tia_cor_pr
			Ctb_tco_rps_tco_fac_pr
			Ctb_tia_rps_tia_fac_pr
			Ctb_tqi_rps_0p_pr
			Ctb_tqi_rps_1p_pr
			Ctb_tqi_rps_amp_cor_pr
			Ctb_tqi_rps_max_pr
			Ctb_tqi_rps_min_pr
			Ctb_tqi_rps_tco_cor_pr
			Ctb_tqi_rps_tia_cor_pr
			Cmp_rps_amp_cor_pr
			Cmp_rps_bas_0p_pr
			Cmp_rps_bas_1p_pr
			Cmp_rps_max_pr
			Cmp_rps_min_pr
			Cmp_rps_tco_cor_pr
			Cmp_rps_tia_cor_pr
			Ctp_rps_amp_fac_pr
			Ctp_rps_tco_fac_pr
			Ctp_rps_tia_fac_pr
			Cxx_rps_cor_sp_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_rps_amp_cor_pr
			Vxx_rps_amp_fac_pr
			Vxx_rps_bas_pr
			Vxx_rps_cor_pr
			Vxx_rps_tco_cor_pr
			Vxx_rps_tco_fac_pr
			Vxx_rps_tia_cor_pr
			Vxx_rps_tia_fac_pr
			Vxx_rps_cor_sp_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin FUNCTION
		CbRapSpt_Rpsrijx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_rps_amp_tco_fac_rij
			Ctb_n_rps_amp_tco_cor_rij
			Ctb_n_rps_max_rij
			Ctb_n_rps_min_rij
			Ctb_n_rps_tia_tco_cor_rij
			Ctb_tco_rps_amp_tco_fac_rij
			Ctb_tco_rps_tco_fac_rij
			Ctb_tco_rps_tia_tco_fac_rij
			Ctb_tia_rps_tia_tco_fac_rij
			Ctb_tqi_rps_amp_tco_cor_rij
			Ctb_tqi_rps_max_rij
			Ctb_tqi_rps_min_rij
			Ctb_tqi_rps_tia_tco_cor_rij
			Cmp_rps_amp_tco_cor_rij
			Cmp_rps_amp_tco_fac_rij
			Cmp_rps_bas_0p_rij
			Cmp_rps_bas_1p_rij
			Cmp_rps_cold_tco_0p_rij
			Cmp_rps_cold_tco_1p_rij
			Cmp_rps_max_rij
			Cmp_rps_min_rij
			Cmp_rps_mv_tco_0p_rij
			Cmp_rps_mv_tco_1p_rij
			Cmp_rps_tia_tco_cor_rij
			Cmp_rps_tia_tco_fac_rij
			Ctp_rps_tco_fac_rij
			Ctb_n_rps_0p_rij
			Ctb_n_rps_1p_rij
			Ctb_tqi_rps_0p_rij
			Ctb_tqi_rps_1p_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_rps_amp_tco_cor_rij
			Vxx_rps_amp_tco_fac_rij
			Vxx_rps_bas_prs_rij
			Vxx_rps_cold_tco_rij
			Vxx_rps_cor_rij
			Vxx_rps_cor_sp_rij
			Vxx_rps_mv_tco_rij
			Vxx_rps_tco_fac_rij
			Vxx_rps_tia_tco_cor_rij
			Vxx_rps_tia_tco_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin FUNCTION
		CbRapSpt_Rpsstax
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_tco_rps_sp_sta_n
			Ctb_n_tco_rps_sp_sta_tco
			Cmp_n_tco_rps_sp_sta
			Ctb_rps_sp_amp_fac_sta
			Ctb_n_rps_sp_amp_cor_sta
			Ctb_tco_rps_sp_amp_cor_sta
			Cmp_rps_sp_amp_cor_sta
			Ctp_rps_sp_amp_fac_sta
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_rps_cor_sp_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin FUNCTION
		CbRapSpt_Rpsxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_rps_bch_mod
			Cxx_rps_grd_prs_dec_prs
			Cxx_rps_bch_mod_val
			Cxx_rps_lim
			Ctb_n_rps_grd_prs_inc_prs
			Ctb_n_rps_sp_lim_abs
			Ctb_tqi_rps_grd_prs_inc_prs
			Ctb_tqi_rps_sp_dec
			Cmp_rps_grd_prs_inc_prs
			Ctb_n_rps_sp_dec
			Ctb_fuel_rps_sp_fac_lim
			Ctb_fuel_rps_sp_lim_abs
			Cmp_rps_sp_dec
			Cmp_rps_sp_lim_abs
			Ctp_rps_sp_fac_lim
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_rps_dp_rail_prs
			Vxx_rps_rail_prs_sp
			Vxx_rps_rail_prs_raw
			Vbx_rps_sp_slop_on
			Vbx_rps_lim
			Vxx_rps_rail_prs_no_lim
			Vxx_rps_lim_abs
			Vxx_rps_lim_tfu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin FUNCTION
		CbRapSpt_Xxwiont
		""
	/begin OUT_MEASUREMENT
			Vxx_rps_cor_sp_npu
			Vxx_rps_cor_sp_spu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/begin FUNCTION
		CbSpvCmr
		""
	/begin SUB_FUNCTION
			CbSpvCmr_Combreq
			CbSpvCmr_Cmreqas
			CbSpvCmr_Cmreqtq
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/begin FUNCTION
		CbSpvCmr_Cmreqas
		""
	/begin OUT_MEASUREMENT
			Vsx_comb_mod_req_air
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/begin FUNCTION
		CbSpvCmr_Cmreqtq
		""
	/begin OUT_MEASUREMENT
			Vsx_comb_mod_req_tq
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/begin FUNCTION
		CbSpvCmr_Combreq
		""
	/begin DEF_CHARACTERISTIC
			Cbx_comb_mod_bch_mod
			Csx_comb_mod_dft_tr
			Csx_comb_mod_req_bch_val
			Cxx_comb_mod_slop_on_tout
			Cmp_fms_comb_mod_swi_t
			Cxx_fms_ext_tq_max_t
			Cxx_inj_cmd_max_npu
			Cxx_inj_cmd_max_pr
			Cxx_inj_cmd_max_ocd
			Ntb_req_fms_comb_mod_swi_t
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_comb_mod_npu
			Vbx_comb_mod_spr
			Vbx_comb_mod_spu
			Vbx_fms_ext_tq_forb_comb_trs
			Vsx_comb_mod_req_old
			Vsx_comb_mod_req_spv
			Vxx_fms_comb_mod_swi_t
			Vsx_comb_mod_req
			Vbx_comb_mod_req_ena
			Vbx_comb_mod_pr
			Vbx_comb_mod_ocd
			Vbx_comb_mod_pp
			Vbx_comb_mod_rij
			Vbx_comb_mod_sta
			Vbx_df_comb_trs_tout
			Vbx_df_comb_trs_tout_old
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbspvcms.xml' */
/begin FUNCTION
		CbSpvCms
		""
	/begin SUB_FUNCTION
			CbSpvCms_Combsta_xxxxxd
			CbSpvCms_Fmsslpx_xxxxxd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbspvcms.xml' */
/begin FUNCTION
		CbSpvCms_Combsta_xxxxxd
		""
	/begin OUT_MEASUREMENT
			Vsx_comb_mod_act
			Vbx_comb_mod_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbspvcms.xml' */
/begin FUNCTION
		CbSpvCms_Fmsslpx_xxxxxd
		""
	/begin OUT_MEASUREMENT
			Vbx_fms_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/begin FUNCTION
		CbTimSck
		""
	/begin SUB_FUNCTION
			CbTimSck_Aftersc
			CbTimSck_Lpostsc
			CbTimSck_Pinj1sc
			CbTimSck_Pinj2sc
			CbTimSck_Postscx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/begin FUNCTION
		CbTimSck_Aftersc
		""
	/begin OUT_MEASUREMENT
			Vbx_fms_taf_max_nok
			Vbx_fms_taf_min_nok
			Vbx_fms_taf_ok
			Vbx_fms_taf_shf
			Vxx_fms_phi_end_aftr
			Vxx_fms_taf
			Vxx_fms_taf_max
			Vxx_fms_taf_min
			Vxx_fms_wish_taf_angl
			Vxx_fms_wish_taf_max
			Vxx_fms_wish_taf_min_max
			Vxx_fms_sep_min_aftr
			Vxx_fms_phi_min_aftr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/begin FUNCTION
		CbTimSck_Lpostsc
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_fms_dyn_phi_ofs_nxt_cyl
			Ctp_fms_dyn_phi_ofs_nxt_cyl
			Ctb_n_fms_wish_tlp2
			Ctb_tqi_fms_wish_tlp2
			Cmp_fms_wish_tlp2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_tlp_max_nok
			Vbx_fms_tlp_min_nok
			Vxx_fms_esti_ti_lpos_angl
			Vxx_fms_tlp_max
			Vxx_fms_tlp_min_end
			Vxx_fms_tlp_nxt_cyl
			Vxx_fms_wish_tlp_max
			Vxx_fms_wish_tlp_min_max
			Vxx_fms_wish_tlp_t
			Vxx_fms_angl_dif_nxt_cyl_lpos
			Vxx_fms_phi_min_lpos
			Vxx_fms_sep_min_lpos
			Vxx_fms_t_min_nxt_cyl
			Vbx_fms_tlp2_min_nok
			Vbx_fms_tlp2_min_nxt_cyl_nok
			Vxx_fms_angl_dif_nxt_cyl_lpos2
			Vxx_fms_esti_ti_lpos1_angl
			Vxx_fms_esti_ti_lpos2_angl
			Vxx_fms_phi_min_lpos2
			Vxx_fms_sep_min_lpos2
			Vxx_fms_t_min_nxt_cyl_lpos2
			Vxx_fms_tlp1_min_shf
			Vxx_fms_tlp2_max_abs_angl
			Vxx_fms_tlp2_min_abs_angl
			Vxx_fms_tlp2_min_end
			Vxx_fms_tlp2_nxt_cyl
			Vxx_fms_tlp_min
			Vxx_fms_wish_tlp2
			Vxx_fms_wish_tlp2_ang
			Vxx_fms_wish_tlp2_max
			Vbx_fms_tlp_ok
			Vbx_fms_tlp_shf
			Vxx_fms_fim_bfr_lpos
			Vbx_fms_lpos2_shf
			Vbx_fms_tlp2_ok
			Vbx_fms_tlp2_shf_tlp1
			Vxx_fms_tlp1
			Vxx_fms_tlp2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/begin FUNCTION
		CbTimSck_Pinj1sc
		""
	/begin OUT_MEASUREMENT
			Vbx_fms_tp1_max_nok
			Vbx_fms_tp1_min_nok
			Vbx_fms_tp1_ok
			Vbx_fms_tp1_shf
			Vxx_fms_tp1
			Vxx_fms_tp1_max
			Vxx_fms_tp1_min
			Vxx_fms_wish_tp1_angl
			Vxx_fms_wish_tp1_angl_abv
			Vxx_fms_wish_tp1_min
			Vxx_fms_wish_tp1_min_max
			Vxx_fms_phi_max_pinj1
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/begin FUNCTION
		CbTimSck_Pinj2sc
		""
	/begin OUT_MEASUREMENT
			Vbx_fms_tp2_max_nok
			Vbx_fms_tp2_min_nok
			Vbx_fms_tp2_ok
			Vbx_fms_tp2_shf
			Vxx_fms_tp2
			Vxx_fms_tp2_max
			Vxx_fms_tp2_min
			Vxx_fms_wish_tp2_angl
			Vxx_fms_wish_tp2_angl_abv
			Vxx_fms_wish_tp2_min
			Vxx_fms_wish_tp2_min_max
			Vxx_fms_phi_max_pinj2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/begin FUNCTION
		CbTimSck_Postscx
		""
	/begin OUT_MEASUREMENT
			Vbx_fms_tpo_max_nok
			Vbx_fms_tpo_min_nok
			Vxx_fms_tpo_max
			Vxx_fms_tpo_min
			Vxx_fms_wish_tpo_max
			Vxx_fms_wish_tpo_min_max
			Vxx_fms_wish_tpo_t
			Vxx_fms_phi_min_post
			Vxx_fms_sep_min_post
			Vxx_fms_tpo_bfr_angl
			Vbx_fms_tpo_ok
			Vbx_fms_tpo_shf
			Vxx_fms_dif_post
			Vxx_fms_tpo
			Vxx_fms_fim_bfr_post
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp
		""
	/begin SUB_FUNCTION
			CbTimTsp_Afterxx
			CbTimTsp_Aftrrij
			CbTimTsp_Lpostpr
			CbTimTsp_Lpostxx
			CbTimTsp_Mainprx
			CbTimTsp_Mainrij
			CbTimTsp_Mainxxx
			CbTimTsp_Pin1rij
			CbTimTsp_Pin2rij
			CbTimTsp_Pinj1pr
			CbTimTsp_Pinj1xx
			CbTimTsp_Pinj2pr
			CbTimTsp_Pinj2xx
			CbTimTsp_Postprx
			CbTimTsp_Postxxx
			CbTimTsp_Xxwiont
			CbTimTsp_Mainsta
			CbTimTsp_Pin1sta
			CbTimTsp_Pin2sta
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Afterxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_taf_bch_mod
			Cxx_fms_taf_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_taf_slop_on
			Vxx_fms_wish_taf
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Aftrrij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_fms_taf_amp_fac_rij
			Ctb_fms_taf_tco_fac_rij
			Ctb_fms_taf_tia_fac_rij
			Ctb_n_fms_taf_amp_cor_rij
			Ctb_n_fms_taf_max_rij
			Ctb_n_fms_taf_min_rij
			Ctb_n_fms_taf_tia_cor_rij
			Ctb_tco_fms_taf_amp_fac_rij
			Ctb_tco_fms_taf_tia_fac_rij
			Ctb_tqi_fms_taf_amp_cor_rij
			Ctb_tqi_fms_taf_max_rij
			Ctb_tqi_fms_taf_min_rij
			Ctb_tqi_fms_taf_tia_cor_rij
			Cmp_fms_bas_taf_rij
			Cmp_fms_taf_amp_cor_rij
			Cmp_fms_taf_amp_fac_rij
			Cmp_fms_taf_cold_tco_rij
			Cmp_fms_taf_max_rij
			Cmp_fms_taf_min_rij
			Cmp_fms_taf_mv_tco_rij
			Cmp_fms_taf_tia_cor_rij
			Cmp_fms_taf_tia_fac_rij
			Ctp_fms_taf_tco_fac_rij
			Ctb_n_fms_taf_rij
			Ctb_tqi_fms_taf_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_taf_rij
			Vxx_fms_cor_taf_rij
			Vxx_fms_taf_amp_cor_rij
			Vxx_fms_taf_amp_fac_rij
			Vxx_fms_taf_cold_tco_rij
			Vxx_fms_taf_cor_rij
			Vxx_fms_taf_mv_tco_rij
			Vxx_fms_taf_tco_fac_rij
			Vxx_fms_taf_tia_cor_rij
			Vxx_fms_taf_tia_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Lpostpr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_fms_bas_tlp_pr
			Ctb_n_fms_tlp_amp_cor_pr
			Ctb_n_fms_tlp_max_pr
			Ctb_n_fms_tlp_min_pr
			Ctb_n_fms_tlp_tco_cor_pr
			Ctb_n_fms_tlp_tia_cor_pr
			Ctb_tqi_fms_bas_tlp_pr
			Ctb_tqi_fms_tlp_amp_cor_pr
			Ctb_tqi_fms_tlp_max_pr
			Ctb_tqi_fms_tlp_min_pr
			Ctb_tqi_fms_tlp_tco_cor_pr
			Ctb_tqi_fms_tlp_tia_cor_pr
			Cmp_fms_bas_tlp_pr
			Cmp_fms_tlp_amp_cor_pr
			Cmp_fms_tlp_max_pr
			Cmp_fms_tlp_min_pr
			Cmp_fms_tlp_tco_cor_pr
			Cmp_fms_tlp_tia_cor_pr
			Ctb_amp_fms_tlp_fac_pr
			Ctb_tco_fms_tlp_fac_pr
			Ctb_tia_fms_tlp_fac_pr
			Ctp_fms_tlp_amp_fac_pr
			Ctp_fms_tlp_tia_fac_pr
			Ctp_fms_tlp_tco_fac_pr
			Cxx_fms_cor_tlp_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_tlp_pr
			Vxx_fms_tlp_amp_cor_pr
			Vxx_fms_tlp_amp_fac_pr
			Vxx_fms_tlp_cor_pr
			Vxx_fms_tlp_tco_cor_pr
			Vxx_fms_tlp_tco_fac_pr
			Vxx_fms_tlp_tia_cor_pr
			Vxx_fms_tlp_tia_fac_pr
			Vxx_fms_cor_tlp_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Lpostxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_tlp_bch_mod
			Cxx_fms_tlp_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_tlp_slop_on
			Vxx_fms_wish_tlp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Mainprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_fms_adv_amp_fac_pr
			Ctb_dp_fms_adv_dp_rps_fac_pr
			Ctb_ms_fms_adv_ms_dp_fac_pr
			Ctb_n_fms_adv_amp_cor_pr
			Ctb_n_fms_adv_dp_rps_cor_pr
			Ctb_n_fms_adv_max_pr
			Ctb_n_fms_adv_min_pr
			Ctb_n_fms_adv_ms_dp_cor_pr
			Ctb_n_fms_adv_tco_cor_pr
			Ctb_n_fms_adv_tia_cor_pr
			Ctb_n_fms_bas_adv_0p_pr
			Ctb_n_fms_bas_adv_1p_pr
			Ctb_n_fms_bas_adv_2p_pr
			Ctb_tco_fms_adv_tco_fac_pr
			Ctb_tia_fms_adv_tia_fac_pr
			Ctb_tqi_fms_adv_amp_tco_cor_pr
			Ctb_tqi_fms_adv_dp_rps_cor_pr
			Ctb_tqi_fms_adv_max_pr
			Ctb_tqi_fms_adv_min_pr
			Ctb_tqi_fms_adv_ms_dp_cor_pr
			Ctb_tqi_fms_adv_tco_cor_pr
			Ctb_tqi_fms_adv_tia_tco_cor_pr
			Ctb_tqi_fms_bas_adv_0p_pr
			Ctb_tqi_fms_bas_adv_1p_pr
			Ctb_tqi_fms_bas_adv_2p_pr
			Cmp_fms_adv_amp_cor_pr
			Cmp_fms_adv_bas_0p_pr
			Cmp_fms_adv_dp_rps_cor_pr
			Cmp_fms_adv_max_pr
			Cmp_fms_adv_min_pr
			Cmp_fms_adv_ms_dp_cor_pr
			Cmp_fms_adv_tco_cor_pr
			Cmp_fms_bas_adv_1p_pr
			Cmp_fms_bas_adv_2p_pr
			Ctp_fms_adv_dp_rps_fac_pr
			Ctp_fms_adv_ms_dp_fac_pr
			Cmp_fms_adv_tia_cor_pr
			Ctp_fms_adv_tco_fac_pr
			Ctp_fms_adv_tia_fac_pr
			Ctp_fms_adv_amp_fac_pr
			Cmp_fms_bas_adv_0p_pr
			Cxx_fms_cor_adv_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_adv_amp_cor_pr
			Vxx_fms_adv_amp_fac_pr
			Vxx_fms_adv_cor_pr
			Vxx_fms_adv_cor_spc_pr
			Vxx_fms_adv_dp_rps_cor_pr
			Vxx_fms_adv_ms_dp_cor_pr
			Vxx_fms_adv_tco_cor_pr
			Vxx_fms_adv_tco_fac_pr
			Vxx_fms_adv_tia_cor_pr
			Vxx_fms_adv_tia_fac_pr
			Vxx_fms_cor_adv_pr
			Vxx_fms_bas_adv_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Mainrij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_fms_adv_amp_tco_fac_rij
			Ctb_dp_fms_adv_dp_map_fac_rij
			Ctb_dp_fms_adv_dp_rps_fac_rij
			Ctb_n_fms_adv_amp_tco_cor_rij
			Ctb_n_fms_adv_aut_eng_cor_rij
			Ctb_n_fms_adv_dp_map_cor_rij
			Ctb_n_fms_adv_dp_rps_cor_rij
			Ctb_n_fms_adv_max_rij
			Ctb_n_fms_adv_min_rij
			Ctb_n_fms_adv_tia_tco_cor_rij
			Ctb_t_fms_adv_aut_eng_fac_rij
			Ctb_tco_fms_adv_amp_tco_fac_rij
			Ctb_tco_fms_adv_aut_eng_fac_rij
			Ctb_tco_fms_adv_tco_fac_rij
			Ctb_tco_fms_adv_tia_tco_fac_rij
			Ctb_tia_fms_adv_tia_tco_fac_rij
			Ctb_tqi_fms_adv_amp_tco_cor_rij
			Ctb_tqi_fms_adv_aut_eng_cor_rij
			Ctb_tqi_fms_adv_dp_map_cor_rij
			Ctb_tqi_fms_adv_dp_rps_cor_rij
			Ctb_tqi_fms_adv_max_rij
			Ctb_tqi_fms_adv_min_rij
			Ctb_tqi_fms_adv_tia_tco_cor_rij
			Cmp_fms_adv_amp_tco_cor_rij
			Cmp_fms_adv_amp_tco_fac_rij
			Cmp_fms_adv_aut_eng_cor_rij
			Cmp_fms_adv_aut_eng_fac_rij
			Cmp_fms_adv_cold_tco_0p_rij
			Cmp_fms_adv_cold_tco_1p_rij
			Cmp_fms_adv_cold_tco_2p_rij
			Cmp_fms_adv_dp_map_cor_rij
			Cmp_fms_adv_dp_rps_cor_rij
			Cmp_fms_adv_max_rij
			Cmp_fms_adv_min_rij
			Cmp_fms_adv_mv_tco_0p_rij
			Cmp_fms_adv_mv_tco_1p_rij
			Cmp_fms_adv_mv_tco_2p_rij
			Cmp_fms_adv_tia_tco_cor_rij
			Cmp_fms_adv_tia_tco_fac_rij
			Cmp_fms_bas_adv_0p_rij
			Cmp_fms_bas_adv_1p_rij
			Cmp_fms_bas_adv_2p_rij
			Ctp_fms_adv_dp_map_fac_rij
			Ctp_fms_adv_dp_rps_fac_rij
			Ctp_fms_adv_tco_fac_rij
			Ctb_n_fms_adv_0p_rij
			Ctb_tqi_fms_adv_0p_rij
			Ctb_n_fms_adv_1p_rij
			Ctb_n_fms_adv_2p_rij
			Ctb_tqi_fms_adv_1p_rij
			Ctb_tqi_fms_adv_2p_rij
			Ctb_n_fms_adv_gear_rij
			Ctb_tqi_fms_adv_gear_rij
			Cmp_fms_adv_gear_rij
			Cxx_fms_bas_adv_gear
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_adv_amp_tco_cor_rij
			Vxx_fms_adv_amp_tco_fac_rij
			Vxx_fms_adv_aut_eng_cor_rij
			Vxx_fms_adv_aut_eng_t
			Vxx_fms_adv_cold_tco_rij
			Vxx_fms_adv_cor_rij
			Vxx_fms_adv_dp_map_cor_rij
			Vxx_fms_adv_dp_rps_cor_rij
			Vxx_fms_adv_mv_tco_rij
			Vxx_fms_adv_spc_cor_rij
			Vxx_fms_adv_tco_fac_rij
			Vxx_fms_adv_tia_tco_cor_rij
			Vxx_fms_adv_tia_tco_fac_rij
			Vxx_fms_cor_adv_rij
			Vxx_fms_bas_adv_rij
			Vxx_fms_adv_gear_rij
			Vxx_fms_adv_aut_eng_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Mainsta
		""
	/begin DEF_CHARACTERISTIC
			Ctb_adv_amp_cor_sta_tco
			Ctb_fms_adv_amp_fac_sta
			Ctb_n_tco_fms_adv_sta_n
			Ctb_n_tco_fms_adv_sta_tco
			Cmp_adv_amp_cor_sta
			Cmp_n_tco_fms_adv_sta
			Ctp_fms_adv_amp_fac_sta
			Ctb_adv_amp_cor_sta_n
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_cor_adv_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Mainxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_fms_adv_bch_mod_val
			Cbx_fms_adv_bch_mod
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_adv_slop_on
			Vxx_fms_adv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pin1rij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_fms_tp1_amp_fac_rij
			Ctb_fms_tp1_tco_fac_rij
			Ctb_n_fms_tp1_amp_cor_rij
			Ctb_n_fms_tp1_max_rij
			Ctb_n_fms_tp1_min_rij
			Ctb_n_fms_tp1_tia_cor_rij
			Ctb_tco_fms_tp1_amp_fac_rij
			Ctb_tco_fms_tp1_tia_fac_rij
			Ctb_tia_fms_tp1_tia_fac_rij
			Ctb_tqi_fms_tp1_amp_cor_rij
			Ctb_tqi_fms_tp1_cold_tco_2p_rij
			Ctb_tqi_fms_tp1_cold_tco_rij
			Ctb_tqi_fms_tp1_max_cor_rij
			Ctb_tqi_fms_tp1_max_rij
			Ctb_tqi_fms_tp1_min_cor_rij
			Ctb_tqi_fms_tp1_min_rij
			Ctb_tqi_fms_tp1_mv_tco_2p_rij
			Ctb_tqi_fms_tp1_mv_tco_rij
			Ctb_tqi_fms_tp1_tia_cor_rij
			Cmp_fms_bas_tp1_2p_rij
			Cmp_fms_bas_tp1_rij
			Cmp_fms_tp1_amp_cor_rij
			Cmp_fms_tp1_amp_fac_rij
			Cmp_fms_tp1_cold_tco_2p_rij
			Cmp_fms_tp1_cold_tco_rij
			Cmp_fms_tp1_max_rij
			Cmp_fms_tp1_min_rij
			Cmp_fms_tp1_mv_tco_2p_rij
			Cmp_fms_tp1_mv_tco_rij
			Cmp_fms_tp1_tia_cor_rij
			Cmp_fms_tp1_tia_fac_rij
			Ctp_fms_tp1_tco_fac_rij
			Ctb_n_fms_tp1_2p_rij
			Ctb_n_fms_tp1_rij
			Ctb_tqi_fms_tp1_2p_rij
			Ctb_tqi_fms_tp1_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_tp1_rij
			Vxx_fms_cor_tp1_rij
			Vxx_fms_tp1_amp_cor_rij
			Vxx_fms_tp1_amp_fac_rij
			Vxx_fms_tp1_cold_tco_rij
			Vxx_fms_tp1_cor_rij
			Vxx_fms_tp1_mv_tco_rij
			Vxx_fms_tp1_tco_fac_rij
			Vxx_fms_tp1_tia_cor_rij
			Vxx_fms_tp1_tia_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pin1sta
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_tco_tsp_tp1_sta_n
			Ctb_n_tco_tsp_tp1_sta_tco
			Ctb_n_tsp_tp1_amp_cor_sta
			Ctb_tco_tsp_tp1_amp_cor_sta
			Cmp_n_tco_tsp_tp1_sta
			Cmp_tsp_tp1_amp_cor_sta
			Ctb_tsp_tp1_amp_fac_sta
			Ctp_tsp_tp1_amp_fac_sta
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_cor_tp1_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pin2rij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_fms_tp2_amp_fac_rij
			Ctb_n_fms_tp2_amp_cor_rij
			Ctb_n_fms_tp2_max_rij
			Ctb_n_fms_tp2_min_rij
			Ctb_n_fms_tp2_tia_cor_rij
			Ctb_tco_fms_tp2_amp_fac_rij
			Ctb_tco_fms_tp2_tco_fac_rij
			Ctb_tco_fms_tp2_tia_fac_rij
			Ctb_tia_fms_tp2_tia_fac_rij
			Ctb_tqi_fms_tp2_amp_cor_rij
			Ctb_tqi_fms_tp2_max_rij
			Ctb_tqi_fms_tp2_min_rij
			Ctb_tqi_fms_tp2_tia_cor_rij
			Cmp_fms_bas_tp2_2p_rij
			Cmp_fms_bas_tp2_rij
			Cmp_fms_tp2_amp_cor_rij
			Cmp_fms_tp2_amp_fac_rij
			Cmp_fms_tp2_cold_tco_2p_rij
			Cmp_fms_tp2_cold_tco_rij
			Cmp_fms_tp2_max_rij
			Cmp_fms_tp2_min_rij
			Cmp_fms_tp2_mv_tco_2p_rij
			Cmp_fms_tp2_mv_tco_rij
			Cmp_fms_tp2_tia_cor_rij
			Cmp_fms_tp2_tia_fac_rij
			Ctp_fms_tp2_tco_fac_rij
			Ctb_n_fms_tp2_2p_rij
			Ctb_n_fms_tp2_rij
			Ctb_tqi_fms_tp2_2p_rij
			Ctb_tqi_fms_tp2_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_tp2_rij
			Vxx_fms_cor_tp2_rij
			Vxx_fms_tp2_amp_cor_rij
			Vxx_fms_tp2_amp_fac_rij
			Vxx_fms_tp2_cold_tco_rij
			Vxx_fms_tp2_cor_rij
			Vxx_fms_tp2_mv_tco_rij
			Vxx_fms_tp2_tco_fac_rij
			Vxx_fms_tp2_tia_cor_rij
			Vxx_fms_tp2_tia_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pin2sta
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_tco_tsp_tp2_sta_n
			Ctb_n_tco_tsp_tp2_sta_tco
			Ctb_n_tsp_tp2_amp_cor_sta
			Ctb_tco_tsp_tp2_amp_cor_sta
			Cmp_n_tco_tsp_tp2_sta
			Cmp_tsp_tp2_amp_cor_sta
			Ctb_tsp_tp2_amp_fac_sta
			Ctp_tsp_tp2_amp_fac_sta
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_cor_tp2_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pinj1pr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_fms_tp1_amp_fac_pr
			Ctb_fms_tp1_tco_fac_pr
			Ctb_fms_tp1_tia_fac_pr
			Ctb_n_fms_bas_tp1_2p_pr
			Ctb_n_fms_bas_tp1_pr
			Ctb_n_fms_tp1_amp_cor_pr
			Ctb_n_fms_tp1_max_pr
			Ctb_n_fms_tp1_min_pr
			Ctb_n_fms_tp1_tco_cor_pr
			Ctb_n_fms_tp1_tia_cor_pr
			Ctb_tqi_fms_bas_tp1_2p_pr
			Ctb_tqi_fms_bas_tp1_pr
			Ctb_tqi_fms_tp1_amp_cor_pr
			Ctb_tqi_fms_tp1_max_pr
			Ctb_tqi_fms_tp1_min_pr
			Ctb_tqi_fms_tp1_tco_cor_pr
			Ctb_tqi_fms_tp1_tia_cor_pr
			Cmp_fms_bas_tp1_2p_pr
			Cmp_fms_bas_tp1_pr
			Cmp_fms_tp1_amp_cor_pr
			Cmp_fms_tp1_max_pr
			Cmp_fms_tp1_min_pr
			Cmp_fms_tp1_tco_cor_pr
			Cmp_fms_tp1_tia_cor_pr
			Ctp_fms_tp1_tco_fac_pr
			Ctp_fms_tp1_tia_fac_pr
			Ctp_fms_tp1_amp_fac_pr
			Cxx_fms_cor_tp1_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_tp1_pr
			Vxx_fms_tp1_amp_cor_pr
			Vxx_fms_tp1_amp_fac_pr
			Vxx_fms_tp1_cor_pr
			Vxx_fms_tp1_tco_cor_pr
			Vxx_fms_tp1_tco_fac_pr
			Vxx_fms_tp1_tia_cor_pr
			Vxx_fms_tp1_tia_fac_pr
			Vxx_fms_cor_tp1_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pinj1xx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_tp1_bch_mod
			Cxx_fms_tp1_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_tp1_slop_on
			Vxx_fms_wish_tp1
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pinj2pr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_fms_bas_tp2_2p_pr
			Ctb_n_fms_bas_tp2_pr
			Ctb_n_fms_tp2_amp_cor_pr
			Ctb_n_fms_tp2_max_pr
			Ctb_n_fms_tp2_min_pr
			Ctb_n_fms_tp2_tco_cor_pr
			Ctb_n_fms_tp2_tia_cor_pr
			Ctb_tqi_fms_bas_tp2_2p_pr
			Ctb_tqi_fms_bas_tp2_pr
			Ctb_tqi_fms_tp2_amp_cor_pr
			Ctb_tqi_fms_tp2_max_pr
			Ctb_tqi_fms_tp2_min_pr
			Ctb_tqi_fms_tp2_tco_cor_pr
			Ctb_tqi_fms_tp2_tia_cor_pr
			Cmp_fms_bas_tp2_2p_pr
			Cmp_fms_bas_tp2_pr
			Cmp_fms_tp2_amp_cor_pr
			Cmp_fms_tp2_max_pr
			Cmp_fms_tp2_min_pr
			Cmp_fms_tp2_tco_cor_pr
			Cmp_fms_tp2_tia_cor_pr
			Ctb_fms_tp2_amp_fac_pr
			Ctp_fms_tp2_amp_fac_pr
			Ctb_fms_tp2_tco_fac_pr
			Ctb_fms_tp2_tia_fac_pr
			Ctp_fms_tp2_tco_fac_pr
			Ctp_fms_tp2_tia_fac_pr
			Cxx_fms_cor_tp2_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_bas_tp2_pr
			Vxx_fms_tp2_amp_cor_pr
			Vxx_fms_tp2_amp_fac_pr
			Vxx_fms_tp2_cor_pr
			Vxx_fms_tp2_tco_cor_pr
			Vxx_fms_tp2_tco_fac_pr
			Vxx_fms_tp2_tia_cor_pr
			Vxx_fms_tp2_tia_fac_pr
			Vxx_fms_cor_tp2_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Pinj2xx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_tp2_bch_mod
			Cxx_fms_tp2_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_tp2_slop_on
			Vxx_fms_wish_tp2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Postprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_fms_bas_tpo_pr
			Ctb_n_fms_tpo_amp_cor_pr
			Ctb_n_fms_tpo_max_pr
			Ctb_n_fms_tpo_min_pr
			Ctb_n_fms_tpo_tco_cor_pr
			Ctb_n_fms_tpo_tia_cor_pr
			Ctb_tqi_fms_bas_tpo_pr
			Ctb_tqi_fms_tpo_amp_cor_pr
			Ctb_tqi_fms_tpo_max_pr
			Ctb_tqi_fms_tpo_min_pr
			Ctb_tqi_fms_tpo_tco_cor_pr
			Ctb_tqi_fms_tpo_tia_cor_pr
			Cmp_fms_bas_tpo_pr
			Cmp_fms_tpo_amp_cor_pr
			Cmp_fms_tpo_max_pr
			Cmp_fms_tpo_min_pr
			Cmp_fms_tpo_tco_cor_pr
			Cmp_fms_tpo_tia_cor_pr
			Ctb_fms_tpo_amp_fac_pr
			Ctb_fms_tpo_tco_fac_pr
			Ctb_fms_tpo_tia_fac_pr
			Ctp_fms_tpo_amp_fac_pr
			Ctp_fms_tpo_tia_fac_pr
			Ctp_fms_tpo_tco_fac_pr
			Cxx_fms_cor_tpo_pft_asd_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_tpo_amp_cor_pr
			Vxx_fms_tpo_amp_fac_pr
			Vxx_fms_tpo_cor_pr
			Vxx_fms_tpo_tco_cor_pr
			Vxx_fms_tpo_tco_fac_pr
			Vxx_fms_tpo_tia_cor_pr
			Vxx_fms_tpo_tia_fac_pr
			Vxx_fms_bas_tpo_pr
			Vxx_fms_cor_tpo_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Postxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_fms_tpo_bch_mod
			Cxx_fms_tpo_bch_mod_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_tpo_slop_on
			Vxx_fms_wish_tpo
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/begin FUNCTION
		CbTimTsp_Xxwiont
		""
	/begin OUT_MEASUREMENT
			Vxx_fms_cor_adv_npu
			Vxx_fms_cor_adv_spu
			Vxx_fms_cor_taf_npu
			Vxx_fms_cor_taf_spu
			Vxx_fms_cor_tp1_npu
			Vxx_fms_cor_tp1_spu
			Vxx_fms_cor_tp2_npu
			Vxx_fms_cor_tp2_spu
			Vxx_fms_cor_tpo_npu
			Vxx_fms_cor_tpo_spu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/begin FUNCTION
		ClCooCtl
		""
	/begin OUT_MEASUREMENT
			ClCooCtl_NVM.Sbx_eng_off_mdf1_on_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'ClCooCtl_Fanmexx' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			ClCooCtl_Chctlxx
			ClCooCtl_Fanrqxx
			ClCooCtl_Fanxxxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/begin FUNCTION
		ClCooCtl_Chctlxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_alt_pwm_nok_cut_ena
			Cbx_glow_thpl_cut_ena
			Cxx_thpl_heat_tco_h
			Cxx_thpl_heat_tco_l
			Cxx_thpl_heat_tco_ofs_h
			Cxx_thpl_heat_tco_ofs_l
			Cxx_thpl_heat_tia_h
			Cxx_thpl_heat_tia_l
			Cxx_thpl_heat_tia_ofs_h
			Cxx_thpl_heat_tia_ofs_l
			Cxx_thpl_nr
			Cxx_vb_fil_fac
			Cxx_vb_thd_h
			Cxx_vb_thd_l
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_thpl_frz
			Vxx_thpl_nr
			Vbx_thpl_cut
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/begin FUNCTION
		ClCooCtl_Fanrqxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_mdf1_asd_comb_mod_req_ena
			Cbx_mdf1_comb_mod_req_2_ena
			Cbx_mdf1_comb_mod_req_3_ena
			Cbx_mdf2_asd_comb_mod_req_ena
			Cbx_mdf2_comb_mod_req_2_ena
			Cbx_mdf2_comb_mod_req_3_ena
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_asd_mdf_comb_mod_req
			Vbx_mdf1_comb_mod_req
			Vbx_mdf2_comb_mod_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/begin FUNCTION
		ClCooCtl_Fanxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_ac_dsb_tco_thd
			Cxx_ac_dsb_tco_thd_h
			Cxx_ac_ena_tco_thd
			Cxx_ac_ena_tco_thd_h
			Cxx_cmd_mdf_dly
			Cxx_mdf1_cmd_ena_thd_tco_h
			Cxx_mdf1_off_tco_thd
			Cxx_mdf1_off_tco_thd_h
			Cxx_mdf1_on_tco_thd
			Cxx_mdf1_on_tco_thd_h
			Cxx_mdf1_on_tco_thd_hys
			Cxx_mdf1_on_tco_thd_hys_h
			Cxx_mdf2_off_tco_thd
			Cxx_mdf2_off_tco_thd_h
			Cxx_mdf2_on_tco_thd
			Cxx_mdf2_on_tco_thd_h
			Cxx_mon_stop_tco_thd
			Cxx_mon_stop_tco_thd_h
			Cxx_run_mdf1_off_tco_thd
			Cxx_run_mdf1_off_tco_thd_h
			Cxx_tco_fail_cmd_mdf_dly
			Cxx_tco_mdf_dly
			Cxx_mdf_1_cmd_ena_thd_tco
			Cbx_eng_stop_mdf_cho
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_eng_mdf1
			Vbx_eng_mdf1_req
			Vbx_eng_mdf2
			Vbx_eng_mdf2_req
			Vbx_mdf1
			Vbx_mdf_pws
			Vbx_tco_ac_dsb
			Vbx_mdf2
			Vbx_eng_off_mdf1
			Vbx_eng_mdf1_dly
			Vbx_eng_aut_fan
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/begin FUNCTION
		ClCooSpt
		""
	/begin SUB_FUNCTION
			ClCooSpt_Cteaubc
			ClCooSpt_Tstaxbc
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/begin FUNCTION
		ClCooSpt_Cteaubc
		""
	/begin OUT_MEASUREMENT
			Vbx_mdf2_reg
			Vbx_tco_sp_l_mod
			Vbx_tsta_ip_dft_lght_tco_h_sp
			Vxx_mdf2_reg_dly
			Vxx_tco_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/begin FUNCTION
		ClCooSpt_Tstaxbc
		""
	/begin OUT_MEASUREMENT
			Vsx_tsta_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer
		""
	/begin OUT_MEASUREMENT
			CmMuxSer_NVM.Vxx_bus_off_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_mute_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_abs_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_agb_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_ccu_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_ddcm_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_ip_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_usm_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_ac_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_acc_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vxx_swa_ecu_stt_ctr_mem_NVM
			CmMuxSer_NVM.Vbx_abs_lk_stt_NVM
			CmMuxSer_NVM.Vbx_agb_lk_stt_NVM
			CmMuxSer_NVM.Vbx_ccu_lk_stt_NVM
			CmMuxSer_NVM.Vbx_ip_lk_stt_NVM
			CmMuxSer_NVM.Vbx_usm_lk_stt_NVM
			CmMuxSer_NVM.Vbx_acc_lk_stt_NVM
			CmMuxSer_NVM.Vbx_ac_lk_stt_NVM
			CmMuxSer_NVM.Vbx_sdl_lk_stt_NVM
			CmMuxSer_NVM.Vbx_swa_lk_stt_NVM
			CmMuxSer_NVM.Vbx_ddcm_lk_stt_NVM
	/end OUT_MEASUREMENT
	/* ASAP2::Database : delete 'CmMuxSer_Smlimin' */
	/* ASAP2::Database : 1 referenced entries deleted */
	/begin SUB_FUNCTION
			CmMuxSer_Atpftou
			CmMuxSer_Cbfulin
			CmMuxSer_Cbstain
			CmMuxSer_Cbxxxou
			CmMuxSer_Clatoou
			CmMuxSer_Clbduin
			CmMuxSer_Clkmxou
			CmMuxSer_Clrstin
			CmMuxSer_Clspoou
			CmMuxSer_Cltoxou
			CmMuxSer_Dgdtvin
			CmMuxSer_Dglpgin
			CmMuxSer_Dgmilou
			CmMuxSer_Dgmltin
			CmMuxSer_Dgwl1ou
			CmMuxSer_Dgwl2ou
			CmMuxSer_Mngtxxx
			CmMuxSer_Pcabsin
			CmMuxSer_Pcaplou
			CmMuxSer_Pcatqin
			CmMuxSer_Pcbpkin
			CmMuxSer_Pcbrkin
			CmMuxSer_Pcbrkou
			CmMuxSer_Pcclbin
			CmMuxSer_Pcclein
			CmMuxSer_Pcespin
			CmMuxSer_Pcfshou
			CmMuxSer_Pcrvnin
			CmMuxSer_Pcspcin
			CmMuxSer_Pctcsin
			CmMuxSer_Pctqeou
			CmMuxSer_Pctrein
			CmMuxSer_Rxfrmxx
			CmMuxSer_Rxp50in
			CmMuxSer_Smacsin
			CmMuxSer_Smat1in
			CmMuxSer_Smat2in
			CmMuxSer_Smengou
			CmMuxSer_Smovnou
			CmMuxSer_Smptcin
			CmMuxSer_Smspdou
			CmMuxSer_Smsptou
			CmMuxSer_Tenvxin
			CmMuxSer_Tqampou
			CmMuxSer_Tqapgou
			CmMuxSer_Tqecfou
			CmMuxSer_Tqestou
			CmMuxSer_Tqlosou
			CmMuxSer_Tqmaxou
			CmMuxSer_Tqminou
			CmMuxSer_Tqmpaou
			CmMuxSer_Tqpalin
			CmMuxSer_Tqreqou
			CmMuxSer_Tqprgin
			CmMuxSer_Txfrmxx
			CmMuxSer_Txp50ou
			CmMuxSer_Smwixin
			CmMuxSer_Tqacxin
			CmMuxSer_Tqacxou
			CmMuxSer_Vfacxin
			CmMuxSer_Vfacxou
			CmMuxSer_Vfadfin
			CmMuxSer_Vffltou
			CmMuxSer_Vfpdain
			CmMuxSer_Vfptcin
			CmMuxSer_Vfrwsin
			CmMuxSer_Vftacin
			CmMuxSer_Pctbnin
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Atpftou
		""
	/begin DEF_CHARACTERISTIC
			Cbx_swi_pft_stat_stt
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			ECM_MechanicalLoadRequest
			ParticulateFilterFailureDisplay
			ParticulateFilterState
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Cbfulin
		""
	/begin DEF_CHARACTERISTIC
			Cbx_diag_fuel_pres_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_mux_min_fuel_raw
			Vsx_mux_min_fuel_raw_vld
			Vbx_min_fuel_navl
			Vbx_frm_min_fuel
			Vsx_mux_fuel_lvl_vld
			Vxx_mux_fuel_lvl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Cbstain
		""
	/begin DEF_CHARACTERISTIC
			Cxx_star_mod_nok
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_star_mod
			Vsx_star_mod_vld
			Vbx_star_mod_no
			Vbx_star_mod_nok
			Vbx_star_mod_ign
			Vbx_star_mod_sta
			Vbx_star_mod_stop
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Cbxxxou
		""
	/begin OUT_MEASUREMENT
			FuelConsumption
			NominalFuelConsumption
			DieselFilterWaterDetection
			DieselPreHeating
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Clatoou
		""
	/begin OUT_MEASUREMENT
			WarningWaterTemp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Clbduin
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_bdu_ope_vld
			Vbx_mux_bdu_ope
			Vbx_mux_bdu_ope_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Clkmxou
		""
	/begin OUT_MEASUREMENT
			ComputedOilDrainingRange
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Clrstin
		""
	/begin OUT_MEASUREMENT
			Vbx_owe_mnl_ini_req_mux
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Clspoou
		""
	/begin OUT_MEASUREMENT
			DownTransitionOfEngCoolantTemp
			EngineCoolantRegulationTemp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Cltoxou
		""
	/begin OUT_MEASUREMENT
			EngineCoolantTemp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Dgdtvin
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_vh_dist_vld
			Vxx_mux_vh_dist
			Vbx_mux_vh_dist_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Dglpgin
		""
	/begin OUT_MEASUREMENT
			Vbx_mil_gcu_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Dgmilou
		""
	/begin OUT_MEASUREMENT
			MILLamp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Dgmltin
		""
	/begin OUT_MEASUREMENT
			Vbx_mil_tcu_req
			Vbx_mux_mil_tcu_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Dgwl1ou
		""
	/begin OUT_MEASUREMENT
			EngineControlFailureLevel1
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Dgwl2ou
		""
	/begin OUT_MEASUREMENT
			EngineControlFailureLevel2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Mngtxxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_AIRBAGCrash_id
			Cxx_ACC_CANHS_R_01_id
			Cxx_BCM_CANHS_RNr_01_id
			Cxx_BCM_VERLOG_id
			Cxx_BCM_CANHS_RNr_02_id
			Cxx_BRAKE_CANHS_RNr_01_id
			Cxx_BRAKE_CANHS_RNr_02_id
			Cxx_BRAKE_CANHS_RNr_03_id
			Cxx_BRAKE_CANHS_R_01_id
			Cxx_BRAKE_CANHS_RNr_04_id
			Cxx_CLIM_CANHS_R_01_id
			Cxx_DDCM_CANLSFT_R_01_id
			Cxx_ECM_CANHS_RNr_01_id
			Cxx_ECM_CANHS_RNr_02_id
			Cxx_ECM_VERLOG_id
			Cxx_FORCE_ECM_CANHS_R_01_id
			Cxx_MMI_ECM_CANHS_RNr_01_id
			Cxx_SWA_CANHS_RNr_01_id
			Cxx_TORQUE_AT_CANHS_RNr_01_id
			Cxx_TORQUE_AT_CANHS_RNr_02_id
			Cxx_TORQUE_ECM_CANHS_RNr_01_id
			Cxx_TORQUE_ECM_CANHS_RNr_02_id
			Cxx_TORQUE_ECM_CANHS_R_01_id
			Cxx_USM_CANHS_RNr_01_id
			Cxx_abs_vld_abst_frm_inc
			Cxx_abs_abst_frm_dly
			Cxx_ac_ecu_conf
			Cxx_abs_vld_abst_frm_dec
			Cxx_ac_vld_abst_frm_inc
			Cxx_ac_abst_frm_dly
			Cxx_abs_ecu_conf
			Cxx_acc_ecu_conf
			Cxx_ac_vld_abst_frm_dec
			Cxx_acc_vld_abst_frm_dec
			Cxx_acc_vld_abst_frm_inc
			Cxx_acc_abst_frm_dly
			Cxx_agb_abst_frm_dly
			Cxx_agb_ecu_conf
			Cxx_agb_vld_abst_frm_dec
			Cxx_agb_vld_abst_frm_inc
			Cxx_ccu_vld_abst_frm_dec
			Cxx_ccu_vld_abst_frm_inc
			Cxx_ddcm_abst_frm_dly
			Cxx_ccu_ecu_conf
			Cxx_ddcm_ecu_conf
			Cxx_ddcm_vld_abst_frm_dec
			Cxx_ddcm_vld_abst_frm_inc
			Cxx_ecu_stt_ctr_dec
			Cxx_ecu_stt_ctr_max
			Cxx_ecu_stt_ctr_thd
			Cxx_ccu_abst_frm_dly
			Cxx_ip_vld_abst_frm_inc
			Cxx_ip_abst_frm_dly
			Cxx_mute_ecu_conf
			Cxx_mute_vld_abst_frm_dec
			Cxx_mute_vld_abst_frm_inc
			Cxx_mux_diag_ena_dly
			Cxx_mux_frm_set_ref
			Cxx_mute_abst_frm_dly
			Cxx_ip_ecu_conf
			Cxx_swa_ecu_conf
			Cxx_ip_vld_abst_frm_dec
			Cxx_swa_vld_abst_frm_dec
			Cxx_swa_vld_abst_frm_inc
			Cxx_swa_abst_frm_dly
			Cxx_usm_abst_frm_dly
			Cxx_usm_ecu_conf
			Cxx_usm_vld_abst_frm_dec
			Cxx_usm_vld_abst_frm_inc
			Cxx_CLUSTER_CANHS_RNr_01_id
			Cxx_CLUSTER_CANHS_R_01_id
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			AIRBAGCrash[0]
			AIRBAGCrash[1]
			BCM_CANHS_RNr_01[0]
			BCM_CANHS_RNr_01[1]
			BCM_CANHS_RNr_01[2]
			BCM_CANHS_RNr_01[3]
			BCM_CANHS_RNr_01[4]
			BCM_CANHS_RNr_01[5]
			BCM_CANHS_RNr_01[6]
			BCM_CANHS_RNr_01[7]
			BCM_CANHS_RNr_02[0]
			BCM_CANHS_RNr_02[1]
			BCM_CANHS_RNr_02[2]
			BCM_CANHS_RNr_02[3]
			BCM_CANHS_RNr_02[4]
			BCM_CANHS_RNr_02[5]
			BCM_CANHS_RNr_02[6]
			BCM_CANHS_RNr_02[7]
			BCM_VERLOG[0]
			BCM_VERLOG[1]
			BCM_VERLOG[2]
			BCM_VERLOG[3]
			BCM_VERLOG[4]
			BRAKE_CANHS_RNr_02[0]
			BRAKE_CANHS_RNr_02[1]
			BRAKE_CANHS_RNr_02[2]
			BRAKE_CANHS_RNr_02[3]
			BRAKE_CANHS_RNr_02[4]
			BRAKE_CANHS_RNr_02[5]
			BRAKE_CANHS_RNr_03[0]
			BRAKE_CANHS_RNr_03[1]
			BRAKE_CANHS_RNr_03[2]
			BRAKE_CANHS_RNr_03[3]
			BRAKE_CANHS_RNr_03[4]
			BRAKE_CANHS_RNr_03[5]
			BRAKE_CANHS_RNr_04[0]
			BRAKE_CANHS_RNr_04[1]
			BRAKE_CANHS_RNr_04[2]
			BRAKE_CANHS_RNr_04[3]
			BRAKE_CANHS_RNr_04[4]
			BRAKE_CANHS_RNr_04[5]
			BRAKE_CANHS_RNr_04[6]
			BRAKE_CANHS_RNr_04[7]
			BRAKE_CANHS_R_01[0]
			BRAKE_CANHS_R_01[1]
			BRAKE_CANHS_R_01[2]
			BRAKE_CANHS_R_01[3]
			BRAKE_CANHS_R_01[4]
			BRAKE_CANHS_R_01[5]
			BRAKE_CANHS_R_01[6]
			CLIM_CANHS_R_01[0]
			CLIM_CANHS_R_01[1]
			CLIM_CANHS_R_01[2]
			CLIM_CANHS_R_01[3]
			CLIM_CANHS_R_01[4]
			CLIM_CANHS_R_01[5]
			DDCM_CANLSFT_R_01[0]
			DDCM_CANLSFT_R_01[1]
			DDCM_CANLSFT_R_01[2]
			DDCM_CANLSFT_R_01[3]
			DDCM_CANLSFT_R_01[4]
			BRAKE_CANHS_RNr_01[0]
			BRAKE_CANHS_RNr_01[1]
			BRAKE_CANHS_RNr_01[2]
			BRAKE_CANHS_RNr_01[3]
			BRAKE_CANHS_RNr_01[4]
			BRAKE_CANHS_RNr_01[5]
			BRAKE_CANHS_RNr_01[6]
			SWA_CANHS_RNr_01[0]
			SWA_CANHS_RNr_01[1]
			SWA_CANHS_RNr_01[2]
			SWA_CANHS_RNr_01[3]
			SWA_CANHS_RNr_01[4]
			SWA_CANHS_RNr_01[5]
			SWA_CANHS_RNr_01[6]
			SWA_CANHS_RNr_01[7]
			TORQUE_AT_CANHS_RNr_01[0]
			TORQUE_AT_CANHS_RNr_01[1]
			TORQUE_AT_CANHS_RNr_01[2]
			TORQUE_AT_CANHS_RNr_01[3]
			TORQUE_AT_CANHS_RNr_01[4]
			TORQUE_AT_CANHS_RNr_01[5]
			TORQUE_AT_CANHS_RNr_01[6]
			TORQUE_AT_CANHS_RNr_01[7]
			TORQUE_AT_CANHS_RNr_02[0]
			TORQUE_AT_CANHS_RNr_02[1]
			TORQUE_AT_CANHS_RNr_02[2]
			TORQUE_AT_CANHS_RNr_02[3]
			TORQUE_AT_CANHS_RNr_02[4]
			TORQUE_AT_CANHS_RNr_02[5]
			TORQUE_AT_CANHS_RNr_02[6]
			TORQUE_AT_CANHS_RNr_02[7]
			USM_CANHS_RNr_01[0]
			USM_CANHS_RNr_01[1]
			USM_CANHS_RNr_01[2]
			USM_CANHS_RNr_01[3]
			USM_CANHS_RNr_01[4]
			Vxx_abs_ecu_stt
			Vxx_ac_ecu_stt
			Vxx_ac_ecu_stt_diag
			Vxx_acc_ecu_stt_diag
			Vxx_agb_ecu_stt
			Vxx_agb_ecu_stt_diag
			Vxx_bus_off_stt_diag
			Vxx_ccu_ecu_stt
			Vxx_ccu_ecu_stt_diag
			Vxx_ip_ecu_stt_diag
			Vxx_mute_stt_diag
			Vxx_mux_frm_set_ref
			Vxx_swa_ecu_stt_diag
			Vxx_ip_ecu_stt
			Vxx_usm_ecu_stt
			Vxx_usm_ecu_stt_diag
			Vxx_abs_ecu_stt_diag
			Vbx_can_diag_ecm
			Vbx_can_diag_bus_fail
			Vbx_mute_pws_typ_bc
			Vxx_abs_ecu_stt_ctr
			Vxx_ac_ecu_stt_ctr
			Vxx_acc_ecu_stt
			Vxx_acc_ecu_stt_ctr
			Vxx_agb_ecu_stt_ctr
			Vxx_bus_off_stt
			Vxx_bus_off_stt_ctr
			Vxx_ccu_ecu_stt_ctr
			Vxx_ddcm_ecu_stt
			Vxx_ddcm_ecu_stt_diag
			Vxx_ddcm_ecu_stt_ctr
			Vxx_ip_ecu_stt_ctr
			Vxx_mute_stt
			Vxx_mute_stt_ctr
			Vxx_swa_ecu_stt
			Vxx_swa_ecu_stt_ctr
			Vxx_usm_ecu_stt_ctr
			Vbx_abs_pws_typ_bc
			Vbx_acc_pws_typ_bc
			Vbx_ac_pws_typ_bc
			Vbx_ccu_pws_typ_bc
			Vbx_ip_pws_typ_bc
			Vbx_ddcm_pws_typ_bc
			Vbx_agb_pws_typ_bc
			Vbx_usm_pws_typ_bc
			Vxx_abs_ecu_stt_ctr_mem_prev
			Vxx_ac_ecu_stt_ctr_mem_prev
			Vxx_ac_ecu_stt_ctr_mem_dec
			Vxx_acc_ecu_stt_ctr_mem_prev
			Vxx_acc_ecu_stt_ctr_mem_dec
			Vxx_agb_ecu_stt_ctr_mem_prev
			Vxx_agb_ecu_stt_ctr_mem_dec
			Vxx_bus_off_stt_ctr_mem_prev
			Vxx_bus_off_stt_ctr_mem_dec
			Vxx_ccu_ecu_stt_ctr_mem_prev
			Vxx_ccu_ecu_stt_ctr_mem_dec
			Vxx_ddcm_ecu_stt_ctr_mem_prev
			Vxx_ddcm_ecu_stt_ctr_mem_dec
			Vxx_ip_ecu_stt_ctr_mem_prev
			Vxx_ip_ecu_stt_ctr_mem_dec
			Vxx_mute_stt_ctr_mem_prev
			Vxx_mute_stt_ctr_mem_dec
			Vxx_swa_ecu_stt_ctr_mem_prev
			Vxx_swa_ecu_stt_ctr_mem_dec
			Vxx_usm_ecu_stt_ctr_mem_prev
			Vxx_usm_ecu_stt_ctr_mem_dec
			Vxx_gcu_ecu_stt_diag
			Vxx_sdl_ecu_stt_diag
			CLUSTER_CANHS_RNr_01[0]
			CLUSTER_CANHS_RNr_01[1]
			CLUSTER_CANHS_RNr_01[2]
			CLUSTER_CANHS_RNr_01[3]
			CLUSTER_CANHS_RNr_01[4]
			CLUSTER_CANHS_R_01[0]
			CLUSTER_CANHS_R_01[1]
			CLUSTER_CANHS_R_01[2]
			CLUSTER_CANHS_R_01[3]
			CLUSTER_CANHS_R_01[4]
			CLUSTER_CANHS_R_01[5]
			CLUSTER_CANHS_R_01[6]
			CLUSTER_CANHS_R_01[7]
			Vbx_swa_pws_typ_bc
			Vbx_sdl_pws_typ_bc
			Vxx_abs_ecu_stt_ctr_mem_dec
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcabsin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_abs_reg
			Vsx_mux_abs_reg_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcaplou
		""
	/begin DEF_CHARACTERISTIC
			Cbx_acel_pdl_rat_secu_1_cfm
			Cbx_mux_driv_pwt_sp_fail
			Cxx_acel_pdl_rat_secu_1_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			KickDownActivated
			PedalError
			PowerTrainSetPoint
			RawSensor
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcatqin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_gear_cge
			Vsx_mux_agb_csm_tq_vld
			Vsx_mux_agb_tq_ctl_typ
			Vxx_mux_agb_clck
			Vxx_mux_agb_csm_tq
			Vxx_mux_agb_tqe_sp
			Vxx_mux_agb_tqe_sp_raw
			Vxx_mux_agb_tqe_tgt_lim
			Vxx_mux_agb_tqe_tgt_lim_raw
			Vbx_mux_agb_csm_tq_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcbpkin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_bpk
			Vsx_mux_bpk_vld
			Vbx_mux_bpk_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcbrkin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_brk_pdl_navl
			Vsx_mux_brk_pdl
			Vsx_mux_brk_pdl_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcbrkou
		""
	/begin OUT_MEASUREMENT
			OpenActiveBrakeSwitch_ECM
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcclbin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_bgin_str_clu_cnt_navl
			Vsx_mux_bgin_str_clu_cnt
			Vsx_mux_bgin_str_clu_cnt_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcclein
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_end_str_clu_cnt_navl
			Vsx_mux_end_str_clu_cnt
			Vsx_mux_end_str_clu_cnt_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcespin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_asr_reg
			Vbx_mux_ayc_reg
			Vsx_mux_asr_msr_typ
			Vsx_mux_asr_msr_typ_vld
			Vsx_mux_asr_reg_vld
			Vxx_mux_asr_msr_clck
			Vxx_mux_asr_tqe_sp
			Vxx_mux_asr_tqe_tgt
			Vxx_mux_asr_tqe_sp_raw
			Vxx_mux_asr_tqe_tgt_raw
			Vxx_mux_msr_tqe_sp
			Vxx_mux_msr_tqe_sp_raw
			Vsx_mux_ayc_reg_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcfshou
		""
	/begin DEF_CHARACTERISTIC
			Cxx_free_shf_dft_val
			Cxx_free_shf_ini_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			FreeShift
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcrvnin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_rvr_cnt_navl
			Vbx_mux_neut_cnt_navl
			Vsx_mux_neut_cnt
			Vsx_mux_neut_cnt_vld
			Vsx_mux_rvr_cnt
			Vsx_mux_rvr_cnt_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pcspcin
		""
	/begin OUT_MEASUREMENT
			Vxx_mux_agb_driv_spt_fac
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pctbnin
		""
	/begin OUT_MEASUREMENT
			Vxx_mux_prim_sha_spd
			Vsx_mux_prim_sha_spd_vld
			Vbx_mux_prim_sha_spd_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pctcsin
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_agb_coup
			Vbx_mux_agb_coup_navl
			Vsx_mux_rgb_coup
			Vsx_mux_agb_coup_vld
			Vsx_mux_rgb_coup_vld
			Vsx_mux_ant_crt_slc
			Vsx_mux_ant_crt_slc_vld
			Vbx_mux_ant_crt_slc_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pctqeou
		""
	/begin OUT_MEASUREMENT
			ASR_MSRAcknowledgement
			AT_TorqueAcknowledgement
			EngineTorque_WithoutTMReq
			RawEngineTorque_WithoutTMReq
			RequestedTorqueAfterProc
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Pctrein
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_drag_red_agb
			Vbx_mux_egb_neut
			Vsx_mux_drag_red_agb_vld
			Vsx_mux_egb_neut_vld
			Vsx_mux_raw_egb_ant_gear
			Vsx_mux_raw_egb_ant_gear_vld
			Vsx_mux_raw_egb_gear
			Vsx_mux_raw_egb_gear_vld
			Vbx_mux_raw_egb_ant_gear_navl
			Vbx_mux_raw_egb_gear_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Rxfrmxx
		""
	/begin OUT_MEASUREMENT
			ABSinRegulation
			ACCompPowerUsed
			ACCompClutchStatus
			ACCompRequest
			ACMinEngineIdleSpeedRequest
			ASRDynamicTorqueRequest
			ASRStaticTorqueRequest
			ASRinRegulation
			ACCoolingFanSpeedRequest
			AT_Clock
			AT_TorqueControlType
			AT_Minimum_IdleSpeedRequest
			AT_TorqueLosses
			AccurateOdometer
			AlternatorLoad
			AnticipatedCurrentShift
			BrakeSwitchFailure
			ClutchSwitchMaximumTravel
			DiagMuxOn_BCM
			DisplayedSpeed
			DistanceTotalizer
			ESP_Clock
			AT_MILRequest
			ESP_TorqueControlType
			ElectricalPowerDrived
			EmergencyEngineStop
			ExternalTemp
			FastTorqueRequest
			AYCinRegulation
			FuelLow
			GenericApplicativeDiagEnable
			AirbagCrashOrder
			InstantMecanicalPowerByAlt
			Limit_SlowTorqueRequest
			MSRTorqueRequest
			MSRinRegulation
			ATCoolingFanSpeedRequest
			MiniConsumptionRequest
			NeutralContact
			DisplayedSpeedUnit
			PTCEngineIdleSpeedRequest
			ClutchSwitchMinimumTravel
			ParkingBrakeStatus
			FrontDefrostEngaged
			RearDefrostEngaged
			RearGearEngaged
			SLockValueControl
			SportivityCriteria
			BrakeInfoStatus
			StartButtonPushed
			StarterStatus
			StartingMode_BCM_R
			InputShaftRevolution
			SteeringWheelAngle
			TorqueConverterState
			TransmRangeEngaged_Current
			TransmRangeEngaged_Target
			TransversalAcceleration
			VehicleSpeed
			WheelSpeedRL
			WheelSpeedRR
			SoftwareLockValue[0]
			SoftwareLockValue[1]
			SoftwareLockValue[2]
			SoftwareLockValue[3]
			ACCompClutchRequest
			OilDrainAlertResetRequest
			ClimateCoolingRequest
			DiagnoseFuelLow
			FuelCutRequestedEngineSpeed
			FuelLevelDisplayed
			KeyVehicle
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Rxp50in
		""
	/begin DEF_CHARACTERISTIC
			Cxx_eng_aut_can_diag_dly
			Cbx_vh_key_navl_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_mux_ac_mdf1_req
			Vbx_mux_ac_mdf2_req
			Vbx_mux_ac_req
			Vbx_mux_agb_mdf1_req
			Vbx_mux_agb_mdf2_req
			Vbx_mux_vh_key
			Vsx_mux_ac_mdf_req_vld
			Vsx_mux_ac_req_vld
			Vsx_mux_agb_mdf_req_vld
			Vsx_mux_ena_sta_agb
			Vsx_mux_ena_sta_agb_vld
			Vsx_mux_sta_stt_vld
			Vsx_mux_vs_vld
			Vxx_mux_dspl_vs
			Vxx_mux_eng_stop_req_ccu
			Vxx_mux_eng_stop_req_rgb
			Vxx_mux_eng_stop_req_ssg
			Vxx_mux_vs
			Vbx_mux_dspl_vs_in_mph
			Vbx_mux_can_diag
			Vsx_mux_dspl_vs_vld
			Vxx_mux_airb1
			Vxx_mux_airb2
			Vbx_can_diag
			Vbx_can_diag_raw
			Vbx_mux_dspl_vs_navl
			Vxx_mux_sta_stt
			Vxx_mux_sta_swi_act_ctr
			Vbx_mux_ac_acel_is_sp_navl
			Vxx_mux_ac_acel_is_sp
			Vsx_mux_ac_acel_is_sp_vld
			Vbx_mux_vs_navl
			Vbx_mux_ac_req_ext
			Vbx_mux_ac_req_int
			Vsx_mux_ac_req_int_vld
			Vsx_mux_ac_req_ext_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smacsin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_acs_acel_is_req
			Vsx_mux_acs_acel_is_req_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smat1in
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_agb_is_acel_req
			Vsx_mux_agb_is_acel_req_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smat2in
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_agb_is_acel_sp_navl
			Vsx_mux_agb_is_acel_sp_vld
			Vxx_mux_agb_is_acel_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smengou
		""
	/begin OUT_MEASUREMENT
			EngineStatus_R
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smovnou
		""
	/begin OUT_MEASUREMENT
			MaxEngineSpeedRequest
			MinEngineSpeedRequest
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smptcin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_ptc_is_acel_req
			Vsx_mux_ptc_is_acel_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smspdou
		""
	/begin OUT_MEASUREMENT
			EngineRPM
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smsptou
		""
	/begin OUT_MEASUREMENT
			IdleSpeedControlInternalRequest
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Smwixin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_el_bk_wind
			Vbx_mux_el_wind_is_acel
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tenvxin
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_tenv_vld
			Vxx_mux_tenv
			Vbx_mux_tenv_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqacxin
		""
	/begin OUT_MEASUREMENT
			Vxx_mux_ac_pow
			Vsx_mux_ac_pow_vld
			Vbx_mux_ac_pow_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqacxou
		""
	/begin OUT_MEASUREMENT
			ACCompMaximumPower
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqampou
		""
	/begin OUT_MEASUREMENT
			AlternatorMaximumPower
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqapgou
		""
	/begin OUT_MEASUREMENT
			AllowedPowerGradient
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqecfou
		""
	/begin OUT_MEASUREMENT
			ElectricalPowerCutFreeze
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqestou
		""
	/begin OUT_MEASUREMENT
			MeanEffectiveTorque
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqlosou
		""
	/begin OUT_MEASUREMENT
			FrictionTorque
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqmaxou
		""
	/begin OUT_MEASUREMENT
			MaximumInstantTorque
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqminou
		""
	/begin OUT_MEASUREMENT
			MinimumInstantTorque
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqmpaou
		""
	/begin OUT_MEASUREMENT
			MaxElectricalPowerAllowed
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqpalin
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_alt_pow_vld
			Vxx_mux_alt_pow
			Vbx_mux_alt_pow_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqprgin
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_rgb_pump_vld
			Vxx_mux_rgb_pump
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Tqreqou
		""
	/begin OUT_MEASUREMENT
			ECM_TorqueRequestStatus
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Txfrmxx
		""
	/begin OUT_MEASUREMENT
			ECM_VERLOG[0]
			ECM_VERLOG[1]
			ECM_VERLOG[2]
			ECM_VERLOG[3]
			ECM_VERLOG[4]
			ECM_VERLOG[5]
			ECM_VERLOG[6]
			ECM_CANHS_RNr_02[0]
			ECM_CANHS_RNr_02[1]
			ECM_CANHS_RNr_02[2]
			ECM_CANHS_RNr_02[3]
			ECM_CANHS_RNr_02[4]
			ECM_CANHS_RNr_02[5]
			ECM_CANHS_RNr_02[6]
			ECM_CANHS_RNr_01[0]
			ECM_CANHS_RNr_01[1]
			ECM_CANHS_RNr_01[2]
			ECM_CANHS_RNr_01[3]
			ECM_CANHS_RNr_01[4]
			ECM_CANHS_RNr_01[5]
			ECM_CANHS_RNr_01[6]
			ECM_CANHS_RNr_01[7]
			MMI_ECM_CANHS_RNr_01[0]
			MMI_ECM_CANHS_RNr_01[1]
			MMI_ECM_CANHS_RNr_01[2]
			MMI_ECM_CANHS_RNr_01[3]
			MMI_ECM_CANHS_RNr_01[4]
			MMI_ECM_CANHS_RNr_01[5]
			TORQUE_ECM_CANHS_RNr_02[0]
			TORQUE_ECM_CANHS_RNr_02[1]
			TORQUE_ECM_CANHS_RNr_02[2]
			TORQUE_ECM_CANHS_RNr_02[3]
			TORQUE_ECM_CANHS_RNr_02[4]
			TORQUE_ECM_CANHS_RNr_02[5]
			TORQUE_ECM_CANHS_RNr_01[0]
			TORQUE_ECM_CANHS_RNr_01[1]
			TORQUE_ECM_CANHS_RNr_01[2]
			TORQUE_ECM_CANHS_RNr_01[3]
			TORQUE_ECM_CANHS_RNr_01[4]
			TORQUE_ECM_CANHS_RNr_01[5]
			TORQUE_ECM_CANHS_RNr_01[6]
			TORQUE_ECM_CANHS_R_01[0]
			TORQUE_ECM_CANHS_R_01[1]
			TORQUE_ECM_CANHS_R_01[2]
			TORQUE_ECM_CANHS_R_01[3]
			TORQUE_ECM_CANHS_R_01[4]
			FORCE_ECM_CANHS_R_01[0]
			FORCE_ECM_CANHS_R_01[1]
			FORCE_ECM_CANHS_R_01[2]
			FORCE_ECM_CANHS_R_01[3]
			FORCE_ECM_CANHS_R_01[4]
			FORCE_ECM_CANHS_R_01[5]
			FORCE_ECM_CANHS_R_01[6]
			FORCE_ECM_CANHS_R_01[7]
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Txp50ou
		""
	/begin OUT_MEASUREMENT
			ACHighPressureSensor
			CruiseControlStatusDisplay
			CruiseControlStatus_forTM
			EngineFanSpeedRequest
			EngineStopRequestOrigine
			OverspeedIndicationDisplayReq
			CrankingAuthorization_ECM
			RequestedSpeedDisplayRequest
			CCSpeedReachedDisplayReq
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vfacxin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_ac_clu_req
			Vsx_mux_ac_clu_req_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vfacxou
		""
	/begin OUT_MEASUREMENT
			ACCompAuthorized
			ACCompClutchActivation
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vfadfin
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_alt_pwm_vld
			Vxx_mux_alt_pwm
			Vbx_mux_alt_pwm_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vffltou
		""
	/begin OUT_MEASUREMENT
			FloatingInhibition
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vfpdain
		""
	/begin OUT_MEASUREMENT
			Vsx_mux_aod_vs_vld
			Vsx_mux_raw_whl_angl_vld
			Vxx_mux_aod_vs
			Vxx_mux_raw_whl_angl
			Vbx_mux_aod_vs_navl
			Vbx_mux_raw_whl_angl_navl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vfptcin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_ptc_pow_navl
			Vsx_mux_ptc_pow_vld
			Vxx_mux_ptc_pow
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vfrwsin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_lft_rwhs_navl
			Vbx_mux_rgt_rwhs_navl
			Vsx_mux_lft_rwhs_vld
			Vsx_mux_rgt_rwhs_vld
			Vxx_mux_lft_rwhs
			Vxx_mux_rgt_rwhs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin FUNCTION
		CmMuxSer_Vftacin
		""
	/begin OUT_MEASUREMENT
			Vbx_mux_tra_acel_in_navl
			Vsx_mux_tra_acel_vld
			Vxx_mux_tra_acel
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin FUNCTION
		DgDftMng
		""
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_NO_ERROR.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_NO_ERROR.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_NO_ERROR.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_NO_ERROR.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_NO_ERROR.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_NO_ERROR.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_NO_ERROR.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_NO_ERROR.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_NO_ERROR.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_NO_ERROR.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_NO_ERROR.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_NO_ERROR.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ac_clu.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ac_clu.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ac_clu.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ac_clu.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ac_clu.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ac_clu.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ac_clu_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ac_clu_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ac_clu_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ac_clu_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ac_clu_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ac_clu_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_alt_pwm.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_alt_pwm.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_alt_pwm.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_alt_pwm.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_alt_pwm.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_alt_pwm.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_alt_pwm_apl_down.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_alt_pwm_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_alt_pwm_apl_down.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_alt_pwm_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_alt_pwm_apl_down.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_alt_pwm_apl_down.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_clos.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_clos.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_clos.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_clos.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_clos.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_clos.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_clos_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_clos_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_no_norm.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_open.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_open.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_open.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_open.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_open.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_brk_pdl_open.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_open_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_brk_pdl_open_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata1.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata1.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata1.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata1.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata1.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata1.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata1_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata1_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cata2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata2_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata2_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_cpt.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_cpt.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_cpt.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_cpt.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_cpt.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_cpt.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cata_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cl_rich.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cl_rich.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cl_rich.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cl_rich.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cl_rich.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cl_rich.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cl_rich_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cl_rich_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cl_rich_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cl_rich_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cl_rich_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cl_rich_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_comb_trs.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_comb_trs.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_comb_trs.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_comb_trs.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_comb_trs.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_comb_trs.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_comb_trs_tout.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_comb_trs_tout.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_blk_open.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_blk_open.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_blk_open.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_blk_open.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cp_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_el.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_el.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_no_norm.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_puls.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_puls.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_puls.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_puls.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_puls.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_puls.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_syn.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_syn.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_trs.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_trs.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_trs.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_crk_trs.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_1.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_1.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_1.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_1.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_1.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_1.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_h_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_h_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_h_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_h_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_l_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_l_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_l_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_1_l_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_h_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_h_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_h_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_h_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_l_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_l_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_l_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_2_l_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_3.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_3.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_3.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_3.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_3.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_3.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_h_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_h_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_h_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_h_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_l_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_l_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_l_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_3_l_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_4.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_4.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_4.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_4.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_4.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_cyl_bal_4.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_h_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_h_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_h_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_h_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_l_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_l_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_l_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_cyl_bal_4_l_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_doc2_utp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_doc2_utp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_doc2_utp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_doc2_utp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_doc2_utp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_doc2_utp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_neg_dev.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_neg_dev.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_pos_dev.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_doc2_utp_pos_dev.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ecu.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ecu.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ecu.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ecu.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ecu.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ecu.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_itl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_itl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_itl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_itl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_itl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_itl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ecu_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ro2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ro2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ro2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ro2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ro2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_ro2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_slow_trs.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_slow_trs.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_slow_trs.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_slow_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_ro2_slow_trs.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_tip.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_tip.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_tip.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_tip.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_tip.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_tip.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_tip_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_tip_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_tip_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_tip_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_tip_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_tip_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_uo2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_uo2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_uo2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_uo2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_uo2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_dps_uo2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_uo2_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_uo2_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_uo2_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_uo2_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_uo2_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_dps_uo2_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_adc.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_adc.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_adc.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_adc.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_adc.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_adc.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_adc_tron.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_adc_tron.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_adc_tron.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_adc_tron.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_adc_tron.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_adc_tron.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_cmp.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_cmp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_cmp.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_cmp.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_cmp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_cmp.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_ini.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_ini.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_inj_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_it.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_it.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_it.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_it.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_it.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_it.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_lih_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_lih_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_lih_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_lih_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_lih_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_lih_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_it_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mcw_clc_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mcw_clc_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mcw_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mcw_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mcw_seq_ctr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mcw_seq_ctr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mon_tron.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mon_tron.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mon_tron.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mon_tron.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mon_tron.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_mon_tron.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_temp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_temp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_temp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_temp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_temp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ecm_temp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_temp_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_temp_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_temp_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_temp_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_temp_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ecm_temp_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_efi_pump.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_efi_pump.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_efi_pump.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_efi_pump.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_efi_pump.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_efi_pump.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_efi_pump_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_byp_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_byp_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_byp_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_byp_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_byp_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_byp_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_egr_cool.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_egr_cool.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_egr_cool.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_egr_cool.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_egr_cool.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_egr_cool.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_cool_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_egr_cool_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_fcap.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_fcap.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_fcap.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_fcap.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_fcap.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_fcap.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_abn_cple.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_abn_cple.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_abn_cple.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_abn_cple.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_abn_cple.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_abn_cple.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_no_lk.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_no_lk.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_no_lk.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_no_lk.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_no_lk.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_fcap_no_lk.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_sldv.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_sldv.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_sldv.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_sldv.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_sldv.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_eva_sldv.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_blk_clos.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_blk_clos.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_blk_clos.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_blk_clos.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_eva_sldv_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_evap.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_evap.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_evap.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_evap.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_evap.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_evap.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_lkg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_lkg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_lkg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_evap_lkg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ex_cam.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ex_cam.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ex_cam.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ex_cam.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ex_cam.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ex_cam.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_crk_cmp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_crk_cmp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_l_puls.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_syn.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ex_cam_syn.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_exh_temp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_exh_temp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_exh_temp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_exh_temp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_exh_temp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_exh_temp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_exh_temp_cmp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_exh_temp_cmp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_actr_blk.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_actr_blk.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_actr_blk.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_actr_blk.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_actr_blk.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_actr_blk.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_dirt_lkg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_dirt_lkg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_no_norm.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_no_norm.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_no_norm.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_no_norm.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_shp.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_shp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_shp.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_shp.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_shp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ff_fct_shp.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_actr_blk.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_actr_blk.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_actr_blk.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_actr_blk.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_actr_blk.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_actr_blk.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_fct_shp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_fct_shp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_h.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_h.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_h.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_h.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_h.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_h.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_h_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_h_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_h_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_h_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_h_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_h_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_l.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_l.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_l.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_l.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_l.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fprs_l.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_l_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_l_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_l_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_l_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_l_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fprs_l_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_cpt.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_cpt.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_cpt.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_cpt.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_cpt.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_cpt.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fsys_lpg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fsys_lpg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fsys_lpg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fsys_lpg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fsys_lpg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_fsys_lpg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_lpg_cpt.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_lpg_cpt.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_lpg_cpt.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_lpg_cpt.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_lpg_cpt.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fsys_lpg_cpt.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_plaus.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_plaus.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_plaus.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_plaus.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_plaus.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_plaus.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_sig_mcut.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_sig_mcut.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_sig_mcut.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_sig_mcut.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_sig_mcut.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_fuel_temp_sig_mcut.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_gas_pump.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_gas_pump.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_gas_pump.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_gas_pump.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_gas_pump.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_gas_pump.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_gas_pump_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_glow_cmd_cpt_blk.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_glow_cmd_cpt_blk.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_glow_cmd_cpt_blk.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_glow_cmd_cpt_blk.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_glow_cmd_cpt_blk.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_glow_cmd_cpt_blk.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1_4.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1_4.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1_4.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1_4.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1_4.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1_4.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_4_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_1.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_1_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2_3.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2_3.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2_3.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2_3.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2_3.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2_3.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_3_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_2_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_3.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_3.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_3.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_3.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_3.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_3.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_3_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_4.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_4.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_4.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_4.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_4.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_igc_4.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_igc_4_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_cam_frq_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_cam_frq_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_cam_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_cam_l_puls.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_cam_syn.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_cam_syn.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_ad.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_ad.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_ad.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_ad.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_ad.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_ad.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_blk.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_blk.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_blk.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_blk.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_blk.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_blk.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_dirt_lkg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_dirt_lkg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc_sldv.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc_sldv.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc_sldv.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc_sldv.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc_sldv.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_in_vvtc_sldv.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_in_vvtc_sldv_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_4_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_4_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_4_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_4_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_4_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_4_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_fast_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_fast_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_freq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_freq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_freq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_freq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_freq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_freq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_frq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_frq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_frq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_frq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_frq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_frq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_r.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_r.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_r.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_r.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_r.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_r.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj1_slow_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_3_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_3_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_3_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_3_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_3_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_3_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_fast_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_fast_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_freq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_freq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_freq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_freq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_freq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_freq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_frq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_frq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_frq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_frq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_frq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_frq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_r.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_r.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_r.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_r.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_r.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_r.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj2_slow_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_fast_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_fast_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_freq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_freq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_freq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_freq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_freq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_freq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_frq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_frq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_frq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_frq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_frq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_frq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_r.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_r.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_r.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_r.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_r.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_r.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj3_slow_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_fast_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_fast_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_freq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_freq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_freq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_freq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_freq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_freq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_frq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_frq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_frq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_frq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_frq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_frq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_r.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_r.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_r.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_r.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_r.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_r.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj4_slow_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_inj_ecu.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_inj_ecu.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_inj_ecu.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_inj_ecu.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_inj_ecu.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_inj_ecu.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_bus_mcut.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_bus_mcut.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_bus_mcut.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_bus_mcut.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_bus_mcut.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_bus_mcut.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_itl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_itl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_itl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_itl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_itl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_itl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbdw_icp.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbdw_icp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbdw_icp.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbdw_icp.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbdw_icp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbdw_icp.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbup_icp.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbup_icp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbup_icp.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbup_icp.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbup_icp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_inj_ecu_lbup_icp.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_isr.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_isr.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_isr.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_isr.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_isr.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_isr.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_h_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_h_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_h_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_h_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_l_lvl.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_l_lvl.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_l_lvl.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_isr_l_lvl.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_it_cmd.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_it_cmd.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_it_cmd.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_it_cmd.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_it_cmd.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_it_cmd.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_cmd_el.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_cmd_el.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_cmd_el.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_cmd_el.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_cmd_el.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_cmd_el.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_meca.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_meca.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_meca.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_meca.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_meca.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_meca.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_secu_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_secu_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_secu_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_secu_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_secu_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_ofs_secu_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_ad.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_ad.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_ad.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_ad.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_ad.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_ad.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_el.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_it_reg_el.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_knk.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_knk.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_knk.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_knk.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_knk.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_knk.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_knk_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_knk_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_knk_shp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_knk_shp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw_hot.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw_hot.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw_hot.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw_hot.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw_hot.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw_hot.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_dirt_lkg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_dirt_lkg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_hot_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbdw.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbdw_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_cpt.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_cpt.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_cpt.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_cpt.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_cpt.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_cpt.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup_hot.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup_hot.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup_hot.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup_hot.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup_hot.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_lbup_hot.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_apl_down.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_apl_down.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_apl_down.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_apl_down.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_dirt_lkg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_dirt_lkg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_hot_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_lbup_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_maf_reg_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_maf_reg_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mafs_plau_diag_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_map_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf1.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf1.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf1.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf1.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf1.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf1.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf1_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf1_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf1_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf1_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf1_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf1_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mdf2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf2_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf2_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf2_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf2_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf2_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mdf2_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1_lpg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1_lpg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1_lpg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1_lpg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1_lpg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_1_lpg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_lpg_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_1_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2_lpg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2_lpg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2_lpg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2_lpg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2_lpg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_2_lpg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_lpg_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_2_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3_lpg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3_lpg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3_lpg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3_lpg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3_lpg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_3_lpg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_lpg_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_3_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4_lpg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4_lpg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4_lpg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4_lpg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4_lpg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_4_lpg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_lpg_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_4_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_lpg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_lpg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_lpg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_lpg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_lpg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_lpg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_lpg_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_min_fuel.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_min_fuel.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_min_fuel.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_min_fuel.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_min_fuel.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_min_fuel.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_min_fuel_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk_lpg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk_lpg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk_lpg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk_lpg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk_lpg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mis_unk_lpg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_cata.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_cata.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_cata.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_cata.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_cata.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_cata.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_lpg_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_trs_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_trs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_trs_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_trs_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_trs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mis_unk_trs_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_pump_rly.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_pump_rly.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_pump_rly.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_pump_rly.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_pump_rly.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_pump_rly.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mvac_pump_rly_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mvac_pump_rly_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mvac_pump_rly_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mvac_pump_rly_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_sys.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_sys.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_sys.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_sys.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_sys.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_mvac_sys.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mvac_sys_cpt.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_mvac_sys_cpt.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oil_dil_ovs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oil_dil_ovs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_oit_hbdg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_oit_hbdg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_oit_hbdg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_oit_hbdg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_oit_hbdg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_oit_hbdg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_el.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_el.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_el.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_el.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_el.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_el.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_ovh.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_ovh.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_ovh.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_ovh.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_ovh.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_oit_hbdg_ovh.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pcv.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pcv.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pcv.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pcv.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pcv.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pcv.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pcv_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_dirt_lkg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dp_dirt_lkg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dtp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dtp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dtp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dtp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dtp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_dtp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_ovh.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_ovh.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_ovh.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_ovh.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_ovh.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pft_ovh.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_ovh.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_dtp_ovh.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_rgn_max_err.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_rgn_max_err.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_utp_ovh.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pft_utp_ovh.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pftrelprs.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pftrelprs.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pftrelprs.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pftrelprs.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pftrelprs.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_pftrelprs.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pftrelprs_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pftrelprs_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pftrelprs_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_pftrelprs_dirt_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ps_toil.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ps_toil.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ps_toil.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ps_toil.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ps_toil.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ps_toil.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_h_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_h_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_h_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_h_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_h_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_h_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_l_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_l_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_l_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_l_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_l_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_max_l_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_h_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_h_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_h_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_h_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_h_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_h_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_l_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_l_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_l_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_l_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_l_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_min_l_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_sig_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_sig_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_sig_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_sig_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_sig_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ps_toil_sig_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilprty.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilprty.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilprty.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilprty.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilprty.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilprty.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_h_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_h_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_h_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_h_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_h_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_h_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_l_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_l_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_l_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_l_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_l_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_max_l_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_h_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_h_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_h_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_h_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_h_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_h_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_l_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_l_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_l_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_l_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_l_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_min_l_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_sig_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_sig_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_sig_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_sig_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_sig_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilprty_sig_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilvisc.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilvisc.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilvisc.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilvisc.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilvisc.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_psoilvisc.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_h_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_h_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_h_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_h_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_h_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_h_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_l_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_l_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_l_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_l_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_l_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_max_l_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_h_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_h_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_h_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_h_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_h_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_h_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_l_t.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_l_t.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_l_t.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_l_t.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_l_t.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_min_l_t.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_sig_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_sig_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_sig_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_sig_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_sig_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_psoilvisc_sig_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc1.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc1.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc1.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc1.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc1.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc1.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc1_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc1_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc1_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc1_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc1_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc1_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc2_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc2_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc2_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc2_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc2_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc2_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc3.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc3.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc3.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc3.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc3.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc3.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc3_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc3_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc3_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc3_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc3_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc3_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc_rov.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc_rov.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc_rov.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc_rov.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc_rov.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ptc_rov.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc_rov_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc_rov_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc_rov_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc_rov_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc_rov_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ptc_rov_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_rail_prs_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_rail_prs_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_alt_pwm.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_alt_pwm.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_alt_pwm.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_alt_pwm.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_alt_pwm.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_alt_pwm.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_alt_pwm_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_amp_reg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_amp_reg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_amp_reg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_amp_reg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_amp_reg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_amp_reg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_reg_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_reg_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_reg_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_reg_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_reg_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_reg_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_amp_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_heat.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_heat.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_heat.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_heat.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_heat.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_heat.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_ovh.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_ovh.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_ovh.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_ovh.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_ovh.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_ovh.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_heat_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_lamb.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_lamb.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_lamb.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_lamb.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_lamb.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_lamb.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_lamb_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_lamb_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_lamb_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_lamb_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_lamb_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_lamb_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_pump.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_pump.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_pump.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_pump.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_pump.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_pump.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_pump_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_pump_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_pump_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_pump_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_pump_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_pump_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_virt.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_virt.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_virt.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_virt.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_virt.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_virt.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_virt_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_virt_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_virt_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_virt_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_virt_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_virt_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_wire.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_wire.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_wire.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_wire.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_wire.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_dps_wire.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_dps_wire_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_ex_prs_no_lk.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_ex_prs_no_lk.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_ex_prs_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_ex_prs_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_1.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_1.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_1.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_1.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_1.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_1.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_1_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_1_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_1_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_1_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_1_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_1_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_it_2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_2_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_2_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_2_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_2_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_2_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_2_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_sig_mcut.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_sig_mcut.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_sig_mcut.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_sig_mcut.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_sig_mcut.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_it_sig_mcut.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_maf_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_maf_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_maf_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_maf_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_maf_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_maf_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_map_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_mat.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_mat_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pft_dp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pft_dp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pft_dp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pft_dp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pft_dp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pft_dp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pft_dp_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pftrelprs.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pftrelprs.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pftrelprs.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pftrelprs.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pftrelprs.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_pftrelprs.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_lkg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_lkg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_pftrelprs_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_rvc.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_rvc.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_rvc.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_rvc.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_rvc.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_rvc.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_sig_mcut.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_sig_mcut.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_sig_mcut.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_sig_mcut.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_sig_mcut.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_rvc_sig_mcut.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_spg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_spg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_spg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_spg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_spg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_spg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_spg_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_tia_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_tia_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_tia_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_tia_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_tia_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_tia_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_toil.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_toil.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_toil.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_toil.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_toil.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_toil.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_toil_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sens_up_it_temp.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_up_it_temp_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_ups_wire_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_ups_wire_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_wfl_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_wfl_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_wfl_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sens_wfl_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sfty_tq_lih_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sfty_tq_lih_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sfty_tq_lim.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sfty_tq_lim.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_hbdg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_hbdg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_hbdg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_hbdg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_hbdg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_hbdg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_el.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_el.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_el.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_el.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_el.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_el.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_ovh.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_ovh.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_ovh.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_ovh.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_ovh.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_hbdg_ovh.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_reg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_reg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_reg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_reg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_reg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_sit_reg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk_open.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk_open.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk_open.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_blk_open.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_el.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_el.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_el.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_el.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_el.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_sit_reg_el.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_spg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_spg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_spg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_spg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_spg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_spg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_nok.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_nok.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_nok.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_nok.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_nok.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_nok.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_oor.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_oor.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_oor.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_oor.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_oor.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_oor.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_reg_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_reg_neg_err.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_reg_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_spg_reg_pos_err.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tbt_reg_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tbt_reg_pos_err.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tco_cl.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tco_cl.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tco_cl.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tco_cl.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tco_cl.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tco_cl.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tco_cl_no_norm.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tco_cl_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tco_cl_no_norm.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tco_cl_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tco_cl_no_norm.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tco_cl_no_norm.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tlz_ad_b.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tlz_ad_b.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tlz_ad_b.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tlz_ad_b.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tlz_ad_b.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tlz_ad_b.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tlz_ad_b_cpt.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tlz_ad_b_cpt.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tlz_ad_b_cpt.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tlz_ad_b_cpt.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tlz_ad_b_cpt.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tlz_ad_b_cpt.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tsta_reg.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tsta_reg.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tsta_reg.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tsta_reg.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tsta_reg.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_tsta_reg.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tsta_reg_no_norm.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tsta_reg_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tsta_reg_no_norm.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tsta_reg_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tsta_reg_no_norm.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_tsta_reg_no_norm.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_crt_intv.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_crt_intv.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_crt_intv.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_crt_intv.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_heat.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_heat.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_heat.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_heat.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_heat.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_heat.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_heat_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_hot.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_hot.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_hot.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_hot.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_hot.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_hot.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_hot_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_hot_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_hot_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_hot_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_hot_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_hot_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_lamb.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_lamb.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_lamb.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_lamb.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_lamb.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_lamb.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_lamb_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_pump.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_pump.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_pump.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_pump.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_pump.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_pump.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_pump_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_shp.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_shp.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_shp.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_shp.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_shp.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_shp.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_slow_trs.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_slow_trs.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_slow_trs.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_slow_trs.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_slow_trs.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_trim.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_trim.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_trim.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_trim.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_trim.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_trim.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_trim_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_virt.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_virt.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_virt.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_virt.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_virt.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_ups_virt.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_ups_virt_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vb_clc_chr.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vb_clc_chr.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vb_clc_chr.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vb_clc_chr.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vb_clc_chr.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vb_clc_chr.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_vcv.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_vcv.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_vcv.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_vcv.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_vcv.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_vcv.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vcv_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vnt_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vnt_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vnt_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vnt_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vnt_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_vnt_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wgc.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wgc.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wgc.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wgc.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wgc.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wgc.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wgc_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr_2.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr_2.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr_2.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr_2.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr_2.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr_2.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_freq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_no_sig.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_no_sig.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_no_sig.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_no_sig.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_no_sig.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_no_sig.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_2_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr.Ctx_ffm_did_xxx[0]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr.Ctx_ffm_did_xxx[1]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr.Ctx_ffm_did_xxx[2]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr.Ctx_ffm_did_xxx[3]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr.Ctx_ffm_did_xxx[4]' */
	/* ASAP2::Database : delete 'Pxx_dgdftmng_dtc_wpmp_egr.Cxx_dtc_hmb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_h.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_h.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_h.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_h.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_h.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_h.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_l.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_l.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_l.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_l.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_l.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_freq_l.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_no_sig.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_no_sig.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_no_sig.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_no_sig.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_no_sig.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_no_sig.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_oc.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_oc.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_oc.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_oc.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_oc.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_oc.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scg.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scg.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scg.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scg.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scg.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scg.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scw.Cxx_dtc_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scw.fm_static_bitfield.Cxx_conf_wal_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scw.fm_static_bitfield.Cbx_obd_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scw.fm_static_bitfield.Cbx_obd_mena_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scw.Cxx_dtc_lb_xxx' */
	/* ASAP2::Database : delete 'fm_cal_wpmp_egr_scw.Cxx_obd_dc_xxx' */
	/* ASAP2::Database : 2480 referenced entries deleted */
	/begin DEF_CHARACTERISTIC
			Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ac_prs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ac_prs.Cxx_dtc_hmb_xxx
			fm_cal_ac_prs_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ac_prs_h.Cxx_dtc_lb_xxx
			fm_cal_ac_prs_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ac_prs_l.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_acel_pdl.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_acel_pdl.Cxx_dtc_hmb_xxx
			fm_cal_acel_pdl_chr.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_chr.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_chr.Cxx_obd_dc_xxx
			fm_cal_acel_pdl_secu_1.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_secu_1.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_secu_1.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_secu_1.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_secu_1.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_secu_1.Cxx_obd_dc_xxx
			fm_cal_acel_pdl_secu_2.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_secu_2.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_secu_2.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_secu_2.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_secu_2.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_secu_2.Cxx_obd_dc_xxx
			fm_cal_acel_pdl_tot.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_tot.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_tot.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_tot.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_tot.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_tot.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_acel_pdl_v1.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_acel_pdl_v1.Cxx_dtc_hmb_xxx
			fm_cal_acel_pdl_v1_h.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_v1_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_v1_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_v1_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_v1_h.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_v1_h.Cxx_obd_dc_xxx
			fm_cal_acel_pdl_v1_l.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_v1_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_v1_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_v1_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_v1_l.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_v1_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_acel_pdl_v2.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_acel_pdl_v2.Cxx_dtc_hmb_xxx
			fm_cal_acel_pdl_v2_h.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_v2_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_v2_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_v2_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_v2_h.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_v2_h.Cxx_obd_dc_xxx
			fm_cal_acel_pdl_v2_l.Cxx_dtc_obd_xxx
			fm_cal_acel_pdl_v2_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_acel_pdl_v2_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_acel_pdl_v2_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_acel_pdl_v2_l.Cxx_dtc_lb_xxx
			fm_cal_acel_pdl_v2_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_actr_rly.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_actr_rly.Cxx_dtc_hmb_xxx
			fm_cal_actr_rly_oc.Cxx_dtc_obd_xxx
			fm_cal_actr_rly_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_actr_rly_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_actr_rly_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_actr_rly_oc.Cxx_dtc_lb_xxx
			fm_cal_actr_rly_oc.Cxx_obd_dc_xxx
			fm_cal_actr_rly_scg.Cxx_dtc_obd_xxx
			fm_cal_actr_rly_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_actr_rly_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_actr_rly_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_actr_rly_scg.Cxx_dtc_lb_xxx
			fm_cal_actr_rly_scg.Cxx_obd_dc_xxx
			fm_cal_actr_rly_scw.Cxx_dtc_obd_xxx
			fm_cal_actr_rly_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_actr_rly_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_actr_rly_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_actr_rly_scw.Cxx_dtc_lb_xxx
			fm_cal_actr_rly_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_agb_data.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_agb_data.Cxx_dtc_hmb_xxx
			fm_cal_agb_data_chr.Cxx_dtc_obd_xxx
			fm_cal_agb_data_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_agb_data_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_agb_data_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_agb_data_chr.Cxx_dtc_lb_xxx
			fm_cal_agb_data_chr.Cxx_obd_dc_xxx
			fm_cal_agb_data_seq_ctr.Cxx_dtc_obd_xxx
			fm_cal_agb_data_seq_ctr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_agb_data_seq_ctr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_agb_data_seq_ctr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_agb_data_seq_ctr.Cxx_dtc_lb_xxx
			fm_cal_agb_data_seq_ctr.Cxx_obd_dc_xxx
			fm_cal_agb_data_tout.Cxx_dtc_obd_xxx
			fm_cal_agb_data_tout.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_agb_data_tout.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_agb_data_tout.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_agb_data_tout.Cxx_dtc_lb_xxx
			fm_cal_agb_data_tout.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_agb.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_agb.Cxx_dtc_hmb_xxx
			fm_cal_agb_no_frm.Cxx_dtc_obd_xxx
			fm_cal_agb_no_frm.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_agb_no_frm.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_agb_no_frm.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_agb_no_frm.Cxx_dtc_lb_xxx
			fm_cal_agb_no_frm.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_amp_reg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_amp_reg.Cxx_dtc_hmb_xxx
			fm_cal_amp_reg_chr.Cxx_dtc_obd_xxx
			fm_cal_amp_reg_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_amp_reg_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_amp_reg_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_amp_reg_chr.Cxx_dtc_lb_xxx
			fm_cal_amp_reg_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_bgin_clu.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_bgin_clu.Cxx_dtc_hmb_xxx
			fm_cal_bgin_clu_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_bgin_clu_cmp.Cxx_dtc_lb_xxx
			fm_cal_bgin_clu_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_bgin_clu_nok.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_brk_pdl.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_brk_pdl.Cxx_dtc_hmb_xxx
			fm_cal_brk_pdl_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_brk_pdl_cmp.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_cata.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_cata.Cxx_dtc_hmb_xxx
			fm_cal_cata_nok_cge.Cxx_dtc_obd_xxx
			fm_cal_cata_nok_cge.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cata_nok_cge.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_cata_nok_cge.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_cata_nok_cge.Cxx_dtc_lb_xxx
			fm_cal_cata_nok_cge.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_clu_cnt.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_clu_cnt.Cxx_dtc_hmb_xxx
			fm_cal_clu_cnt_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_clu_cnt_nok.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_crk.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_crk.Cxx_dtc_hmb_xxx
			fm_cal_crk_chr.Cxx_dtc_obd_xxx
			fm_cal_crk_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_crk_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_crk_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_crk_chr.Cxx_dtc_lb_xxx
			fm_cal_crk_chr.Cxx_obd_dc_xxx
			fm_cal_crk_cmp.Cxx_dtc_obd_xxx
			fm_cal_crk_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_crk_cmp.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_crk_cmp.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_crk_cmp.Cxx_dtc_lb_xxx
			fm_cal_crk_cmp.Cxx_obd_dc_xxx
			fm_cal_crk_cyc.Cxx_dtc_obd_xxx
			fm_cal_crk_cyc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_crk_cyc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_crk_cyc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_crk_cyc.Cxx_dtc_lb_xxx
			fm_cal_crk_cyc.Cxx_obd_dc_xxx
			fm_cal_crk_no_sig.Cxx_dtc_obd_xxx
			fm_cal_crk_no_sig.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_crk_no_sig.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_crk_no_sig.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_crk_no_sig.Cxx_dtc_lb_xxx
			fm_cal_crk_no_sig.Cxx_obd_dc_xxx
			fm_cal_crk_oc.Cxx_dtc_obd_xxx
			fm_cal_crk_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_crk_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_crk_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_crk_oc.Cxx_dtc_lb_xxx
			fm_cal_crk_oc.Cxx_obd_dc_xxx
			fm_cal_crk_shp.Cxx_dtc_obd_xxx
			fm_cal_crk_shp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_crk_shp.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_crk_shp.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_crk_shp.Cxx_dtc_lb_xxx
			fm_cal_crk_shp.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_cru.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_cru.Cxx_dtc_hmb_xxx
			fm_cal_cru_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cru_cmp.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_cru_sl_swi.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_cru_sl_swi.Cxx_dtc_hmb_xxx
			fm_cal_cru_sl_swi_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cru_sl_swi_chr.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_cru_sl.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_cru_sl.Cxx_dtc_hmb_xxx
			fm_cal_cru_sl_tot.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cru_sl_tot.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_cru_vs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_cru_vs.Cxx_dtc_hmb_xxx
			fm_cal_cru_vs_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cru_vs_cmp.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_cru_whl_cmd.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_cru_whl_cmd.Cxx_dtc_hmb_xxx
			fm_cal_cru_whl_cmd_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cru_whl_cmd_nok.Cxx_dtc_lb_xxx
			fm_cal_cru_whl_cmd_oc_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cru_whl_cmd_oc_scw.Cxx_dtc_lb_xxx
			fm_cal_cru_whl_cmd_oor.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_cru_whl_cmd_oor.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_doc1_utp.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_doc1_utp.Cxx_dtc_hmb_xxx
			fm_cal_doc1_utp_chr.Cxx_dtc_obd_xxx
			fm_cal_doc1_utp_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_doc1_utp_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_doc1_utp_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_doc1_utp_chr.Cxx_dtc_lb_xxx
			fm_cal_doc1_utp_chr.Cxx_obd_dc_xxx
			fm_cal_doc1_utp_h.Cxx_dtc_obd_xxx
			fm_cal_doc1_utp_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_doc1_utp_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_doc1_utp_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_doc1_utp_h.Cxx_dtc_lb_xxx
			fm_cal_doc1_utp_h.Cxx_obd_dc_xxx
			fm_cal_doc1_utp_l.Cxx_dtc_obd_xxx
			fm_cal_doc1_utp_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_doc1_utp_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_doc1_utp_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_doc1_utp_l.Cxx_dtc_lb_xxx
			fm_cal_doc1_utp_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ecm_err.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ecm_err.Cxx_dtc_hmb_xxx
			fm_cal_ecm_err_itl.Cxx_dtc_obd_xxx
			fm_cal_ecm_err_itl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ecm_err_itl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ecm_err_itl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ecm_err_itl.Cxx_dtc_lb_xxx
			fm_cal_ecm_err_itl.Cxx_obd_dc_xxx
			fm_cal_ecm_err_no_norm.Cxx_dtc_obd_xxx
			fm_cal_ecm_err_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ecm_err_no_norm.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ecm_err_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ecm_err_no_norm.Cxx_dtc_lb_xxx
			fm_cal_ecm_err_no_norm.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ecm_inj.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ecm_inj.Cxx_dtc_hmb_xxx
			fm_cal_ecm_inj_bus_mcut.Cxx_dtc_obd_xxx
			fm_cal_ecm_inj_bus_mcut.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ecm_inj_bus_mcut.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ecm_inj_bus_mcut.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ecm_inj_bus_mcut.Cxx_dtc_lb_xxx
			fm_cal_ecm_inj_bus_mcut.Cxx_obd_dc_xxx
			fm_cal_ecm_inj_cpt_blk.Cxx_dtc_obd_xxx
			fm_cal_ecm_inj_cpt_blk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ecm_inj_cpt_blk.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ecm_inj_cpt_blk.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ecm_inj_cpt_blk.Cxx_dtc_lb_xxx
			fm_cal_ecm_inj_cpt_blk.Cxx_obd_dc_xxx
			fm_cal_ecm_inj_no_norm.Cxx_dtc_obd_xxx
			fm_cal_ecm_inj_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ecm_inj_no_norm.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ecm_inj_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ecm_inj_no_norm.Cxx_dtc_lb_xxx
			fm_cal_ecm_inj_no_norm.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ecm_mon.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ecm_mon.Cxx_dtc_hmb_xxx
			fm_cal_ecm_mon_secu_1.Cxx_dtc_obd_xxx
			fm_cal_ecm_mon_secu_1.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ecm_mon_secu_1.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ecm_mon_secu_1.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ecm_mon_secu_1.Cxx_dtc_lb_xxx
			fm_cal_ecm_mon_secu_1.Cxx_obd_dc_xxx
			fm_cal_ecm_mon_secu_2.Cxx_dtc_obd_xxx
			fm_cal_ecm_mon_secu_2.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ecm_mon_secu_2.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ecm_mon_secu_2.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ecm_mon_secu_2.Cxx_dtc_lb_xxx
			fm_cal_ecm_mon_secu_2.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_efi_inj.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_efi_inj.Cxx_dtc_hmb_xxx
			fm_cal_efi_inj_oc.Cxx_dtc_obd_xxx
			fm_cal_efi_inj_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_efi_inj_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_efi_inj_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_efi_inj_oc.Cxx_dtc_lb_xxx
			fm_cal_efi_inj_oc.Cxx_obd_dc_xxx
			fm_cal_efi_inj_scg.Cxx_dtc_obd_xxx
			fm_cal_efi_inj_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_efi_inj_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_efi_inj_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_efi_inj_scg.Cxx_dtc_lb_xxx
			fm_cal_efi_inj_scg.Cxx_obd_dc_xxx
			fm_cal_efi_inj_scw.Cxx_dtc_obd_xxx
			fm_cal_efi_inj_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_efi_inj_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_efi_inj_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_efi_inj_scw.Cxx_dtc_lb_xxx
			fm_cal_efi_inj_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_efi_sldv.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_efi_sldv.Cxx_dtc_hmb_xxx
			fm_cal_efi_sldv_oc.Cxx_dtc_obd_xxx
			fm_cal_efi_sldv_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_efi_sldv_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_efi_sldv_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_efi_sldv_oc.Cxx_dtc_lb_xxx
			fm_cal_efi_sldv_oc.Cxx_obd_dc_xxx
			fm_cal_efi_sldv_scg.Cxx_dtc_obd_xxx
			fm_cal_efi_sldv_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_efi_sldv_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_efi_sldv_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_efi_sldv_scg.Cxx_dtc_lb_xxx
			fm_cal_efi_sldv_scg.Cxx_obd_dc_xxx
			fm_cal_efi_sldv_scw.Cxx_dtc_obd_xxx
			fm_cal_efi_sldv_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_efi_sldv_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_efi_sldv_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_efi_sldv_scw.Cxx_dtc_lb_xxx
			fm_cal_efi_sldv_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_egr_byp.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_egr_byp.Cxx_dtc_hmb_xxx
			fm_cal_egr_byp_blk.Cxx_dtc_obd_xxx
			fm_cal_egr_byp_blk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_egr_byp_blk.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_egr_byp_blk.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_egr_byp_blk.Cxx_dtc_lb_xxx
			fm_cal_egr_byp_blk.Cxx_obd_dc_xxx
			fm_cal_egr_byp_h.Cxx_dtc_obd_xxx
			fm_cal_egr_byp_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_egr_byp_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_egr_byp_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_egr_byp_h.Cxx_dtc_lb_xxx
			fm_cal_egr_byp_h.Cxx_obd_dc_xxx
			fm_cal_egr_byp_l.Cxx_dtc_obd_xxx
			fm_cal_egr_byp_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_egr_byp_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_egr_byp_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_egr_byp_l.Cxx_dtc_lb_xxx
			fm_cal_egr_byp_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_emtv_flow.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_emtv_flow.Cxx_dtc_hmb_xxx
			fm_cal_emtv_flow_meca.Cxx_dtc_obd_xxx
			fm_cal_emtv_flow_meca.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_emtv_flow_meca.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_emtv_flow_meca.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_emtv_flow_meca.Cxx_dtc_lb_xxx
			fm_cal_emtv_flow_meca.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_emtv_hbdg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_emtv_hbdg.Cxx_dtc_hmb_xxx
			fm_cal_emtv_hbdg_el.Cxx_dtc_obd_xxx
			fm_cal_emtv_hbdg_el.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_emtv_hbdg_el.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_emtv_hbdg_el.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_emtv_hbdg_el.Cxx_dtc_lb_xxx
			fm_cal_emtv_hbdg_el.Cxx_obd_dc_xxx
			fm_cal_emtv_hbdg_ovh.Cxx_dtc_obd_xxx
			fm_cal_emtv_hbdg_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_emtv_hbdg_ovh.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_emtv_hbdg_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_emtv_hbdg_ovh.Cxx_dtc_lb_xxx
			fm_cal_emtv_hbdg_ovh.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_emtv_ofs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_emtv_ofs.Cxx_dtc_hmb_xxx
			fm_cal_emtv_ofs_no_norm.Cxx_dtc_obd_xxx
			fm_cal_emtv_ofs_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_emtv_ofs_no_norm.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_emtv_ofs_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_emtv_ofs_no_norm.Cxx_dtc_lb_xxx
			fm_cal_emtv_ofs_no_norm.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_emtv_reg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_emtv_reg.Cxx_dtc_hmb_xxx
			fm_cal_emtv_reg_blk.Cxx_dtc_obd_xxx
			fm_cal_emtv_reg_blk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_emtv_reg_blk.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_emtv_reg_blk.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_emtv_reg_blk.Cxx_dtc_lb_xxx
			fm_cal_emtv_reg_blk.Cxx_obd_dc_xxx
			fm_cal_emtv_reg_blk_open.Cxx_dtc_obd_xxx
			fm_cal_emtv_reg_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_emtv_reg_blk_open.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_emtv_reg_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_emtv_reg_blk_open.Cxx_dtc_lb_xxx
			fm_cal_emtv_reg_blk_open.Cxx_obd_dc_xxx
			fm_cal_emtv_reg_dirt.Cxx_dtc_obd_xxx
			fm_cal_emtv_reg_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_emtv_reg_dirt.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_emtv_reg_dirt.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_emtv_reg_dirt.Cxx_dtc_lb_xxx
			fm_cal_emtv_reg_dirt.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_esp_data.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_esp_data.Cxx_dtc_hmb_xxx
			fm_cal_esp_data_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_esp_data_chr.Cxx_dtc_lb_xxx
			fm_cal_esp_data_seq_ctr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_esp_data_seq_ctr.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_esp.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_esp.Cxx_dtc_hmb_xxx
			fm_cal_esp_no_frm.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_esp_no_frm.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ex_prs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ex_prs.Cxx_dtc_hmb_xxx
			fm_cal_ex_prs_no_lk.Cxx_dtc_obd_xxx
			fm_cal_ex_prs_no_lk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ex_prs_no_lk.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ex_prs_no_lk.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ex_prs_no_lk.Cxx_dtc_lb_xxx
			fm_cal_ex_prs_no_lk.Cxx_obd_dc_xxx
			fm_cal_ex_prs_nok.Cxx_dtc_obd_xxx
			fm_cal_ex_prs_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ex_prs_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ex_prs_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ex_prs_nok.Cxx_dtc_lb_xxx
			fm_cal_ex_prs_nok.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ff_actr.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ff_actr.Cxx_dtc_hmb_xxx
			fm_cal_ff_actr_blk_clos.Cxx_dtc_obd_xxx
			fm_cal_ff_actr_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_actr_blk_clos.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_actr_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_actr_blk_clos.Cxx_dtc_lb_xxx
			fm_cal_ff_actr_blk_clos.Cxx_obd_dc_xxx
			fm_cal_ff_actr_blk_open.Cxx_dtc_obd_xxx
			fm_cal_ff_actr_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_actr_blk_open.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_actr_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_actr_blk_open.Cxx_dtc_lb_xxx
			fm_cal_ff_actr_blk_open.Cxx_obd_dc_xxx
			fm_cal_ff_actr_crt_down.Cxx_dtc_obd_xxx
			fm_cal_ff_actr_crt_down.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_actr_crt_down.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_actr_crt_down.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_actr_crt_down.Cxx_dtc_lb_xxx
			fm_cal_ff_actr_crt_down.Cxx_obd_dc_xxx
			fm_cal_ff_actr_crt_up.Cxx_dtc_obd_xxx
			fm_cal_ff_actr_crt_up.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_actr_crt_up.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_actr_crt_up.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_actr_crt_up.Cxx_dtc_lb_xxx
			fm_cal_ff_actr_crt_up.Cxx_obd_dc_xxx
			fm_cal_ff_actr_ovh.Cxx_dtc_obd_xxx
			fm_cal_ff_actr_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_actr_ovh.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_actr_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_actr_ovh.Cxx_dtc_lb_xxx
			fm_cal_ff_actr_ovh.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ff_fct.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ff_fct.Cxx_dtc_hmb_xxx
			fm_cal_ff_fct_chr.Cxx_dtc_obd_xxx
			fm_cal_ff_fct_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_fct_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_fct_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_fct_chr.Cxx_dtc_lb_xxx
			fm_cal_ff_fct_chr.Cxx_obd_dc_xxx
			fm_cal_ff_fct_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_ff_fct_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_fct_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_fct_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_fct_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_ff_fct_h_lvl.Cxx_obd_dc_xxx
			fm_cal_ff_fct_l_lvl.Cxx_dtc_obd_xxx
			fm_cal_ff_fct_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_fct_l_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_fct_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_fct_l_lvl.Cxx_dtc_lb_xxx
			fm_cal_ff_fct_l_lvl.Cxx_obd_dc_xxx
			fm_cal_ff_fct_neg_err.Cxx_dtc_obd_xxx
			fm_cal_ff_fct_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_fct_neg_err.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_fct_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_fct_neg_err.Cxx_dtc_lb_xxx
			fm_cal_ff_fct_neg_err.Cxx_obd_dc_xxx
			fm_cal_ff_fct_pos_err.Cxx_dtc_obd_xxx
			fm_cal_ff_fct_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ff_fct_pos_err.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ff_fct_pos_err.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ff_fct_pos_err.Cxx_dtc_lb_xxx
			fm_cal_ff_fct_pos_err.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_fprs_actr.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_fprs_actr.Cxx_dtc_hmb_xxx
			fm_cal_fprs_actr_blk_clos.Cxx_dtc_obd_xxx
			fm_cal_fprs_actr_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_actr_blk_clos.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_actr_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_actr_blk_clos.Cxx_dtc_lb_xxx
			fm_cal_fprs_actr_blk_clos.Cxx_obd_dc_xxx
			fm_cal_fprs_actr_blk_open.Cxx_dtc_obd_xxx
			fm_cal_fprs_actr_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_actr_blk_open.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_actr_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_actr_blk_open.Cxx_dtc_lb_xxx
			fm_cal_fprs_actr_blk_open.Cxx_obd_dc_xxx
			fm_cal_fprs_actr_crt_down.Cxx_dtc_obd_xxx
			fm_cal_fprs_actr_crt_down.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_actr_crt_down.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_actr_crt_down.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_actr_crt_down.Cxx_dtc_lb_xxx
			fm_cal_fprs_actr_crt_down.Cxx_obd_dc_xxx
			fm_cal_fprs_actr_crt_up.Cxx_dtc_obd_xxx
			fm_cal_fprs_actr_crt_up.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_actr_crt_up.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_actr_crt_up.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_actr_crt_up.Cxx_dtc_lb_xxx
			fm_cal_fprs_actr_crt_up.Cxx_obd_dc_xxx
			fm_cal_fprs_actr_ovh.Cxx_dtc_obd_xxx
			fm_cal_fprs_actr_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_actr_ovh.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_actr_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_actr_ovh.Cxx_dtc_lb_xxx
			fm_cal_fprs_actr_ovh.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_fprs_fct.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_fprs_fct.Cxx_dtc_hmb_xxx
			fm_cal_fprs_fct_chr.Cxx_dtc_obd_xxx
			fm_cal_fprs_fct_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_fct_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_fct_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_fct_chr.Cxx_dtc_lb_xxx
			fm_cal_fprs_fct_chr.Cxx_obd_dc_xxx
			fm_cal_fprs_fct_dirt_lkg.Cxx_dtc_obd_xxx
			fm_cal_fprs_fct_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_fct_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_fct_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_fct_dirt_lkg.Cxx_dtc_lb_xxx
			fm_cal_fprs_fct_dirt_lkg.Cxx_obd_dc_xxx
			fm_cal_fprs_fct_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_fprs_fct_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_fct_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_fct_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_fct_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_fprs_fct_h_lvl.Cxx_obd_dc_xxx
			fm_cal_fprs_fct_l_lvl.Cxx_dtc_obd_xxx
			fm_cal_fprs_fct_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_fct_l_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_fct_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_fct_l_lvl.Cxx_dtc_lb_xxx
			fm_cal_fprs_fct_l_lvl.Cxx_obd_dc_xxx
			fm_cal_fprs_fct_neg_err.Cxx_dtc_obd_xxx
			fm_cal_fprs_fct_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_fct_neg_err.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_fct_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_fct_neg_err.Cxx_dtc_lb_xxx
			fm_cal_fprs_fct_neg_err.Cxx_obd_dc_xxx
			fm_cal_fprs_fct_pos_err.Cxx_dtc_obd_xxx
			fm_cal_fprs_fct_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fprs_fct_pos_err.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fprs_fct_pos_err.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fprs_fct_pos_err.Cxx_dtc_lb_xxx
			fm_cal_fprs_fct_pos_err.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_fsys.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_fsys.Cxx_dtc_hmb_xxx
			fm_cal_fsys_apl_down.Cxx_dtc_obd_xxx
			fm_cal_fsys_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fsys_apl_down.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fsys_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fsys_apl_down.Cxx_dtc_lb_xxx
			fm_cal_fsys_apl_down.Cxx_obd_dc_xxx
			fm_cal_fsys_apl_up.Cxx_dtc_obd_xxx
			fm_cal_fsys_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fsys_apl_up.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fsys_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fsys_apl_up.Cxx_dtc_lb_xxx
			fm_cal_fsys_apl_up.Cxx_obd_dc_xxx
			fm_cal_fsys_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_fsys_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fsys_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fsys_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fsys_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_fsys_h_lvl.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_fuel_temp.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_fuel_temp.Cxx_dtc_hmb_xxx
			fm_cal_fuel_temp_h.Cxx_dtc_obd_xxx
			fm_cal_fuel_temp_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fuel_temp_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fuel_temp_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fuel_temp_h.Cxx_dtc_lb_xxx
			fm_cal_fuel_temp_h.Cxx_obd_dc_xxx
			fm_cal_fuel_temp_l.Cxx_dtc_obd_xxx
			fm_cal_fuel_temp_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_fuel_temp_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_fuel_temp_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_fuel_temp_l.Cxx_dtc_lb_xxx
			fm_cal_fuel_temp_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_glow_cmd.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_glow_cmd.Cxx_dtc_hmb_xxx
			fm_cal_glow_cmd_fail.Cxx_dtc_obd_xxx
			fm_cal_glow_cmd_fail.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_glow_cmd_fail.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_glow_cmd_fail.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_glow_cmd_fail.Cxx_dtc_lb_xxx
			fm_cal_glow_cmd_fail.Cxx_obd_dc_xxx
			fm_cal_glow_cmd_oc.Cxx_dtc_obd_xxx
			fm_cal_glow_cmd_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_glow_cmd_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_glow_cmd_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_glow_cmd_oc.Cxx_dtc_lb_xxx
			fm_cal_glow_cmd_oc.Cxx_obd_dc_xxx
			fm_cal_glow_cmd_scg.Cxx_dtc_obd_xxx
			fm_cal_glow_cmd_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_glow_cmd_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_glow_cmd_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_glow_cmd_scg.Cxx_dtc_lb_xxx
			fm_cal_glow_cmd_scg.Cxx_obd_dc_xxx
			fm_cal_glow_cmd_scw.Cxx_dtc_obd_xxx
			fm_cal_glow_cmd_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_glow_cmd_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_glow_cmd_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_glow_cmd_scw.Cxx_dtc_lb_xxx
			fm_cal_glow_cmd_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_in_cam.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_in_cam.Cxx_dtc_hmb_xxx
			fm_cal_in_cam_chr.Cxx_dtc_obd_xxx
			fm_cal_in_cam_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_in_cam_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_in_cam_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_in_cam_chr.Cxx_dtc_lb_xxx
			fm_cal_in_cam_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_in_cam_crk.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_in_cam_crk.Cxx_dtc_hmb_xxx
			fm_cal_in_cam_crk_cmp.Cxx_dtc_obd_xxx
			fm_cal_in_cam_crk_cmp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_in_cam_crk_cmp.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_in_cam_crk_cmp.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_in_cam_crk_cmp.Cxx_dtc_lb_xxx
			fm_cal_in_cam_crk_cmp.Cxx_obd_dc_xxx
			fm_cal_in_cam_cyc.Cxx_dtc_obd_xxx
			fm_cal_in_cam_cyc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_in_cam_cyc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_in_cam_cyc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_in_cam_cyc.Cxx_dtc_lb_xxx
			fm_cal_in_cam_cyc.Cxx_obd_dc_xxx
			fm_cal_in_cam_no_sig.Cxx_dtc_obd_xxx
			fm_cal_in_cam_no_sig.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_in_cam_no_sig.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_in_cam_no_sig.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_in_cam_no_sig.Cxx_dtc_lb_xxx
			fm_cal_in_cam_no_sig.Cxx_obd_dc_xxx
			fm_cal_in_cam_nok.Cxx_dtc_obd_xxx
			fm_cal_in_cam_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_in_cam_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_in_cam_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_in_cam_nok.Cxx_dtc_lb_xxx
			fm_cal_in_cam_nok.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_inj1.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_inj1.Cxx_dtc_hmb_xxx
			fm_cal_inj1_chk_sum.Cxx_dtc_obd_xxx
			fm_cal_inj1_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_chk_sum.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_chk_sum.Cxx_dtc_lb_xxx
			fm_cal_inj1_chk_sum.Cxx_obd_dc_xxx
			fm_cal_inj1_crt_intv.Cxx_dtc_obd_xxx
			fm_cal_inj1_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_crt_intv.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_crt_intv.Cxx_dtc_lb_xxx
			fm_cal_inj1_crt_intv.Cxx_obd_dc_xxx
			fm_cal_inj1_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj1_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj1_h_lvl.Cxx_obd_dc_xxx
			fm_cal_inj1_h_puls.Cxx_dtc_obd_xxx
			fm_cal_inj1_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_h_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_h_puls.Cxx_dtc_lb_xxx
			fm_cal_inj1_h_puls.Cxx_obd_dc_xxx
			fm_cal_inj1_l_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj1_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_l_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_l_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj1_l_lvl.Cxx_obd_dc_xxx
			fm_cal_inj1_l_puls.Cxx_dtc_obd_xxx
			fm_cal_inj1_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_l_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_l_puls.Cxx_dtc_lb_xxx
			fm_cal_inj1_l_puls.Cxx_obd_dc_xxx
			fm_cal_inj1_nok.Cxx_dtc_obd_xxx
			fm_cal_inj1_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_nok.Cxx_dtc_lb_xxx
			fm_cal_inj1_nok.Cxx_obd_dc_xxx
			fm_cal_inj1_oc.Cxx_dtc_obd_xxx
			fm_cal_inj1_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_oc.Cxx_dtc_lb_xxx
			fm_cal_inj1_oc.Cxx_obd_dc_xxx
			fm_cal_inj1_shp.Cxx_dtc_obd_xxx
			fm_cal_inj1_shp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj1_shp.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj1_shp.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj1_shp.Cxx_dtc_lb_xxx
			fm_cal_inj1_shp.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_inj2.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_inj2.Cxx_dtc_hmb_xxx
			fm_cal_inj2_chk_sum.Cxx_dtc_obd_xxx
			fm_cal_inj2_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_chk_sum.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_chk_sum.Cxx_dtc_lb_xxx
			fm_cal_inj2_chk_sum.Cxx_obd_dc_xxx
			fm_cal_inj2_crt_intv.Cxx_dtc_obd_xxx
			fm_cal_inj2_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_crt_intv.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_crt_intv.Cxx_dtc_lb_xxx
			fm_cal_inj2_crt_intv.Cxx_obd_dc_xxx
			fm_cal_inj2_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj2_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj2_h_lvl.Cxx_obd_dc_xxx
			fm_cal_inj2_h_puls.Cxx_dtc_obd_xxx
			fm_cal_inj2_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_h_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_h_puls.Cxx_dtc_lb_xxx
			fm_cal_inj2_h_puls.Cxx_obd_dc_xxx
			fm_cal_inj2_l_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj2_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_l_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_l_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj2_l_lvl.Cxx_obd_dc_xxx
			fm_cal_inj2_l_puls.Cxx_dtc_obd_xxx
			fm_cal_inj2_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_l_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_l_puls.Cxx_dtc_lb_xxx
			fm_cal_inj2_l_puls.Cxx_obd_dc_xxx
			fm_cal_inj2_nok.Cxx_dtc_obd_xxx
			fm_cal_inj2_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_nok.Cxx_dtc_lb_xxx
			fm_cal_inj2_nok.Cxx_obd_dc_xxx
			fm_cal_inj2_oc.Cxx_dtc_obd_xxx
			fm_cal_inj2_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_oc.Cxx_dtc_lb_xxx
			fm_cal_inj2_oc.Cxx_obd_dc_xxx
			fm_cal_inj2_shp.Cxx_dtc_obd_xxx
			fm_cal_inj2_shp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj2_shp.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj2_shp.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj2_shp.Cxx_dtc_lb_xxx
			fm_cal_inj2_shp.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_inj3.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_inj3.Cxx_dtc_hmb_xxx
			fm_cal_inj3_chk_sum.Cxx_dtc_obd_xxx
			fm_cal_inj3_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_chk_sum.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_chk_sum.Cxx_dtc_lb_xxx
			fm_cal_inj3_chk_sum.Cxx_obd_dc_xxx
			fm_cal_inj3_crt_intv.Cxx_dtc_obd_xxx
			fm_cal_inj3_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_crt_intv.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_crt_intv.Cxx_dtc_lb_xxx
			fm_cal_inj3_crt_intv.Cxx_obd_dc_xxx
			fm_cal_inj3_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj3_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj3_h_lvl.Cxx_obd_dc_xxx
			fm_cal_inj3_h_puls.Cxx_dtc_obd_xxx
			fm_cal_inj3_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_h_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_h_puls.Cxx_dtc_lb_xxx
			fm_cal_inj3_h_puls.Cxx_obd_dc_xxx
			fm_cal_inj3_l_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj3_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_l_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_l_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj3_l_lvl.Cxx_obd_dc_xxx
			fm_cal_inj3_l_puls.Cxx_dtc_obd_xxx
			fm_cal_inj3_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_l_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_l_puls.Cxx_dtc_lb_xxx
			fm_cal_inj3_l_puls.Cxx_obd_dc_xxx
			fm_cal_inj3_nok.Cxx_dtc_obd_xxx
			fm_cal_inj3_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_nok.Cxx_dtc_lb_xxx
			fm_cal_inj3_nok.Cxx_obd_dc_xxx
			fm_cal_inj3_oc.Cxx_dtc_obd_xxx
			fm_cal_inj3_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_oc.Cxx_dtc_lb_xxx
			fm_cal_inj3_oc.Cxx_obd_dc_xxx
			fm_cal_inj3_shp.Cxx_dtc_obd_xxx
			fm_cal_inj3_shp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj3_shp.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj3_shp.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj3_shp.Cxx_dtc_lb_xxx
			fm_cal_inj3_shp.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_inj4.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_inj4.Cxx_dtc_hmb_xxx
			fm_cal_inj4_chk_sum.Cxx_dtc_obd_xxx
			fm_cal_inj4_chk_sum.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_chk_sum.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_chk_sum.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_chk_sum.Cxx_dtc_lb_xxx
			fm_cal_inj4_chk_sum.Cxx_obd_dc_xxx
			fm_cal_inj4_crt_intv.Cxx_dtc_obd_xxx
			fm_cal_inj4_crt_intv.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_crt_intv.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_crt_intv.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_crt_intv.Cxx_dtc_lb_xxx
			fm_cal_inj4_crt_intv.Cxx_obd_dc_xxx
			fm_cal_inj4_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj4_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj4_h_lvl.Cxx_obd_dc_xxx
			fm_cal_inj4_h_puls.Cxx_dtc_obd_xxx
			fm_cal_inj4_h_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_h_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_h_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_h_puls.Cxx_dtc_lb_xxx
			fm_cal_inj4_h_puls.Cxx_obd_dc_xxx
			fm_cal_inj4_l_lvl.Cxx_dtc_obd_xxx
			fm_cal_inj4_l_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_l_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_l_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_l_lvl.Cxx_dtc_lb_xxx
			fm_cal_inj4_l_lvl.Cxx_obd_dc_xxx
			fm_cal_inj4_l_puls.Cxx_dtc_obd_xxx
			fm_cal_inj4_l_puls.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_l_puls.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_l_puls.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_l_puls.Cxx_dtc_lb_xxx
			fm_cal_inj4_l_puls.Cxx_obd_dc_xxx
			fm_cal_inj4_nok.Cxx_dtc_obd_xxx
			fm_cal_inj4_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_nok.Cxx_dtc_lb_xxx
			fm_cal_inj4_nok.Cxx_obd_dc_xxx
			fm_cal_inj4_oc.Cxx_dtc_obd_xxx
			fm_cal_inj4_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_oc.Cxx_dtc_lb_xxx
			fm_cal_inj4_oc.Cxx_obd_dc_xxx
			fm_cal_inj4_shp.Cxx_dtc_obd_xxx
			fm_cal_inj4_shp.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj4_shp.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj4_shp.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj4_shp.Cxx_dtc_lb_xxx
			fm_cal_inj4_shp.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_inj.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_inj.Cxx_dtc_hmb_xxx
			fm_cal_inj_cpt_blk.Cxx_dtc_obd_xxx
			fm_cal_inj_cpt_blk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj_cpt_blk.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj_cpt_blk.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj_cpt_blk.Cxx_dtc_lb_xxx
			fm_cal_inj_cpt_blk.Cxx_obd_dc_xxx
			fm_cal_inj_oor.Cxx_dtc_obd_xxx
			fm_cal_inj_oor.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_inj_oor.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_inj_oor.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_inj_oor.Cxx_dtc_lb_xxx
			fm_cal_inj_oor.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ip_lght_tco.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ip_lght_tco.Cxx_dtc_hmb_xxx
			fm_cal_ip_lght_tco_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ip_lght_tco_ovh.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_it_hbdg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_it_hbdg.Cxx_dtc_hmb_xxx
			fm_cal_it_hbdg_el.Cxx_dtc_obd_xxx
			fm_cal_it_hbdg_el.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_it_hbdg_el.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_it_hbdg_el.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_it_hbdg_el.Cxx_dtc_lb_xxx
			fm_cal_it_hbdg_el.Cxx_obd_dc_xxx
			fm_cal_it_hbdg_ovh.Cxx_dtc_obd_xxx
			fm_cal_it_hbdg_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_it_hbdg_ovh.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_it_hbdg_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_it_hbdg_ovh.Cxx_dtc_lb_xxx
			fm_cal_it_hbdg_ovh.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_it_ofs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_it_ofs.Cxx_dtc_hmb_xxx
			fm_cal_it_ofs_no_norm.Cxx_dtc_obd_xxx
			fm_cal_it_ofs_no_norm.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_it_ofs_no_norm.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_it_ofs_no_norm.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_it_ofs_no_norm.Cxx_dtc_lb_xxx
			fm_cal_it_ofs_no_norm.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_it_reg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_it_reg.Cxx_dtc_hmb_xxx
			fm_cal_it_reg_blk.Cxx_dtc_obd_xxx
			fm_cal_it_reg_blk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_it_reg_blk.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_it_reg_blk.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_it_reg_blk.Cxx_dtc_lb_xxx
			fm_cal_it_reg_blk.Cxx_obd_dc_xxx
			fm_cal_it_reg_blk_clos.Cxx_dtc_obd_xxx
			fm_cal_it_reg_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_it_reg_blk_clos.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_it_reg_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_it_reg_blk_clos.Cxx_dtc_lb_xxx
			fm_cal_it_reg_blk_clos.Cxx_obd_dc_xxx
			fm_cal_it_reg_blk_open.Cxx_dtc_obd_xxx
			fm_cal_it_reg_blk_open.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_it_reg_blk_open.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_it_reg_blk_open.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_it_reg_blk_open.Cxx_dtc_lb_xxx
			fm_cal_it_reg_blk_open.Cxx_obd_dc_xxx
			fm_cal_it_reg_dirt.Cxx_dtc_obd_xxx
			fm_cal_it_reg_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_it_reg_dirt.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_it_reg_dirt.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_it_reg_dirt.Cxx_dtc_lb_xxx
			fm_cal_it_reg_dirt.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_maf_reg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_maf_reg.Cxx_dtc_hmb_xxx
			fm_cal_maf_reg_neg_err.Cxx_dtc_obd_xxx
			fm_cal_maf_reg_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_maf_reg_neg_err.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_maf_reg_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_maf_reg_neg_err.Cxx_dtc_lb_xxx
			fm_cal_maf_reg_neg_err.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_mafs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_mafs.Cxx_dtc_hmb_xxx
			fm_cal_mafs_apl_down.Cxx_dtc_obd_xxx
			fm_cal_mafs_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_mafs_apl_down.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_mafs_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_mafs_apl_down.Cxx_dtc_lb_xxx
			fm_cal_mafs_apl_down.Cxx_obd_dc_xxx
			fm_cal_mafs_apl_up.Cxx_dtc_obd_xxx
			fm_cal_mafs_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_mafs_apl_up.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_mafs_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_mafs_apl_up.Cxx_dtc_lb_xxx
			fm_cal_mafs_apl_up.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_map.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_map.Cxx_dtc_hmb_xxx
			fm_cal_map_nok.Cxx_dtc_obd_xxx
			fm_cal_map_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_map_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_map_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_map_nok.Cxx_dtc_lb_xxx
			fm_cal_map_nok.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_oil_dil.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_oil_dil.Cxx_dtc_hmb_xxx
			fm_cal_oil_dil_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_oil_dil_nok.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_pft.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_pft.Cxx_dtc_hmb_xxx
			fm_cal_pft_dirt.Cxx_dtc_obd_xxx
			fm_cal_pft_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_dirt.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pft_dirt.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pft_dirt.Cxx_dtc_lb_xxx
			fm_cal_pft_dirt.Cxx_obd_dc_xxx
			fm_cal_pft_dirt_lkg.Cxx_dtc_obd_xxx
			fm_cal_pft_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pft_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pft_dirt_lkg.Cxx_dtc_lb_xxx
			fm_cal_pft_dirt_lkg.Cxx_obd_dc_xxx
			fm_cal_pft_no_lk.Cxx_dtc_obd_xxx
			fm_cal_pft_no_lk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_no_lk.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pft_no_lk.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pft_no_lk.Cxx_dtc_lb_xxx
			fm_cal_pft_no_lk.Cxx_obd_dc_xxx
			fm_cal_pft_nok_cge.Cxx_dtc_obd_xxx
			fm_cal_pft_nok_cge.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_nok_cge.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pft_nok_cge.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pft_nok_cge.Cxx_dtc_lb_xxx
			fm_cal_pft_nok_cge.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_pft_rgn.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_pft_rgn.Cxx_dtc_hmb_xxx
			fm_cal_pft_rgn_dirt.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_rgn_dirt.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_pft_utp.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_pft_utp.Cxx_dtc_hmb_xxx
			fm_cal_pft_utp_chr.Cxx_dtc_obd_xxx
			fm_cal_pft_utp_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_utp_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pft_utp_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pft_utp_chr.Cxx_dtc_lb_xxx
			fm_cal_pft_utp_chr.Cxx_obd_dc_xxx
			fm_cal_pft_utp_h.Cxx_dtc_obd_xxx
			fm_cal_pft_utp_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_utp_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pft_utp_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pft_utp_h.Cxx_dtc_lb_xxx
			fm_cal_pft_utp_h.Cxx_obd_dc_xxx
			fm_cal_pft_utp_l.Cxx_dtc_obd_xxx
			fm_cal_pft_utp_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_utp_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pft_utp_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pft_utp_l.Cxx_dtc_lb_xxx
			fm_cal_pft_utp_l.Cxx_obd_dc_xxx
			fm_cal_pft_utp_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_utp_neg_err.Cxx_dtc_lb_xxx
			fm_cal_pft_utp_pos_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pft_utp_pos_err.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_pws_1.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_pws_1.Cxx_dtc_hmb_xxx
			fm_cal_pws_1_h.Cxx_dtc_obd_xxx
			fm_cal_pws_1_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pws_1_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pws_1_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pws_1_h.Cxx_dtc_lb_xxx
			fm_cal_pws_1_h.Cxx_obd_dc_xxx
			fm_cal_pws_1_l.Cxx_dtc_obd_xxx
			fm_cal_pws_1_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pws_1_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pws_1_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pws_1_l.Cxx_dtc_lb_xxx
			fm_cal_pws_1_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_pws_2.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_pws_2.Cxx_dtc_hmb_xxx
			fm_cal_pws_2_h.Cxx_dtc_obd_xxx
			fm_cal_pws_2_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pws_2_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pws_2_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pws_2_h.Cxx_dtc_lb_xxx
			fm_cal_pws_2_h.Cxx_obd_dc_xxx
			fm_cal_pws_2_l.Cxx_dtc_obd_xxx
			fm_cal_pws_2_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pws_2_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pws_2_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pws_2_l.Cxx_dtc_lb_xxx
			fm_cal_pws_2_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_pws_3.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_pws_3.Cxx_dtc_hmb_xxx
			fm_cal_pws_3_h.Cxx_dtc_obd_xxx
			fm_cal_pws_3_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pws_3_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pws_3_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pws_3_h.Cxx_dtc_lb_xxx
			fm_cal_pws_3_h.Cxx_obd_dc_xxx
			fm_cal_pws_3_l.Cxx_dtc_obd_xxx
			fm_cal_pws_3_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_pws_3_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_pws_3_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_pws_3_l.Cxx_dtc_lb_xxx
			fm_cal_pws_3_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_rail_prs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_rail_prs.Cxx_dtc_hmb_xxx
			fm_cal_rail_prs_h.Cxx_dtc_obd_xxx
			fm_cal_rail_prs_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_rail_prs_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_rail_prs_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_rail_prs_h.Cxx_dtc_lb_xxx
			fm_cal_rail_prs_h.Cxx_obd_dc_xxx
			fm_cal_rail_prs_h_lvl.Cxx_dtc_obd_xxx
			fm_cal_rail_prs_h_lvl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_rail_prs_h_lvl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_rail_prs_h_lvl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_rail_prs_h_lvl.Cxx_dtc_lb_xxx
			fm_cal_rail_prs_h_lvl.Cxx_obd_dc_xxx
			fm_cal_rail_prs_l.Cxx_dtc_obd_xxx
			fm_cal_rail_prs_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_rail_prs_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_rail_prs_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_rail_prs_l.Cxx_dtc_lb_xxx
			fm_cal_rail_prs_l.Cxx_obd_dc_xxx
			fm_cal_rail_prs_plaus.Cxx_dtc_obd_xxx
			fm_cal_rail_prs_plaus.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_rail_prs_plaus.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_rail_prs_plaus.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_rail_prs_plaus.Cxx_dtc_lb_xxx
			fm_cal_rail_prs_plaus.Cxx_obd_dc_xxx
			fm_cal_rail_prs_sig_mcut.Cxx_dtc_obd_xxx
			fm_cal_rail_prs_sig_mcut.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_rail_prs_sig_mcut.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_rail_prs_sig_mcut.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_rail_prs_sig_mcut.Cxx_dtc_lb_xxx
			fm_cal_rail_prs_sig_mcut.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_rup.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_rup.Cxx_dtc_hmb_xxx
			fm_cal_rup_dirt_lkg.Cxx_dtc_obd_xxx
			fm_cal_rup_dirt_lkg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_rup_dirt_lkg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_rup_dirt_lkg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_rup_dirt_lkg.Cxx_dtc_lb_xxx
			fm_cal_rup_dirt_lkg.Cxx_obd_dc_xxx
			fm_cal_rup_nok.Cxx_dtc_obd_xxx
			fm_cal_rup_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_rup_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_rup_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_rup_nok.Cxx_dtc_lb_xxx
			fm_cal_rup_nok.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_amp.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_amp.Cxx_dtc_hmb_xxx
			fm_cal_sens_amp_h.Cxx_dtc_obd_xxx
			fm_cal_sens_amp_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_amp_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_amp_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_amp_h.Cxx_dtc_lb_xxx
			fm_cal_sens_amp_h.Cxx_obd_dc_xxx
			fm_cal_sens_amp_l.Cxx_dtc_obd_xxx
			fm_cal_sens_amp_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_amp_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_amp_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_amp_l.Cxx_dtc_lb_xxx
			fm_cal_sens_amp_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_egr_temp.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_egr_temp.Cxx_dtc_hmb_xxx
			fm_cal_sens_egr_temp_h.Cxx_dtc_obd_xxx
			fm_cal_sens_egr_temp_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_egr_temp_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_egr_temp_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_egr_temp_h.Cxx_dtc_lb_xxx
			fm_cal_sens_egr_temp_h.Cxx_obd_dc_xxx
			fm_cal_sens_egr_temp_l.Cxx_dtc_obd_xxx
			fm_cal_sens_egr_temp_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_egr_temp_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_egr_temp_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_egr_temp_l.Cxx_dtc_lb_xxx
			fm_cal_sens_egr_temp_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_emtv.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_emtv.Cxx_dtc_hmb_xxx
			fm_cal_sens_emtv_nok.Cxx_dtc_obd_xxx
			fm_cal_sens_emtv_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_emtv_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_emtv_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_emtv_nok.Cxx_dtc_lb_xxx
			fm_cal_sens_emtv_nok.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_ex_prs.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_ex_prs.Cxx_dtc_hmb_xxx
			fm_cal_sens_ex_prs_h.Cxx_dtc_obd_xxx
			fm_cal_sens_ex_prs_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ex_prs_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ex_prs_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ex_prs_h.Cxx_dtc_lb_xxx
			fm_cal_sens_ex_prs_h.Cxx_obd_dc_xxx
			fm_cal_sens_ex_prs_l.Cxx_dtc_obd_xxx
			fm_cal_sens_ex_prs_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ex_prs_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ex_prs_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ex_prs_l.Cxx_dtc_lb_xxx
			fm_cal_sens_ex_prs_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_it.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_it.Cxx_dtc_hmb_xxx
			fm_cal_sens_it_nok.Cxx_dtc_obd_xxx
			fm_cal_sens_it_nok.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_it_nok.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_it_nok.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_it_nok.Cxx_dtc_lb_xxx
			fm_cal_sens_it_nok.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_maf.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_maf.Cxx_dtc_hmb_xxx
			fm_cal_sens_maf_h.Cxx_dtc_obd_xxx
			fm_cal_sens_maf_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_maf_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_maf_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_maf_h.Cxx_dtc_lb_xxx
			fm_cal_sens_maf_h.Cxx_obd_dc_xxx
			fm_cal_sens_maf_l.Cxx_dtc_obd_xxx
			fm_cal_sens_maf_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_maf_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_maf_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_maf_l.Cxx_dtc_lb_xxx
			fm_cal_sens_maf_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_map.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_map.Cxx_dtc_hmb_xxx
			fm_cal_sens_map_h.Cxx_dtc_obd_xxx
			fm_cal_sens_map_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_map_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_map_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_map_h.Cxx_dtc_lb_xxx
			fm_cal_sens_map_h.Cxx_obd_dc_xxx
			fm_cal_sens_map_l.Cxx_dtc_obd_xxx
			fm_cal_sens_map_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_map_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_map_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_map_l.Cxx_dtc_lb_xxx
			fm_cal_sens_map_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_rup.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_rup.Cxx_dtc_hmb_xxx
			fm_cal_sens_rup_h.Cxx_dtc_obd_xxx
			fm_cal_sens_rup_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_rup_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_rup_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_rup_h.Cxx_dtc_lb_xxx
			fm_cal_sens_rup_h.Cxx_obd_dc_xxx
			fm_cal_sens_rup_l.Cxx_dtc_obd_xxx
			fm_cal_sens_rup_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_rup_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_rup_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_rup_l.Cxx_dtc_lb_xxx
			fm_cal_sens_rup_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_tco.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_tco.Cxx_dtc_hmb_xxx
			fm_cal_sens_tco_h.Cxx_dtc_obd_xxx
			fm_cal_sens_tco_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_tco_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_tco_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_tco_h.Cxx_dtc_lb_xxx
			fm_cal_sens_tco_h.Cxx_obd_dc_xxx
			fm_cal_sens_tco_l.Cxx_dtc_obd_xxx
			fm_cal_sens_tco_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_tco_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_tco_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_tco_l.Cxx_dtc_lb_xxx
			fm_cal_sens_tco_l.Cxx_obd_dc_xxx
			fm_cal_sens_tco_sig_mcut.Cxx_dtc_obd_xxx
			fm_cal_sens_tco_sig_mcut.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_tco_sig_mcut.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_tco_sig_mcut.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_tco_sig_mcut.Cxx_dtc_lb_xxx
			fm_cal_sens_tco_sig_mcut.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_tia.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_tia.Cxx_dtc_hmb_xxx
			fm_cal_sens_tia_h.Cxx_dtc_obd_xxx
			fm_cal_sens_tia_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_tia_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_tia_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_tia_h.Cxx_dtc_lb_xxx
			fm_cal_sens_tia_h.Cxx_obd_dc_xxx
			fm_cal_sens_tia_l.Cxx_dtc_obd_xxx
			fm_cal_sens_tia_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_tia_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_tia_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_tia_l.Cxx_dtc_lb_xxx
			fm_cal_sens_tia_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_ups_heat.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_ups_heat.Cxx_dtc_hmb_xxx
			fm_cal_sens_ups_heat_oc.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_heat_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_heat_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_heat_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_heat_oc.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_heat_oc.Cxx_obd_dc_xxx
			fm_cal_sens_ups_heat_ovh.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_heat_ovh.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_heat_ovh.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_heat_ovh.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_heat_ovh.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_heat_ovh.Cxx_obd_dc_xxx
			fm_cal_sens_ups_heat_scg.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_heat_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_heat_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_heat_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_heat_scg.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_heat_scg.Cxx_obd_dc_xxx
			fm_cal_sens_ups_heat_scw.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_heat_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_heat_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_heat_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_heat_scw.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_heat_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_ups_lamb.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_ups_lamb.Cxx_dtc_hmb_xxx
			fm_cal_sens_ups_lamb_oc.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_lamb_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_lamb_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_lamb_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_lamb_oc.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_lamb_oc.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_ups_pump.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_ups_pump.Cxx_dtc_hmb_xxx
			fm_cal_sens_ups_pump_oc.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_pump_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_pump_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_pump_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_pump_oc.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_pump_oc.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_ups_virt.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_ups_virt.Cxx_dtc_hmb_xxx
			fm_cal_sens_ups_virt_oc.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_virt_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_virt_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_virt_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_virt_oc.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_virt_oc.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_ups_wire.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_ups_wire.Cxx_dtc_hmb_xxx
			fm_cal_sens_ups_wire_scg.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_wire_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_wire_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_wire_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_wire_scg.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_wire_scg.Cxx_obd_dc_xxx
			fm_cal_sens_ups_wire_scw.Cxx_dtc_obd_xxx
			fm_cal_sens_ups_wire_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_ups_wire_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_ups_wire_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_ups_wire_scw.Cxx_dtc_lb_xxx
			fm_cal_sens_ups_wire_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sens_wfl.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sens_wfl.Cxx_dtc_hmb_xxx
			fm_cal_sens_wfl_oc.Cxx_dtc_obd_xxx
			fm_cal_sens_wfl_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sens_wfl_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sens_wfl_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sens_wfl_oc.Cxx_dtc_lb_xxx
			fm_cal_sens_wfl_oc.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_sfty_tq.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_sfty_tq.Cxx_dtc_hmb_xxx
			fm_cal_sfty_tq_chr.Cxx_dtc_obd_xxx
			fm_cal_sfty_tq_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sfty_tq_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sfty_tq_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sfty_tq_chr.Cxx_dtc_lb_xxx
			fm_cal_sfty_tq_chr.Cxx_obd_dc_xxx
			fm_cal_sfty_tq_clc_chr.Cxx_dtc_obd_xxx
			fm_cal_sfty_tq_clc_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sfty_tq_clc_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sfty_tq_clc_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sfty_tq_clc_chr.Cxx_dtc_lb_xxx
			fm_cal_sfty_tq_clc_chr.Cxx_obd_dc_xxx
			fm_cal_sfty_tq_fail.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sfty_tq_fail.Cxx_dtc_lb_xxx
			fm_cal_sfty_tq_supl.Cxx_dtc_obd_xxx
			fm_cal_sfty_tq_supl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_sfty_tq_supl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_sfty_tq_supl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_sfty_tq_supl.Cxx_dtc_lb_xxx
			fm_cal_sfty_tq_supl.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_spg_cmd.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_spg_cmd.Cxx_dtc_hmb_xxx
			fm_cal_spg_cmd_blk_clos.Cxx_dtc_obd_xxx
			fm_cal_spg_cmd_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_spg_cmd_blk_clos.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_spg_cmd_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_spg_cmd_blk_clos.Cxx_dtc_lb_xxx
			fm_cal_spg_cmd_blk_clos.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_spg_reg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_spg_reg.Cxx_dtc_hmb_xxx
			fm_cal_spg_reg_apl_down.Cxx_dtc_obd_xxx
			fm_cal_spg_reg_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_spg_reg_apl_down.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_spg_reg_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_spg_reg_apl_down.Cxx_dtc_lb_xxx
			fm_cal_spg_reg_apl_down.Cxx_obd_dc_xxx
			fm_cal_spg_reg_apl_up.Cxx_dtc_obd_xxx
			fm_cal_spg_reg_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_spg_reg_apl_up.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_spg_reg_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_spg_reg_apl_up.Cxx_dtc_lb_xxx
			fm_cal_spg_reg_apl_up.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_tbf_fct.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_tbf_fct.Cxx_dtc_hmb_xxx
			fm_cal_tbf_fct_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tbf_fct_apl_down.Cxx_dtc_lb_xxx
			fm_cal_tbf_fct_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tbf_fct_apl_up.Cxx_dtc_lb_xxx
			Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_tbt.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_tbt.Cxx_dtc_hmb_xxx
			fm_cal_tbt_chr.Cxx_dtc_obd_xxx
			fm_cal_tbt_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tbt_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_tbt_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_tbt_chr.Cxx_dtc_lb_xxx
			fm_cal_tbt_chr.Cxx_obd_dc_xxx
			fm_cal_tbt_h.Cxx_dtc_obd_xxx
			fm_cal_tbt_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tbt_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_tbt_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_tbt_h.Cxx_dtc_lb_xxx
			fm_cal_tbt_h.Cxx_obd_dc_xxx
			fm_cal_tbt_l.Cxx_dtc_obd_xxx
			fm_cal_tbt_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tbt_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_tbt_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_tbt_l.Cxx_dtc_lb_xxx
			fm_cal_tbt_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_tbt_reg.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_tbt_reg.Cxx_dtc_hmb_xxx
			fm_cal_tbt_reg_apl_up.Cxx_dtc_obd_xxx
			fm_cal_tbt_reg_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tbt_reg_apl_up.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_tbt_reg_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_tbt_reg_apl_up.Cxx_dtc_lb_xxx
			fm_cal_tbt_reg_apl_up.Cxx_obd_dc_xxx
			fm_cal_tbt_reg_neg_err.Cxx_dtc_obd_xxx
			fm_cal_tbt_reg_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tbt_reg_neg_err.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_tbt_reg_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_tbt_reg_neg_err.Cxx_dtc_lb_xxx
			fm_cal_tbt_reg_neg_err.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_thpl_cmd1.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_thpl_cmd1.Cxx_dtc_hmb_xxx
			fm_cal_thpl_cmd1_oc.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd1_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd1_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd1_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd1_oc.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd1_oc.Cxx_obd_dc_xxx
			fm_cal_thpl_cmd1_scg.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd1_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd1_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd1_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd1_scg.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd1_scg.Cxx_obd_dc_xxx
			fm_cal_thpl_cmd1_scw.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd1_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd1_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd1_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd1_scw.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd1_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_thpl_cmd2.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_thpl_cmd2.Cxx_dtc_hmb_xxx
			fm_cal_thpl_cmd2_oc.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd2_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd2_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd2_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd2_oc.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd2_oc.Cxx_obd_dc_xxx
			fm_cal_thpl_cmd2_scg.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd2_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd2_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd2_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd2_scg.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd2_scg.Cxx_obd_dc_xxx
			fm_cal_thpl_cmd2_scw.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd2_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd2_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd2_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd2_scw.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd2_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_thpl_cmd3.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_thpl_cmd3.Cxx_dtc_hmb_xxx
			fm_cal_thpl_cmd3_oc.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd3_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd3_oc.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd3_oc.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd3_oc.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd3_oc.Cxx_obd_dc_xxx
			fm_cal_thpl_cmd3_scg.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd3_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd3_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd3_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd3_scg.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd3_scg.Cxx_obd_dc_xxx
			fm_cal_thpl_cmd3_scw.Cxx_dtc_obd_xxx
			fm_cal_thpl_cmd3_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_thpl_cmd3_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_thpl_cmd3_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_thpl_cmd3_scw.Cxx_dtc_lb_xxx
			fm_cal_thpl_cmd3_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_tqi_cor.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_tqi_cor.Cxx_dtc_hmb_xxx
			fm_cal_tqi_cor_chr.Cxx_dtc_obd_xxx
			fm_cal_tqi_cor_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_tqi_cor_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_tqi_cor_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_tqi_cor_chr.Cxx_dtc_lb_xxx
			fm_cal_tqi_cor_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_unk_thpl1.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_unk_thpl1.Cxx_dtc_hmb_xxx
			fm_cal_unk_thpl1_chr.Cxx_dtc_obd_xxx
			fm_cal_unk_thpl1_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_unk_thpl1_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_unk_thpl1_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_unk_thpl1_chr.Cxx_dtc_lb_xxx
			fm_cal_unk_thpl1_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_unk_thpl2.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_unk_thpl2.Cxx_dtc_hmb_xxx
			fm_cal_unk_thpl2_chr.Cxx_dtc_obd_xxx
			fm_cal_unk_thpl2_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_unk_thpl2_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_unk_thpl2_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_unk_thpl2_chr.Cxx_dtc_lb_xxx
			fm_cal_unk_thpl2_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_unk_thpl3.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_unk_thpl3.Cxx_dtc_hmb_xxx
			fm_cal_unk_thpl3_chr.Cxx_dtc_obd_xxx
			fm_cal_unk_thpl3_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_unk_thpl3_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_unk_thpl3_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_unk_thpl3_chr.Cxx_dtc_lb_xxx
			fm_cal_unk_thpl3_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_unk_thpl4.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_unk_thpl4.Cxx_dtc_hmb_xxx
			fm_cal_unk_thpl4_chr.Cxx_dtc_obd_xxx
			fm_cal_unk_thpl4_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_unk_thpl4_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_unk_thpl4_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_unk_thpl4_chr.Cxx_dtc_lb_xxx
			fm_cal_unk_thpl4_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_unk_thpl.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_unk_thpl.Cxx_dtc_hmb_xxx
			fm_cal_unk_thpl_chr.Cxx_dtc_obd_xxx
			fm_cal_unk_thpl_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_unk_thpl_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_unk_thpl_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_unk_thpl_chr.Cxx_dtc_lb_xxx
			fm_cal_unk_thpl_chr.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ups_ecu.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ups_ecu.Cxx_dtc_hmb_xxx
			fm_cal_ups_ecu_chr.Cxx_dtc_obd_xxx
			fm_cal_ups_ecu_chr.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ups_ecu_chr.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ups_ecu_chr.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ups_ecu_chr.Cxx_dtc_lb_xxx
			fm_cal_ups_ecu_chr.Cxx_obd_dc_xxx
			fm_cal_ups_ecu_itl.Cxx_dtc_obd_xxx
			fm_cal_ups_ecu_itl.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ups_ecu_itl.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ups_ecu_itl.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ups_ecu_itl.Cxx_dtc_lb_xxx
			fm_cal_ups_ecu_itl.Cxx_obd_dc_xxx
			fm_cal_ups_ecu_oor.Cxx_dtc_obd_xxx
			fm_cal_ups_ecu_oor.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ups_ecu_oor.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ups_ecu_oor.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ups_ecu_oor.Cxx_dtc_lb_xxx
			fm_cal_ups_ecu_oor.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ups_ro2.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ups_ro2.Cxx_dtc_hmb_xxx
			fm_cal_ups_ro2_oor.Cxx_dtc_obd_xxx
			fm_cal_ups_ro2_oor.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ups_ro2_oor.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ups_ro2_oor.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ups_ro2_oor.Cxx_dtc_lb_xxx
			fm_cal_ups_ro2_oor.Cxx_obd_dc_xxx
			fm_cal_ups_ro2_slow_trs.Cxx_dtc_obd_xxx
			fm_cal_ups_ro2_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ups_ro2_slow_trs.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ups_ro2_slow_trs.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ups_ro2_slow_trs.Cxx_dtc_lb_xxx
			fm_cal_ups_ro2_slow_trs.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ups_tip.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ups_tip.Cxx_dtc_hmb_xxx
			fm_cal_ups_tip_oor.Cxx_dtc_obd_xxx
			fm_cal_ups_tip_oor.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ups_tip_oor.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ups_tip_oor.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ups_tip_oor.Cxx_dtc_lb_xxx
			fm_cal_ups_tip_oor.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_ups_uo2.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_ups_uo2.Cxx_dtc_hmb_xxx
			fm_cal_ups_uo2_oor.Cxx_dtc_obd_xxx
			fm_cal_ups_uo2_oor.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_ups_uo2_oor.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_ups_uo2_oor.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_ups_uo2_oor.Cxx_dtc_lb_xxx
			fm_cal_ups_uo2_oor.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_vb.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_vb.Cxx_dtc_hmb_xxx
			fm_cal_vb_h.Cxx_dtc_obd_xxx
			fm_cal_vb_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_vb_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_vb_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_vb_h.Cxx_dtc_lb_xxx
			fm_cal_vb_h.Cxx_obd_dc_xxx
			fm_cal_vb_l.Cxx_dtc_obd_xxx
			fm_cal_vb_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_vb_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_vb_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_vb_l.Cxx_dtc_lb_xxx
			fm_cal_vb_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_vb_rly.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_vb_rly.Cxx_dtc_hmb_xxx
			fm_cal_vb_rly_oc_scg.Cxx_dtc_obd_xxx
			fm_cal_vb_rly_oc_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_vb_rly_oc_scg.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_vb_rly_oc_scg.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_vb_rly_oc_scg.Cxx_dtc_lb_xxx
			fm_cal_vb_rly_oc_scg.Cxx_obd_dc_xxx
			fm_cal_vb_rly_scw.Cxx_dtc_obd_xxx
			fm_cal_vb_rly_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_vb_rly_scw.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_vb_rly_scw.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_vb_rly_scw.Cxx_dtc_lb_xxx
			fm_cal_vb_rly_scw.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_vnt.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_vnt.Cxx_dtc_hmb_xxx
			fm_cal_vnt_h.Cxx_dtc_obd_xxx
			fm_cal_vnt_h.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_vnt_h.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_vnt_h.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_vnt_h.Cxx_dtc_lb_xxx
			fm_cal_vnt_h.Cxx_obd_dc_xxx
			fm_cal_vnt_l.Cxx_dtc_obd_xxx
			fm_cal_vnt_l.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_vnt_l.fm_static_bitfield.Cbx_obd_xxx
			fm_cal_vnt_l.fm_static_bitfield.Cbx_obd_mena_xxx
			fm_cal_vnt_l.Cxx_dtc_lb_xxx
			fm_cal_vnt_l.Cxx_obd_dc_xxx
			Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[0]
			Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[1]
			Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[2]
			Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[3]
			Pxx_dgdftmng_dtc_wpmp_tcr.Ctx_ffm_did_xxx[4]
			Pxx_dgdftmng_dtc_wpmp_tcr.Cxx_dtc_hmb_xxx
			fm_cal_wpmp_tcr_blk.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_wpmp_tcr_blk.Cxx_dtc_lb_xxx
			fm_cal_wpmp_tcr_oc.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_wpmp_tcr_oc.Cxx_dtc_lb_xxx
			fm_cal_wpmp_tcr_scg.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_wpmp_tcr_scg.Cxx_dtc_lb_xxx
			fm_cal_wpmp_tcr_scw.fm_static_bitfield.Cxx_conf_wal_xxx
			fm_cal_wpmp_tcr_scw.Cxx_dtc_lb_xxx
	/end DEF_CHARACTERISTIC
	/* ASAP2::Database : delete 'fm_sta_eprm_NO_ERROR.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_NO_ERROR.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_NO_ERROR.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_NO_ERROR.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_NO_ERROR.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_ac_clu_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_ac_clu_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_alt_pwm_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_alt_pwm_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_alt_pwm_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_alt_pwm_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_alt_pwm_apl_down.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_clos_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_clos_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_clos_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_clos_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_clos_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_no_norm.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_open_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_open_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_open_nok.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_brk_pdl_open_nok.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_brk_pdl_open_nok.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata1_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata1_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata1_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata1_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata1_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata2_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata2_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata2_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata2_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata2_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_cpt.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_cpt.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_cpt.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_cpt.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_cpt.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cata_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cata_dirt_lkg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cl_rich_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cl_rich_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cl_rich_chr.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cl_rich_chr.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cl_rich_chr.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_comb_trs_tout.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_comb_trs_tout.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_comb_trs_tout.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_comb_trs_tout.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_comb_trs_tout.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_blk_open.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_oc.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_oc.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_oc.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scg.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scg.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scg.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scw.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_cp_scw.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_cp_scw.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_el.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_el.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_el.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_el.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_el.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_no_norm.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_puls.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_puls.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_puls.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_syn.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_syn.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_syn.fm_static_eprm_bitfield.Sbx_mf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_syn.fm_static_eprm_bitfield.Sbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.Vxx_dfctr_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.Vxx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.fm_static_bitfield.Vbx_cf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.fm_static_bitfield.Vbx_clf_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.fm_static_bitfield.Vbx_df_old_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.fm_static_bitfield.Vbx_dfctr_sat_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.fm_static_bitfield.Vbx_rdn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_crk_syn.Vxx_dtc_stt_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_trs.fm_static_eprm_bitfield.Sbx_dyn_xxx' */
	/* ASAP2::Database : delete 'fm_sta_eprm_crk_trs.fm_static_eprm_bitfield.Sbx_rdn_xxx' */
