/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_amp_cor_pr
		"Engine toruqe breakpoint of atmospheric pressure correction of pre injection 1 during pft rgn"
		0x8004bcce
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_amp_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction during regular injection"
		0x8004a884
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_max_pr
		"Engine torque breakpoint of maximum quantity of pre-injection 1 during pft regeneration"
		0x8004bcb8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_max_rij
		"Engine torque breakpoint of maximum quantity of pre-injection 1 during regular injection"
		0x8004a86e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_rij
		"Engine torque breakpoint for quantity of pre-injection 1 during rij"
		0x8004a84c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction of pre injection 1 during pft rgn"
		0x8004bc9e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_tia_cor_pr
		"Engine torque breakpoint of intake air temperature correction of pre injection 1 during pft rgn"
		0x8004bc84
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_tia_cor_rij
		"Engine torque breakpoint of tia correction for quantity of pre injection 1 during regular injection"
		0x8004a832
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_amp_cor_pr
		"Engine toruqe breakpoint of atmospheric pressure correction of pre injection 2 during pft rgn"
		0x8004c4ae
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_amp_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction during regular injection"
		0x8004b35e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_max_pr
		"Engine torque breakpoint of maximum quantity of pre-injection 2 during pft regeneration"
		0x8004c498
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_max_rij
		"Engine torque breakpoint of maximum quantity of pre-injection 2 during regular injection"
		0x8004b348
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_rij
		"Engine torque breakpoint for quantity of pre-injection 2 for cold tco during rij"
		0x8004b326
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction of pre injection 2 during pft rgn"
		0x8004c47e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_tia_cor_pr
		"Engine torque breakpoint of intake air temperature correction of pre injection 2 during pft rgn"
		0x8004c464
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp2_tia_cor_rij
		"Engine torque breakpoint of tia correction for quantity of pre injection 2 during regular injection"
		0x8004b30c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fpo_amp_cor_pr
		"Engine torque breakpoint of atmospheric pressure correction during pft regeneration"
		0x8004d0ee
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fpo_max_pr
		"Engine torque breakpoint of maximum quantity of post injection during pft regeneration"
		0x8004d0d8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fpo_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction during pft regeneration"
		0x8004d0be
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fpo_tia_cor_pr
		"Engine torque breakpoint of intake air temperature correction during pft regeneration"
		0x8004d0a4
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_ms_dp_cor_pr
		"Programmable indicated torque breakpoints for CSF equivalent load correction of global injection during pft rgn"
		0x80044a1e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_pinj_cut_1
		"Torque inner setpoint breakpoint of the pre injection cut one"
		0x8004c9ba
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_pinj_cut_2
		"Torque inner setpoint breakpoint of the pre injection cut two"
		0x8004c9a8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_pinj_cut_3
		"Torque inner setpoint breakpoint of the pre injection cut three"
		0x8004c996
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_pinj_cut_4
		"Torque inner setpoint breakpoint of the pre injection cut four"
		0x8004c984
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_pinj_cut_5
		"Torque inner setpoint breakpoint of the pre injection cut five"
		0x8004c972
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_taf_amp_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction during regular injection"
		0x80069d08
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_taf_max_rij
		"Engine torque breakpoint of maximum separation of after injection during regular injection"
		0x80069cf2
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_taf_min_rij
		"Engine torque breakpoint of minimum separation of after injection during regular injection"
		0x80069cdc
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_taf_rij
		"Engine torque breakpoint of separation of after injection during rij"
		0x80069cba
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_taf_tia_cor_rij
		"Engine torque breakpoint of intake air temperature correction during regular injection"
		0x80069ca0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tia_cor_pr
		"Programmable indicated torque breakpoints for intake air temperature correction of global injection during pft rgn"
		0x80044a04
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tlp_amp_cor_pr
		"Engine torque breakpoint of atmospheric pressure correction of late post injetcion during pft rgn"
		0x8004f280
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tlp_max_pr
		"Engine torque breakpoint of maximum angle of late post injection during pft regeneration"
		0x8004f26a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tlp_min_pr
		"Engine torque breakpoint of minimum angle of late post injection during pft regeneration"
		0x8004f254
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tlp_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction of late post injetcion during pft rgn"
		0x8004f23a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tlp_tia_cor_pr
		"Engine torque breakpoint of intake air temperature correction of late post injetcion during pft rgn"
		0x8004f220
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_2p_rij
		"Engine torque breakpoint for separation of pre-injection 1 with 2 pre-injection during rij"
		0x80052134
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_amp_cor_pr
		"Engine toruqe breakpoint of atmospheric pressure correction of pre injection 1 during pft rgn"
		0x80053d90
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_amp_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction during regular injection"
		0x8005211a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_cold_tco_2p_rij
		"Engine torque breakpoint for separation of pre-injection 1 with 2 preinjection for cold tco during r"
		0x800520f8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_cold_tco_rij
		"Engine torque breakpoint for separation of pre-injection 1 for cold tco during rij"
		0x800520d6
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_max_cor_rij
		"Engine torque breakpoint of maximum correction for separation of pre-injection 1 during rij"
		0x800520c0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_max_pr
		"Engine torque breakpoint of maximum separation of pre-injection 1 during pft regeneration"
		0x80053d7a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_max_rij
		"Engine torque breakpoint of maximum separation of pre-injection 1 during regular injection"
		0x800520aa
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_min_cor_rij
		"Engine torque breakpoint of minimum correction for separation of pre-injection 1 during rij"
		0x80052094
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_min_pr
		"Engine torque breakpoint of minimum separation of pre-injection 1 during pft regeneration"
		0x80053d64
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_min_rij
		"Engine torque breakpoint of minimum separation of pre-injection 1 during regular injection"
		0x8005207e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_mv_tco_2p_rij
		"Engine torque breakpoint for separation of preinjection1 with 2 preinjection for medium tco during r"
		0x8005205c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_mv_tco_rij
		"Engine torque breakpoint of separation of pre-injection 1 for medium coolant temperature during rij"
		0x8005203a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_rij
		"Engine torque breakpoint for separation of pre-injection 1 during rij"
		0x80052018
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction of pre injection 1 during pft rgn"
		0x80053d4a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_tia_cor_pr
		"Engine torque breakpoint of intake air temperature correction of pre injection 1 during pft rgn"
		0x80053d30
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp1_tia_cor_rij
		"Engine torque breakpoint of tia correction for separation of pre injection 1 during regular injectio"
		0x80051ffe
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_2p_rij
		"Engine torque breakpoint for separation of pre-injection 2 with 2 pre-injection for cold tco during rij"
		0x80053302
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_amp_cor_pr
		"Engine toruqe breakpoint of atmospheric pressure correction of pre injection 2 during pft rgn"
		0x80054868
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_amp_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction during regular injection"
		0x800532e8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_max_pr
		"Engine torque breakpoint of maximum separation of pre-injection 2 during pft regeneration"
		0x80054852
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_max_rij
		"Engine torque breakpoint of maximum separation of pre-injection 2 during regular injection"
		0x800532d2
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_min_pr
		"Engine torque breakpoint of minimum separation of pre-injection 2 during pft regeneration"
		0x8005483c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_min_rij
		"Engine torque breakpoint of minimum separation of pre-injection 2 during regular injection"
		0x800532bc
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_rij
		"Engine torque breakpoint for separation of pre-injection 2 for cold tco during rij"
		0x8005329a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction of pre injection 2 during pft rgn"
		0x80054822
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_tia_cor_pr
		"Engine torque breakpoint of intake air temperature correction of pre injection 2 during pft rgn"
		0x80054808
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tp2_tia_cor_rij
		"Engine torque breakpoint of tia correction for separation of pre injection 2 during regular injectio"
		0x80053280
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tpo_amp_cor_pr
		"Engine torque breakpoint of atmospheric pressure correction during pft regeneration"
		0x80055140
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tpo_max_pr
		"Engine torque breakpoint of maximum angle of post injection during pft regeneration"
		0x8005512a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tpo_min_pr
		"Engine torque breakpoint of minimum angle of post injection during pft regeneration"
		0x80055114
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tpo_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction during pft regeneration"
		0x800550fa
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_tpo_tia_cor_pr
		"Engine torque breakpoint of intake air temperature correction during pft regeneration"
		0x800550e0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_wish_tlp2
		"Torque breakpoint for Late post injection 2 desired timing separation"
		0x80069226
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_lpos_efi_exo_fac
		"Programmable indicated torque breakpoints for physical fuel flow exotherm adaptation from late post injection to 5th injector ."
		0x800449e2
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_cor
		"Torque breakpoint for the pulsation correction"
		0x80057652
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_cor_n_pr
		"Engine speed breakpoints for mass air flow correction of main torque model in pr mode"
		0x8005c2c0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_cor_n_rij
		"Engine speed breakpoints for mass air flow correction of main torque model in rij mode"
		0x8005ca34
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_cor_tqi_pr
		"Torque breakpoints for mass air flow correction of main torque model in pr mode"
		0x8005c2a6
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_cor_tqi_rij
		"Torque breakpoints for mass air flow correction of main torque model in rij mode"
		0x8005ca1a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_fac_ocd
		"Mass air flow breakpoints of main torque model correction in ocd mode"
		0x8005bbea
		Vxx_tqi_maf_err_fil_ocd
		RSA_RecordLayout_Axis_UWORD
		6000
		tClffab_hirDflc_mxtqjrd_mtA_o00
		12
		-3000.
		3000.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_fac_pr
		"Mass air flow breakpoints of main torque model correction in pr mode"
		0x8005c28c
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		6000
		tClffab_hirDflc_mxtqjrd_mtA_o00
		12
		-3000.
		3000.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_maf_fac_rij
		"Mass air flow breakpoints of main torque model correction in rij mode"
		0x8005ca00
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		6000
		tClffab_hirDflc_mxtqjrd_mtA_o00
		12
		-3000.
		3000.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protqxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_max_fuel_temp
		"Fuel temperature breakpoints map for hydraulic system protection"
		0x8005bade
		Vxx_fuel_temp
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_max_map
		"Manifold pressure breakpoint of full load torque limitation in regeneration mode"
		0x8005b888
		Vxx_map_fil_max_tq
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		10
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_max_ms_dp
		"soot mass breakpoint of lull load torque limitation in regeneration mode"
		0x8005b876
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		8
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_max_n
		"engine speed breakpoint of full load torque limitation"
		0x8005ba5c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_max_up_it_temp
		"Table of 9 programable breakpoints of upstream throttle temperature"
		0x8005b862
		Vxx_up_it_temp
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_fms_cor
		"Programmable indicated torque breakpoints for basic injected fuel mass flow settings correction."
		0x80045724
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_fms_dg
		"Programmable indicated torque breakpoints for derivative gain of injected fuel mass flow control"
		0x80045712
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_fms_ig
		"Programmable indicated torque breakpoints for integral gain of injected fuel mass flow control"
		0x80045700
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_fms_pg
		"Programmable indicated torque breakpoints for proportional gain of injected fuel mass flow control"
		0x800456ee
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_inj_fms_bas
		"Programmable indicated torque breakpoints of injected fuel mass flow basic settings"
		0x800456cc
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_neg_dev
		"Programmable indicated torque breakpoints for negative deviation of TBF regulation"
		0x80044d60
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_pos_dev
		"Programmable indicated torque breakpoints for positive deviation of TBF regulation"
		0x80044d4e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_utp_bas
		"Programmable indicated torque breakpoints map for the variable CSF up temp with base setting"
		0x800456ba
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_utp_bas_ftc
		"Programmable indicated torque breakpoints for the value of filter time constant of CSF up temp with base setting"
		0x800456a8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_utp_inj_fms_fac
		"Programmable indicated torque breakpoints for CSF up temp / injected fuel mass flow gain"
		0x80045696
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_utp_reg_on_stt
		"Programmable indicated torque breakpoints for CSF up temp regulation activation state"
		0x800458d0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_utp_reg_ovs
		"Programmable indicated torque breakpoints for CSF up temp regulator overshoot"
		0x80045c3e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_utp_sp
		"Programmable indicated torque breakpoints for CSF up temp regulator setpoint"
		0x80045c2c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_pft_utp_sp_max
		"Table of upstream temp maximum setpoint value depending on mass air flow"
		0x80045c1a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_post_efy_phi_cor_n_pr
		"Engine speed breakpoints for post efficiency correction in pr mode"
		0x8005cd08
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_post_efy_phi_cor_tqi_pr
		"Torque breakpoints for post efficiency correction in pr mode"
		0x8005ccf6
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_post_efy_phi_fac_pr
		"Angle breakpoints of diff between current and basic post injection timing for efficiency in pr mode"
		0x8005cce4
		Vxx_tqi_tpo_dif_pr
		RSA_RecordLayout_Axis_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		8
		-360.
		360.
    FORMAT "%7.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_post_efy_ti_cor_n_pr
		"Engine speed breakpoints for post efficiency correction in pr mode"
		0x8005ccd2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_post_efy_ti_cor_tqi_pr
		"Torque breakpoints for post efficiency correction in pr mode"
		0x8005ccc0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_post_efy_ti_dif_fac_pr
		"Angle breakpoints of diff between current and last injection timing for efficiency in pr mode"
		0x8005ccae
		Vxx_fms_dif_post
		RSA_RecordLayout_Axis_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		8
		-32768.
		32767.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rat
		"Indicated torque ratio breakpoints table"
		0x800585aa
		Vxx_tqi_rat_tgt
		RSA_RecordLayout_Axis_UWORD
		1
		wijukob_vbAeApa_hCDsnsa_n__a40a
		6
		0.
		1.
    FORMAT "%11.9" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_0p_pr
		"Engine torque breakpoint of base rail pressure without pre-injection during pr"
		0x8004daa4
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_0p_rij
		"Engine torque breakpoint of rail pressure for cold coolant temperatrure without pre-injection"
		0x8004e96c
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_1p_pr
		"Engine torque breakpoint of base rail pressure with 1 pre-injection during pr"
		0x8004da82
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_1p_rij
		"Engine torque breakpoint of rail pressure for cold coolant temperatrure with 1 pre-injection"
		0x8004e94a
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_amp_cor_pr
		"Engine torque breakpoint of atmospheric pressure correction for rail pressure during pr"
		0x8004da68
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_amp_tco_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction for rail pressure"
		0x8004e930
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_grd_prs_inc_prs
		""
		0x8006911a
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_max_pr
		"Engine torque breakpoint of maximum rail pressure during pr"
		0x8004da52
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_max_rij
		"Engine torque breakpoint of maximun for rail pressure"
		0x8004e91a
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_min_pr
		"Engine torque breakpoint of minimum for rail pressure during pr"
		0x8004da3c
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_min_rij
		"Engine torque breakpoint of minimum for rail pressure"
		0x8004e904
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_sp_dec
		"Engine trorque breakpoint of rail pressure setpoint decrease by fuel temperature"
		0x80069108
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction for rail pressure during pr"
		0x8004da22
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_tia_cor_pr
		"Engine torque breakpoint of atmospheric temperature correction for rail pressure during pr"
		0x8004da08
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_rps_tia_tco_cor_rij
		"Engine torque breakpoint of atmospheric temperature correction for rail pressure"
		0x8004e8ea
		Vxx_tqi_tgt
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_t_fil_down_ocd
		"Engine breakpoints of torque model filtration time down in ocd mode"
		0x8005bbd8
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_t_fil_up_ocd
		"Engine breakpoints of torque model filtration time up in ocd mode"
		0x8005bbc6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tqi_thpl_err
		"Breakpoints of tqi error for calculation of number of coolant heaters to activate"
		0x800432d2
		Vxx_tqi_thpl_gov
		RSA_RecordLayout_Axis_UWORD
		7
		lasreaa_cardnzb_hCDtpsa_n__a00a
		8
		0.
		7.
    FORMAT "%4.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_tt_bas
		"Programmable indicated torque breakpoints for ttr with basic engine calibration during regeneration"
		0x80045684
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_tt_bas_ftc
		"Programmable indicated torque breakpoints for ttr filtering time constants"
		0x80045672
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_tt_pft_utp_fac
		"Programmable indicated torque breakpoints to convert ttr difference to a CSF up temp difference equivalent"
		0x80045660
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_vnt_dft_spg
		"Breakpoints y for maximum torque in case of negative regulation error"
		0x8005ba46
		Vxx_spg
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		10
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_vnt_emtv_psn_thd
		"Breakpoints y of emtv position threshold to force i part initialisation"
		0x8005f058
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tsp_tp1_amp_fac_sta
		"Breakpoints of atmospheric pressure for starting set point tables correction"
		0x8006af60
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tsp_tp2_amp_fac_sta
		"Breakpoints of atmospheric pressure for starting set point tables correction for pre injection 2 separation"
		0x8006b042
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tt
		"Programmable temperature before turbine breakpoints map for sampling time"
		0x80058e86
		Vxx_tt
		RSA_RecordLayout_Axis_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tt_fms_efi_max_pr
		"Programmable temperature before turbine breakpoint map of maximum quantity of late post injection during pft regeneration"
		0x800449d0
		Vxx_tt
		RSA_RecordLayout_Axis_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_up_shf_pdl
		"Ctb_up_shf_pdl"
		0x8005939e
		Vxx_free_shf_pdl
		RSA_RecordLayout_Axis_UWORD
		100
		VA_F_0v125_p0_6
		11
		0
		100
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vb_vnt_pwm_fac
		"Breakpoints for battery voltage correction factor on turbocharger pwm"
		0x800400fe
		Vxx_vb
		RSA_RecordLayout_Axis_UWORD
		60
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		8
		0.
		60.
    FORMAT "%5.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vh_dist
		"Programmable vehicle distance breakpoints for msot contribution"
		0x800465d4
		Vxx_vh_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		4
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vh_dist_efy_driv
		"Programmable vehicle distance breakpoints"
		0x80058080
		Vxx_pft_vh_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		8
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vh_dist_rgn
		"Programmable vehicle distance breakpoints"
		0x80047052
		Vxx_vh_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		6
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vh_dist_wait_cdn
		"Programmable vehicule distance breakpoints for waiting conditions"
		0x80046d3c
		Vxx_vh_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		6
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_neg_typ_1
		"Breakpoint of negative membership function for the derivative error gear type 1"
		0x8005f04c
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_neg_typ_2
		"Breakpoint of negative membership function for the derivative error gear type 2"
		0x8005f040
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_neg_typ_3
		"Breakpoint of negative membership function for the derivative error gear type 3"
		0x8005f034
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_nul_typ_1
		"Breakpoint of zero membership function for the derivative error gear type 1"
		0x8005f028
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_nul_typ_2
		"Breakpoint of zero membership function for the derivative error gear type 2"
		0x8005f01c
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_nul_typ_3
		"Breakpoint of zero membership function for the derivative error gear type 3"
		0x8005f010
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_pos_typ_1
		"Breakpoint of positive membership function for the derivative error gear type 1"
		0x8005f004
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_pos_typ_2
		"Breakpoint of positive membership function for the derivative error gear type 2"
		0x8005eff8
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_drv_pos_typ_3
		"Breakpoint of positive membership function for the derivative error gear type 3"
		0x8005efec
		Vxx_vnt_err_drv_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_neg_typ_1
		"Breakpoint of negative membership function for the error gear type 1"
		0x8005efe0
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_neg_typ_2
		"Breakpoint of negative membership function for the error gear type 2"
		0x8005efd4
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_neg_typ_3
		"Breakpoint of negative membership function for the error gear type 3"
		0x8005efc8
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_nul_typ_1
		"Breakpoint of zero membership function for the error gear type 1"
		0x8005efbc
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_nul_typ_2
		"Breakpoint of zero membership function for the error gear type 2"
		0x8005efb0
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_nul_typ_3
		"Breakpoint of zero membership function for the error gear type 3"
		0x8005efa4
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		5
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_pos_typ_1
		"Breakpoint of positive membership function for the error gear type 1"
		0x8005ef8e
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		10
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_pos_typ_2
		"Breakpoint of positive membership function for the error gear type 2"
		0x8005ef78
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		10
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_err_pos_typ_3
		"Breakpoint of positive membership function for the error gear type 3"
		0x8005ef62
		Vxx_vnt_err_fzy
		RSA_RecordLayout_Axis_UWORD
		2
		lkejytd_cutavkd_xfybptd_nA_0a0a
		10
		-1.
		1.
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vnt_pwm_i_rst_ena
		"X breakpoints of i reset enabling curve function of consumation"
		0x8005ef4c
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_vs_efi_ext_sph
		"Programmable indicated vehicle speed breakpoints map for exhaust line injector external enthalpy calculus."
		0x800582ba
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		10
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_amp_sp_max
		"Breakpoints x for setpoint limitation"
		0x80043a5e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_amp_spg_sp_cor_pr
		"Breakpoints x for boost air pressure correction for atm pressure during regeneration"
		0x8005f870
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		7
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_amp_spg_sp_cor_rij
		"Breakpoints x for b.a.p setpoint atmospheric pressure correction in regular injection mode"
		0x80060070
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		7
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_conv_egr_it_psn
		"X breakpoint for curve of conversion for inlet throttle position command"
		0x80063b98
		Vxx_it_wit_emtv_cmd
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		16
		0.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_efy_cpr
		"X-breakpoints for compressor efficiency map"
		0x80057ca6
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		13
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_efy_spg_cool
		""
		0x80057c8a
		Vxx_maf_kgh
		RSA_RecordLayout_Axis_UWORD
		2000
		bCkDtxb_iBmhrgb_vDEgpCc_khA_10a
		13
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_byp_tco_hys_low
		"X breakpoints for hysteresis cartography"
		0x800602be
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_cut_dly_aftr_sta
		"X breakpoint for the map of EGR cut off time after start"
		0x8006289a
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_cut_tqi_tco_pr
		"X breakpoints for tco curve correction in fast accel in pr mode"
		0x800618ac
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		4
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_cut_tqi_tco_rij_pp
		"X breakpoints for tco curve correction in fast accel in rij and pp modes"
		0x800618a2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		4
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_cut_tqi_thd_pp
		"X breakpoints for the map of EGR cut depending on torque in pp mode"
		0x80061880
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_cut_tqi_thd_pr
		"X breakpoints for the map of EGR cut depending on torque in pr mode"
		0x8006185e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_cut_tqi_thd_rij
		"X breakpoints for the map of EGR cut depending on torque in rij mode"
		0x8006183c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_egr_maf_reg_min_lim
		"X breakpoints for the map of PI governor minimal output value"
		0x80063ec2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_emtv_sp_max_pp
		"X Bkp for MAP for egr valve position threshold value in pp mode"
		0x80061b9a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_emtv_sp_max_pr
		"X Bkp for MAP for egr valve position threshold value in pr mode"
		0x80061e8a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_emtv_sp_max_rij
		"X Bkp for MAP for egr valve position threshold value in rij mode"
		0x8006217a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_eng_vol_efy_ex
		"The x breakpoints of exhaust volumetric efficiency map"
		0x800573b2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		13
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_eng_vol_efy_in
		"The x breakpoints of intake volumetric efficiency map"
		0x80057396
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		13
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_ex_df_spg_sp_cor_pr
		"Breakpoints x for boost air pressure setpoint intake temperature correction in case of exhaust pressure sensor limphome in particule"
		0x8005f860
		Vxx_tia_spg_sp_pr
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_ex_df_spg_sp_cor_rij
		"Breakpoints x for boost air pressure setpoint intake temperature correction in case of exhaust pressure sensor limphome in regular"
		0x80060060
		Vxx_tia_spg_sp_rij
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_psn_max_pp
		"X breakpoints for Cmp_n_ff_itp_max_rgn_prmt"
		0x80061b80
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_psn_max_pr
		"X breakpoints for Cmp_n_ff_itp_max_rgn"
		0x80061e70
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_psn_max_rij
		"X breakpoints for Cmp_n_ff_itp_max in rij mode"
		0x80062160
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_amp_pp
		"X breakpoints for curve of corrector factor for thr sat depending on amp in rgn_prmt mode"
		0x80062ed4
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		16
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_amp_pr
		"X breakpoints for curve of corrector factor for thr sat depending on amp if rgn mode is on"
		0x8006350a
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		16
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_amp_rij
		"X breakpoints for curve of corrector factor for thr sat depending on amp in regular injection mode"
		0x80063b42
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		16
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_tco_pp
		"X breakpoints for curve of corrector factor for thr sat depending of tco if rgn_prmt mode is on"
		0x80062ec2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_tco_pr
		"X breakpoints for curve of corrector factor for thr sat depending of tco if rgn mode is on"
		0x800634f8
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_tco_rij
		"X breakpoints for curve of corrector factor for thr sat depending on tco in regular injection mode"
		0x80063b30
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_tia_pp
		"X breakpoints for curve of corrector factor for thr sat depending on tia if rgn_prmt mode is on"
		0x80062eb0
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_tia_pr
		"X breakpoints for curve of corrector factor for thr sat depending on tia if rgn mode is on"
		0x800634e6
		Vxx_tia_cor
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_cor_tia_rij
		"X breakpoints for curve of corrector factor for thr sat depending on tia in regular injection mode"
		0x80063b1e
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_val_bas_pp
		"X breakpoints for cartography of thr sat setpoints in permanent regeneration mode"
		0x80062e8e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_val_bas_pr
		"X breakpoints for cartography of thr sat setpoints in rgn mode"
		0x800634c4
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_it_sat_val_bas_rij
		"X breakpoints for cartography of thr sat setpoints in regular injection mode"
		0x80063afc
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_amp_pp
		"X breakpoints for cartography of thr sat correction depending on amp in rgn_prmt mode"
		0x80062e6c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_amp_pr
		"X breakpoints for cartography of thr sat correction depending on amp in rgn mode"
		0x800634a2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_amp_rij
		"X breakpoints for cartography of thr sat correction depending on amp in rij mode"
		0x80063ada
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_tco_pp
		"X breakpoints for cartography of thr sat correction depending on tco in rgn_prmt mode"
		0x80062e5a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_tco_pr
		"X breakpoints for cartography of thr sat correction depending on tco in rgn mode"
		0x80063490
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_tco_rij
		"X breakpoints for cartography of thr sat correction depending on tco in rij mode"
		0x80063ac8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_tia_pp
		"X breakpoints for cartography of thr sat corrected by tia in rgn_prmt mode"
		0x80062e48
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_tia_pr
		"X breakpoints for cartography of thr sat correction depending on tia in rgn mode"
		0x8006347e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_it_sat_cor_tia_rij
		"X breakpoints for cartography of thr sat corrected by tia in rij mode"
		0x80063ab6
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_amp_pp
		"X breakpoints for cartography of maf correction depending on amp in pp mode"
		0x80065a04
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_amp_pr
		"X breakpoints for cartography of maf correction depending on amp in pr mode"
		0x80066660
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_amp_rij
		"X breakpoints for cartography of maf correction depending on amp in rij mode"
		0x80067ea0
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tco_pp
		"X breakpoints for cartography of maf correction depending on tco in pp mode"
		0x800659e2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tco_pr
		"X breakpoints for cartography of maf correction depending on tco in pr mode"
		0x8006663e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tco_rij
		"X breakpoints for cartography of maf correction depending on tco in rij mode"
		0x80067e7e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tia_pp
		"X breakpoints for cartography of maf corrected by tia  in pp mode"
		0x800659c0
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tia_pr
		"X breakpoints for cartography of maf corrected by tia in pr mode"
		0x8006661c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tia_rij
		"X breakpoints for cartography of maf corrected by tia in rij mode"
		0x80067e5c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tkof_pp
		"X breakpoints for cartography of maf correction depending of take in pp mode"
		0x800659b2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_m_maf_cor_tkof_rij
		"X breakpoints for cartography of maf correction depending on take off in rij mode."
		0x80067e4e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_amp_pp
		"X breakpoints for curve of corrector factor for maf depending on amp in pp mode"
		0x80065990
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		16
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_amp_pr
		"X breakpoints for curve of corrector factor for maf depending on amp if pr mode is on"
		0x800665fa
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		16
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_amp_rij
		"X breakpoints for curve of corrector factor for maf depending on amp in rij mode"
		0x80067e2c
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		16
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsbcx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_egr_byp_on
		"X breakpoints for the cartography of multiplicative factor"
		0x80063f98
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_prs_ratio_pp
		"X breakpoints for cartography of maf correction depending on pressure variation (pft) in pp mode"
		0x8006596e
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		16
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_prs_ratio_pr
		"X breakpoints for cartography of maf correction depending on pressure variation (pft) in pr mode"
		0x800665d8
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		16
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_prs_ratio_rij
		"X breakpoints for cartography of maf correction depending on pressure variation (pft)"
		0x80067e0a
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		16
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tco_pp
		"X breakpoints for curve of corrector factor for maf depending of tco if pp mode is on"
		0x8006594c
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tco_pr
		"X breakpoints for curve of corrector factor for maf depending of tco if pr mode is on"
		0x800665b6
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tco_rij
		"X breakpoints for curve of corrector factor for maf depending on tco in rij mode"
		0x80067de8
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tia_pp
		"X breakpoints for curve of corrector factor for maf depending on tia if pp mode is on"
		0x8006592a
		Vxx_tia_cor
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tia_pr
		"X breakpoints for curve of corrector factor for maf depending on tia if pr mode is on"
		0x80066594
		Vxx_tia_cor
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tia_rij
		"X breakpoints for curve of corrector factor for maf depending on tia in rij mode"
		0x80067dc6
		Vxx_tia_cor
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tkof_pp
		"X breakpoints for curve of corrector factor for maf depending on tkof in pp mode"
		0x80065922
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		6
		0.
		1.
    FORMAT "%9.7" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_cor_tkof_rij
		"X breakpoints for curve of corrector factor for maf depending on take off in rij mode"
		0x80067dbe
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		6
		0.
		1.
    FORMAT "%9.7" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_max_lim
		"X breakpoints for the map of the max. limitation of the maf sp"
		0x800641d8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_reg_fac_pft_cor
		"X breakpoints for cartography of maf regulator gains correction depending on CSF equivalent load"
		0x80063ea0
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		16
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_reg_fac_tia_tco_cor
		"X breakpoints for cartography of maf regulator gains correction depending on tia or tco"
		0x80063e7e
		Vxx_maf_reg_fac_tia_tco_cor
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_cor_prs_pp
		"X breakpoints for cartography of maf correction depending on pressure variation (pft) in pp mode"
		0x80065900
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_cor_prs_pr
		"X breakpoints for cartography of maf setpoints for back-pressure corrections in pr mode"
		0x80066572
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_cor_prs_rij
		"X breakpoints for cartography of maf setpoints for back-pressure corrections"
		0x80067d9c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_emtv_psn_sp_pp
		"X breakpoints for the map for egr valve lift setpoint in rgn_prmt mode"
		0x800623d6
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_emtv_psn_sp_pr
		"X breakpoints for the map for egr valve lift setpoint in rgn mode"
		0x8006261a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_emtv_psn_sp_rij
		"X breakpoints for the map for egr valve lift setpoint in rij mode"
		0x8006285e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear
		"as_maf_spt_mafsri/ X breakpoints for the adaptation of the current gear value"
		0x80067d92
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%4.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_1_pp
		"X breakpoints for cartography of maf setpoints for gear 1 (or neutral or reverse gear) in pp mode"
		0x800658de
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_1_rij
		"X breakpoints for cartography of maf setpoints for gear 1 (or neutral or reverse gear) in rij mode"
		0x80067d70
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_2_pp
		"X breakpoints for cartography of maf setpoints for gear 2 in pp mode"
		0x800658bc
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_2_rij
		"X breakpoints for cartography of maf setpoints for gear 2 in rij mode"
		0x80067d4e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_3_pp
		"X breakpoints for cartography of maf setpoints for gear 3 in pp mode"
		0x8006589a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_3_rij
		"X breakpoints for cartography of maf setpoints for gear 3 in rij mode"
		0x80067d2c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_4_pp
		"X breakpoints for cartography of maf setpoints for gear 4 in pp mode"
		0x80065878
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_4_rij
		"X breakpoints for cartography of maf setpoints for gear 4 in rij mode"
		0x80067d0a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_5_pp
		"X breakpoints for cartography of maf setpoints for gear 5 in pp mode"
		0x80065856
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_5_rij
		"X breakpoints for cartography of maf setpoints for gear 5 in rij mode"
		0x80067ce8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_6_pp
		"X breakpoints for cartography of maf setpoints for gear 6 in pp mode"
		0x80065834
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_gear_6_rij
		"X breakpoints for cartography of maf setpoints for gear 6 in rij mode"
		0x80067cc6
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_maf_sp_pr
		"X breakpoints for cartography of maf setpoints in pr mode"
		0x80066550
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_n_vnt_sge_on_h_thd_pr
		"X Breakpoint of high thresholds for anti-surge mode hysteresis for pr mode"
		0x8005d510
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_n_vnt_sge_on_h_thd_rij
		"X Breakpoint of high thresholds for anti-surge mode hysteresis for rij mode"
		0x8005d7ce
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_n_vnt_sge_on_l_thd_pr
		"X Breakpoint of low thresholds for anti-surge mode hysteresis for pr mode"
		0x8005d4fa
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_n_vnt_sge_on_l_thd_rij
		"X Breakpoint of low thresholds for anti-surge mode hysteresis for rij mode"
		0x8005d7b8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_n_vnt_sge_t_pr
		"X breakpoints for activation time of anti-surge mode on pr mode"
		0x8005d4e4
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_n_vnt_sge_t_rij
		"X breakpoints for activation time of anti-surge mode on rij mode"
		0x8005d7a2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_pft_sp_max_rij
		"Breakpoints x for setpoint limitation for regular injection mode"
		0x8006004a
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		10
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_pft_spg_sp_max_pr
		"Breakpoints x for setpoint limitation depending on CSF  soot mass in regeneration mode"
		0x8005f84a
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		10
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_pft_vnt_ctl_ofs
		"as_bst_ctl_bpolcri/X breakpoints for pre-control offset map depending on soot mass in rij and pp mode"
		0x8005ea1c
		Vxx_csm_cyl_comb
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_pft_vnt_ctl_ofs_pr
		"X breakpoints for pre-control offset map depending on soot mass in PR and NPU modes"
		0x8005e02e
		Vxx_csm_cyl_comb
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_amp_cor_pr
		"Breakpoints x for atmospheric pressure correction of b.a.p setpoint in regeneration"
		0x8005f828
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_amp_cor_rij
		"Breakpoints x for atmospheric pressure correction of b.a.p setpoint in regular injection mode"
		0x80060028
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_bas_pr
		"Breakpoint x for basic boost air pressure setpoint in regeneration mode"
		0x8005f806
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_bas_rij
		"Breakpoint x for basic boost air pressure setpoint in regular injection mode"
		0x80060006
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_ex_df_cor_pr
		"Breakpoints x for basic air temperature correction in case of exhaust pressure sensor limphome in particule filter regeneration injection"
		0x8005f7e4
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_ex_df_cor_rij
		"Breakpoints x for basic air temperature correction in case of exhaust pressure sensor limphome in regular injection mode."
		0x8005ffe4
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_tia_cor_pr
		"Breakpoint x for basic air temperature correction in regeneration mode"
		0x8005f7c2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_spg_sp_tia_cor_rij
		"Breakpoints y for basic air temperature correction in regular injection mode"
		0x8005ffc2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tco_cor_egrless
		"The x breakpoints of the engine tempearture correction curve"
		0x80057382
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tia_cor_egrless
		"The x breakpoints of the ambiant temperature correction curve"
		0x8005736e
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tia_spg_sp_cor_pr
		"Breakpoints x for boost air pressure setpoint intake temperature correction for regeneration mode"
		0x8005f7b2
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tia_spg_sp_cor_rij
		"Breakpoints x for boost air pressure setpoint intake temperature correction in regular injection."
		0x8005ffb2
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tran_off_t
		""
		0x800437b8
		Vxx_gear_df_tran
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tran_off_thd
		"X breakpoints for Cmp_gear_n_tran_off_thd"
		0x800437b0
		Vxx_gear_df_tran
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tran_on_thd
		"X breakpoints for Cmp_gear_n_tran_on_thd"
		0x800437a8
		Vxx_gear_df_tran
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tran_open_pwm
		"X breakpoints for Cmp_gear_n_tran_open_pwm"
		0x800437a0
		Vxx_gear_df_tran
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%4.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_tran_open_t
		"X breakpoints for Cmp_gear_n_tran_open_t"
		0x80043798
		Vxx_gear_df_tran
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%4.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_cold_sta_dly
		"Breakpoints x for curve Ctx_tco_vnt_cold_sta_dly"
		0x80043462
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		10
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_amp_pr
		"Breakpoints x for atmospheric pressure correction of vnt control value for regeneration"
		0x8005e01e
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		7
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_amp_rij
		"Breakpoints x for atmospheric pressure correction of vnt control value"
		0x8005ea0c
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		7
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_amp_pr
		"Breakpoints x atmospheric pressure correction for vnt control value in regeneration mode"
		0x8005dffc
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_amp_rij
		"Breakpoints x atmospheric pressure correction for vnt control value"
		0x8005e9ea
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_pr
		"Breakpoints x for basic vnt control value in regeneration mode"
		0x8005dfda
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_rij
		"Breakpoints x for basic vnt control value"
		0x8005e9c8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_tco_rij
		"Breakpoints x forengine coolant temperature basic correction of vnt control value"
		0x8005e9a6
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_tia_pr
		"Breakpoints x for intake air temperature basic correction of vnt control value in regeneration mode"
		0x8005dfb8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_tia_rij
		"Breakpoints x for intake air temperature basic correction of vnt control value"
		0x8005e984
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_tkof_pr
		"Breakpoints x of take off assistance basic correction for vnt control value in PR mode"
		0x8005dfaa
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_bas_tkof_rij
		"Breakpoints x of take off assistance basic correction for vnt control value"
		0x8005e976
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_ex_df_pr
		"Breakpoints x for exhaust pressure sensor limphome correction of vnt control value in pr mode."
		0x8005df88
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_ex_df_rij
		"Breakpoints x for exhaust pressure sensor limphome correction of vnt control value in rij mode."
		0x8005e954
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_tco_rij
		"Breakpoints x for engine coolant temperature correction of vnt control value"
		0x8005e944
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_tia_pr
		"Breakpoints x for intake air temperature correction of vnt control value for regeneration"
		0x8005df78
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_tia_rij
		"Breakpoints x for intake air temperature correction of vnt control value"
		0x8005e934
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_tkof_pr
		"Breakpoints x for take off assistance factor correction of vnt control value in PR mode"
		0x8005df70
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		7
		0.
		1.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ctl_tkof_rij
		"Breakpoints x for take off assistance factor correction of vnt control value"
		0x8005e92c
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		7
		0.
		1.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_lih_cdn
		"Breakpoints x for curve Ctm_stt_vnt_diag_lih_cdn"
		0x80043451
		Vsx_vnt_diag_stt
		RSA_RecordLayout_Axis_UBYTE
		18
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		16
		0.
		18.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_lih_fac
		"Breakpoint s for curve Ctx_stt_vnt_diag_lih_fac"
		0x80043440
		Vsx_vnt_diag_stt
		RSA_RecordLayout_Axis_UBYTE
		18
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		16
		0.
		18.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_lih_ofs
		"Breakpoint s for curve Ctx_stt_vnt_diag_lih_ofs"
		0x8004342f
		Vsx_vnt_diag_stt
		RSA_RecordLayout_Axis_UBYTE
		18
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		16
		0.
		18.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_lih_set
		"Breakpoints for curve Ctx_stt_vnt_diag_lih_set"
		0x8004341e
		Vsx_vnt_diag_stt
		RSA_RecordLayout_Axis_UBYTE
		18
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		16
		0.
		18.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_stt_off_pr
		"Breakpoints x for curve Ctp_n_vnt_diag_stt_off_pr"
		0x8005eb6e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_stt_off_rij
		"Breakpoints x for curve Ctp_n_vnt_diag_stt_off_rij"
		0x8005ecc0
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_stt_on_pr
		"Breakpoints x for curve Ctp_n_vnt_diag_stt_on_pr"
		0x8005eb58
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_diag_stt_on_rij
		"Breakpoints x for curve Ctp_n_vnt_diag_stt_on_rij"
		0x8005ecaa
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ex_reg_i_fac_pr
		"X breakpoints for curve of correction factor of I part for exhaust pressure limitation"
		0x8005d4ce
		Vxx_csm_cyl_comb
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ex_reg_i_fac_rij
		"X breakpoints for curve of correction factor of I part for exhaust pressure limitation"
		0x8005d78c
		Vxx_csm_cyl_comb
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ex_reg_max
		"X Breakpoints for curve of maximum VNT governor pwm  in exhaust pressure limitation mode"
		0x8005d252
		Vxx_csm_cyl_comb
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_ex_reg_min
		"X Breakpoints for curve of minimum VNT governor pwm"
		0x8005d23c
		Vxx_csm_cyl_comb
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_pft_max_lim
		"Breakpoints of fuel flow ( l/h ) for vnt max rco limitation map"
		0x8005d226
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_pwm_i_rst
		"Engine speed breakpoints for integral re-initialization"
		0x8005ef36
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_dfz_fac_pr
		"X breakpoints for curve of formatting factor correction gain for pr mode"
		0x8005d4b8
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_dfz_fac_rij
		"X breakpoints for curve of formatting factor correction gain for rij mode"
		0x8005d776
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_i_fac_neg
		"X breakpoints for curve of factor of I part in the negative window"
		0x8005d21e
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_i_fac_pos
		"X breakpoints for curve of factor of I part in the positive window"
		0x8005d216
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_i_fac_pr
		"X breakpoints for curve of correction factor of I part"
		0x8005d4a2
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_i_fac_rij
		"X breakpoints for curve of correction factor of I part"
		0x8005d760
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_i_fac_sig
		"X breakpoints for curve of factor of I part in the window"
		0x8005d20e
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_i_win_neg
		"X breakpoints for values of i part negative window"
		0x8005d206
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_i_win_pos
		"X breakpoints for values of i part positive window"
		0x8005d1fe
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		7
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_reg_min
		"X Breakpoints for curve of minimum VNT governor pwm"
		0x8005d1e8
		Vxx_csm_cyl_comb
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_sge_emtv_req_pp
		"X breakpoint for VNT antisurge request value of emtv position in pp mode"
		0x80061b5e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_sge_emtv_req_pr
		"X breakpoint for VNT antisurge request value of emtv position in pr mode"
		0x80061e4e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_sge_emtv_req_rij
		"X breakpoint for VNT antisurge request value of emtv position in rij mode"
		0x8006213e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_stt_cor_pr
		"X Breakpoints for open loop activation thresholds correction in pft regeneration mode."
		0x8005eb42
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_stt_cor_rij
		"X Breakpoints for open loop activation thresholds correction in regular injection mode"
		0x8005ec94
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_tran_amp_cor
		"X breakpoints for atmospheric pressure correction  applied to rco saturation maps"
		0x80043782
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		10
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_tran_pwm_pr
		"X breakpoints for transient saturation rco command in regeneration mode"
		0x8005d48c
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_x_vnt_tran_pwm_rij
		"X breakpoints for transient saturation rco command in regular injection mode"
		0x8005d74a
		Vxx_csm
		RSA_RecordLayout_Axis_UWORD
		100
		uztFExb_owBhqra_ykamwda_l__000a
		10
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_amp_sp_max
		"Breakpoints y for setpoint limitation"
		0x80043a48
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		10
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_cpr_rat_vnt_sge_t_pr
		"Y breakpoints for activation time of anti-surge mode on pr mode"
		0x8005d476
		Vxx_cpr_rat_pr
		RSA_RecordLayout_Axis_UWORD
		5
		lasreaa_cardnzb_hCDtpsa_n__a00a
		10
		0.
		5.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_cpr_rat_vnt_sge_t_rij
		"Y breakpoints for activation time of anti-surge mode on rij mode"
		0x8005d734
		Vxx_cpr_rat_rij
		RSA_RecordLayout_Axis_UWORD
		5
		lasreaa_cardnzb_hCDtpsa_n__a00a
		10
		0.
		5.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_efy_cpr
		"Y-breakpoints for compressor efficiency map"
		0x80057c68
		Vxx_cpr_prs_rat
		RSA_RecordLayout_Axis_UWORD
		5
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		16
		0.
		5.
    FORMAT "%6.4" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_efy_spg_cool
		"Y-breakpoints for supercharger cooler efficiency map"
		0x80057c46
		Vxx_vs_sat
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		16
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_egr_byp_tco_hys_low
		"Y breakpoints for hysteresis cartography"
		0x8006029c
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_egr_cut_tqi_thd_pp
		"X breakpoints for the map of EGR cut depending on torque in pp mode"
		0x80061832
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_egr_cut_tqi_thd_pr
		"Y breakpoints for the map of EGR cut depending on torque in pr mode"
		0x80061829
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_egr_cut_tqi_thd_rij
		"Y breakpoints for the map of EGR cut depending on torque in rij mode"
		0x80061820
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_egr_maf_reg_min_lim
		"Y breakpoints for the map of PI governor minimal output value"
		0x80063e5c
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_emtv_sp_max_pp
		"Y Bkp for MAP for egr valve position threshold value in pp mode"
		0x80061b44
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_emtv_sp_max_pr
		"Y Bkp for MAP for egr valve position threshold value in pr mode"
		0x80061e34
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_emtv_sp_max_rij
		"Y Bkp for MAP for egr valve position threshold value in rij mode"
		0x80062124
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_eng_vol_efy_ex
		"The y breakpoints of exhaust volumetric efficiency map"
		0x8005734c
		Vxx_air_dens_ex
		RSA_RecordLayout_Axis_UWORD
		5
		yvyupqb_iFBfdid_awzApyb_kE__0a0
		16
		0.
		5.
    FORMAT "%6.4" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_eng_vol_efy_in
		"The y breakpoints of intake volumetric efficiency map"
		0x8005732a
		Vxx_air_dens_in
		RSA_RecordLayout_Axis_UWORD
		5
		yvyupqb_iFBfdid_awzApyb_kE__0a0
		16
		0.
		5.
    FORMAT "%6.4" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_it_psn_max_pp
		"Y breakpoints for Cmp_n_tqi_itp_max_rgn_prmt"
		0x80061b2a
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_it_psn_max_pr
		"Y breakpoints for Cmp_n_tqi_itp_max_rgn"
		0x80061e1a
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_it_psn_max_rij
		"Y breakpoints for Cmp_n_tqi_itp_max in rij mode"
		0x8006210a
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_it_sat_val_bas_pp
		"Y breakpoints for cartography of thr sat setpoints in permanent regeneration mode"
		0x80062e26
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_it_sat_val_bas_pr
		"Y breakpoints for cartography of thr sat setpoints in rgn mode"
		0x8006345c
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_it_sat_val_bas_rij
		"Y breakpoints for cartography of thr sat setpoints in regular injection mode"
		0x80063a94
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_amp_pp
		"Y breakpoints for cartography of thr sat corrected by amp in rgn_prmt mode"
		0x80062e04
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_amp_pr
		"Y breakpoints for cartography of thr sat corrected by amp in rgn mode"
		0x8006343a
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_amp_rij
		"Y breakpoints for cartography of thr sat corrected by amp in rij mode"
		0x80063a72
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_tco_pp
		"Y breakpoints for cartography of thr sat corrected by tco in rgn_prmt mode"
		0x80062df2
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_tco_pr
		"Y breakpoints for cartography of thr sat corrected by tco in rgn mode"
		0x80063428
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_tco_rij
		"Y breakpoints for cartography of thr sat corrected by tco in rij mode"
		0x80063a60
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_tia_pp
		"Y breakpoints for cartography of thr sat corrected by tia in rgn_prmt mode"
		0x80062de0
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_tia_pr
		"Y breakpoints for cartography of thr sat corrected by tia in rgn mode"
		0x80063416
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_it_sat_cor_tia_rij
		"Y breakpoints for cartography of thr sat corrected by tia in rij mode"
		0x80063a4e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_amp_pp
		"Y breakpoints for cartography of maf corrected by amp in pp mode"
		0x80065812
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_amp_pr
		"Y breakpoints for cartography of maf corrected by amp in pr mode"
		0x8006652e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_amp_rij
		"Y breakpoints for cartography of maf corrected by amp in rij mode"
		0x80067ca4
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tco_pp
		"Y breakpoints for cartography of maf corrected by tco in pp mode"
		0x800657f0
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tco_pr
		"Y breakpoints for cartography of maf corrected by tco in pr mode"
		0x8006650c
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tco_rij
		"Y breakpoints for cartography of maf corrected by tco in rij mode"
		0x80067c82
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tia_pp
		"Y breakpoints for cartography of maf corrected by tia   in pp mode"
		0x800657ce
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tia_pr
		"Y breakpoints for cartography of maf corrected by tia   in pr mode"
		0x800664ea
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tia_rij
		"Y breakpoints for cartography of maf corrected by tia   in rij mode"
		0x80067c60
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tkof_pp
		"Y breakpoints for cartography of maf corrected by take in pp mode"
		0x800657c0
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		6
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_m_maf_cor_tkof_rij
		"Y breakpoints for cartography of maf corrected by take off in rij mode."
		0x80067c52
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		6
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsbcx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_cor_egr_byp_on
		"Y breakpoints for the cartography of multiplicative factor"
		0x80063f86
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_max_lim
		"Y breakpoints for the map of the max. limitation of the maf sp"
		0x800641b6
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_cor_prs_pp
		"Y breakpoints for cartography of maf setpoints for back-pressure corrections in pp mode"
		0x8006579e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_cor_prs_pr
		"Y breakpoints for cartography of maf setpoints for back-pressure corrections in pr mode"
		0x800664c8
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_cor_prs_rij
		"Y breakpoints for cartography of maf setpoints for back-pressure corrections"
		0x80067c30
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpp_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_emtv_psn_sp_pp
		"Y breakpoints for the map for egr valve lift setpoint in rgn_prmt mode"
		0x800623b4
		Vxx_maf_sp_lim
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_emtv_psn_sp_pr
		"Y breakpoints for the map for egr valve lift setpoint in rgn mode"
		0x800625f8
		Vxx_maf_sp_lim
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_emtv_psn_sp_rij
		"Y breakpoints for the map for egr valve lift setpoint in rij mode"
		0x8006283c
		Vxx_maf_sp_lim
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_1_pp
		"Y breakpoints for cartography of maf setpoints for gear 1 (or neutral or reverse gear) in pp mode"
		0x8006577c
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_1_rij
		"Y breakpoints for cartography of maf setpoints for gear 1 (or neutral or reverse gear) in rij mode"
		0x80067c0e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_2_pp
		"Y breakpoints for cartography of maf setpoints for gear 2 in pp mode."
		0x8006575a
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_2_rij
		"Y breakpoints for cartography of maf setpoints for gear 2 in rij mode"
		0x80067bec
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_3_pp
		"Y breakpoints for cartography of maf setpoints for gear 3 in pp mode."
		0x80065738
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_3_rij
		"Y breakpoints for cartography of maf setpoints for gear 3 in rij mode"
		0x80067bca
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_4_pp
		"Y breakpoints for cartography of maf setpoints for gear 4 in pp mode."
		0x80065716
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_4_rij
		"Y breakpoints for cartography of maf setpoints for gear 4 in rij mode"
		0x80067ba8
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_5_pp
		"Y breakpoints for cartography of maf setpoints for gear 5 in pp mode."
		0x800656f4
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_5_rij
		"Y breakpoints for cartography of maf setpoints for gear 5 in rij mode"
		0x80067b86
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_6_pp
		"Y breakpoints for cartography of maf setpoints for gear 6 in pp mode."
		0x800656d2
		Vxx_egr_tqi
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_gear_6_rij
		"Y breakpoints for cartography of maf setpoints for gear 6 in rij mode"
		0x80067b64
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_maf_sp_pr
		"Y breakpoints for cartography of maf setpoints in pr mode"
		0x800664a6
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_pft_sp_max_rij
		"Breakpoints y for setpoint limitation in regular injection mode"
		0x8005ff9c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_pft_spg_sp_max_pr
		"Breakpoints y for setpoint limitation depending on CSF soot mass in regenration mode"
		0x8005f79c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_pft_vnt_ctl_ofs
		"as_bst_ctl_bpolcri/Y breakpoints for pre-control offset map depending on soot mass in rij and pp modes"
		0x8005e916
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		10
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_pft_vnt_ctl_ofs_pr
		"Y  breakpoints for pre-control offset map depending on soot mass  in PR or NPU modes"
		0x8005df5a
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		10
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_amp_cor_pr
		"Breakpoints y for atmospheric pressure correction of b.a.p setpoint in regeneration mode"
		0x8005f786
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_amp_cor_rij
		"Breakpoints y for atmospheric pressure correction of b.a.p setpoint in regular injection mode."
		0x8005ff86
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_bas_pr
		"Breakpoint y for basic boost air pressure setpoint in regeneration mode"
		0x8005f764
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_bas_rij
		"Breakpoint y for basic boost air pressure setpoint in regular injection mode"
		0x8005ff64
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_ex_df_cor_pr
		"Breakpoints y for basic air temperature correction in case of exhaust pressure sensor limphome in particule filter regeneration injection"
		0x8005f74e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_ex_df_cor_rij
		"Breakpoints y for basic air temperature correction in case of exhaust pressure sensor limphome in regular injection mode."
		0x8005ff4e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_tia_cor_pr
		"Breakpoints y for basic air temperature correction in particulate filter regeneration  mode"
		0x8005f738
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_spg_sp_tia_cor_rij
		"Breakpoints y for basic air temperature correction in regular  injection mode"
		0x8005ff38
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_tran_off_t
		"Y breakpoints for Cmp_gear_n_tran_off_t"
		0x8004376c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_tran_off_thd
		"Y breakpoints for Cmp_gear_n_tran_off_thd"
		0x8004375e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_tran_on_thd
		"Y breakpoints for Cmp_gear_n_tran_on_thd"
		0x80043750
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_tran_open_pwm
		"Y breakpoints for Cmp_gear_n_tran_open_pwm"
		0x8004373a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_tran_open_t
		"Y breakpoints for Cmp_gear_n_tran_open_t"
		0x80043724
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_amp_pr
		"Breakpoints y for atmospheric pressure correction for vnt control value in  regeneration mode"
		0x8005df44
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_amp_rij
		"Breakpoints y for atmospheric pressure correction for vnt control value"
		0x8005e900
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_pr
		"Breakpoints y for basic vnt control value in regeneration mode"
		0x8005df22
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_rij
		"Breakpoints y for basic vnt control value in regular injection mode"
		0x8005e8de
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_tco_rij
		"Breakpoints y for engine coolant temperature basic correction of vnt control value"
		0x8005e8c8
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_tia_pr
		"Breakpoints y for intake air temperature basic correction of vnt control value in regeneration mode"
		0x8005df0c
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_tia_rij
		"Breakpoints y for intake air temperature basic correction of vnt control value"
		0x8005e8b2
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_tkof_pr
		"Breakpoints y for take off assistance basic correction for vnt control value in PR mode"
		0x8005defe
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		6
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_bas_tkof_rij
		"Breakpoints y for take off assistance basic correction for vnt control value"
		0x8005e8a4
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		6
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_ex_df_pr
		"Breakpoints y for exhaust pressure sensor limphome correction of vnt control value in pr mode."
		0x8005dee8
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_ctl_ex_df_rij
		"Breakpoints y for exhaust pressure sensor limphome correction of vnt control value in rij mode."
		0x8005e88e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_pft_max_lim
		"Breakpoints of soot mass stored in the catalytic soot  filter for vnt max rco limitation map"
		0x8005d1d2
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		10
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_pwm_i_rst
		"Torque raw breakpoints for integral re-initialization"
		0x8005ef20
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdpprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_stt_cor_pr
		"Y Breakpoints  for open loop activation thresholds correction map in pft regeneration mode."
		0x8005eb2c
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		10
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdprijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_stt_cor_rij
		"Y Breakpoints  for open loop activation thresholds correction map in regular injection mode."
		0x8005ec7e
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		10
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_tran_pwm_pr
		"Y breakpoints for transient saturation rco command in regeneration mode"
		0x8005d460
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		10
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_y_vnt_tran_pwm_rij
		"Y breakpoints for transient saturation rco command in regular injection mode"
		0x8005d71e
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		10
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ntb_coup
		"Coupler state breakpoint (1=close; 2=sliding; 8=open)"
		0x80058838
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		3
		0.
		255.
    FORMAT "%3.0" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ntb_gear
		"Gearbox ratio breakpoint"
		0x8005882f
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%2.0" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_msswixx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ntb_pft_sot_ms_cor
		"Breakpoint for mass type choice dependent of driver type"
		0x80046b6b
		AtPftMng_NVM.Vsx_pft_rgn_cdn_tgt_NVM
		RSA_RecordLayout_Axis_UBYTE
		2
		ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf
		3
		0.
		2.
    FORMAT "%6.3" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin AXIS_PTS
		Ntb_req_fms_comb_mod_swi_t
		"Bench mode activation for combustion mode"
		0x8004eaf4
		Vsx_comb_mod_req
		RSA_RecordLayout_Axis_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		8
		0.
		15.
    FORMAT "%2.0" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ntb_tco_fms_pinj_cut
		"index breakpoint of coolant temperature"
		0x8004c5b7
		Vxx_fms_pinj_cut_tco
		RSA_RecordLayout_Axis_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		8
		1.
		8.
    FORMAT "%3.0" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ntb_tia_fms_pinj_cut
		"Index breakpoint of intake air temperature"
		0x8004c5ae
		Vxx_fms_pinj_cut_tia
		RSA_RecordLayout_Axis_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		8
		1.
		8.
    FORMAT "%3.0" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ntx_pft_intv_ind_sum_rat
		"Temporary constant array whose 16 val = proba [dist to following opp < each dist interval between opp / same proba for all dist intv)"
		0x80046ce7
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UBYTE
		0.9375
		ftmodod_Ffszhha_Fbvahrc_n_R0ooa
		16
		0.0625
		1.
    FORMAT "%7.5" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ac_cold_loop_in_ecm
		"Boolean to set cold loop inside or outside ECM (1= cold loop inside ECM)"
		VALUE
		0x8005ceea
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_ac_cold_loop_in_ecm 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ac_max_pow_ena_cfm
		"Activation of air conditioning power limitation strategy"
		VALUE
		0x8005cdc7
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ac_max_pow_ena_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_acel_is_ac_dsb_cfm
		"Activation of air conditioning accelerated idle speed strategy"
		VALUE
		0x8005cdc6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_acel_is_ac_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_acel_pdl_fmt_mnl_cfm
		"Selects a manual interpolation factor between pedal progressivity maps (for tuning purposes)"
		VALUE
		0x80059c2c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_acel_pdl_fmt_mnl_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_acel_pdl_lvl_cfm
		"Activation of a torque level to help in the calibration of the pedal limp home regulators"
		VALUE
		0x80059d28
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_acel_pdl_lvl_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcaplou_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cbx_acel_pdl_rat_secu_1_cfm
		"Configuration of the value sent on CAN during detected failure of reversible pedal safety case"
		VALUE
		0x8006b1ff
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_acel_pdl_rat_secu_1_cfm 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_acel_pdl_secu_2_cfm
		"bit of configuration to set accelerator pedal safety case N°2 irreversible"
		VALUE
		0x800587f6
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_acel_pdl_secu_2_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_acel_pdl_secu_acc_cfm
		"bit of configuration to disable ACC condition for accelerator pedal safety case"
		VALUE
		0x800587f5
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_acel_pdl_secu_acc_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_acel_pdl_secu_esp_cfm
		"bit of configuration to disable ASR/MSR/AYC conditions for accelerator pedal safety case"
		VALUE
		0x800587f4
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_acel_pdl_secu_esp_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_agb_csm_ofs_cfm
		"Configuration boolean, To calculate the torque offset to estimate the gearbox losses"
		VALUE
		0x8005861c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_agb_csm_ofs_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_agb_csm_slop_cfm
		"Flag to disable the slew rate on the converter torque losses"
		VALUE
		0x8005861b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_agb_csm_slop_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_agb_csm_tq_temp_cfm
		"Configuration boolean, To calculate the thermic dependence according to water temperature or oil temperature"
		VALUE
		0x8005861a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_agb_csm_tq_temp_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_agb_driv_spt_fac_cfm
		"Selection of driving style indicator calculated by Automatic Transmission"
		VALUE
		0x80059198
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_agb_driv_spt_fac_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_cor_driv_cut_cfm
		"Boolean calibration to cut AJCOR if an injection cut is requested"
		VALUE
		0x80040a1c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_cor_driv_cut_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_cor_dz_cfm
		"Boolean calibration to active AJCOR dead zone"
		VALUE
		0x80040a1b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_cor_dz_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_cor_is_cfm
		"Boolean calibration to enable (=1) AJCOR function when idle speed regulation is active"
		VALUE
		0x80040a1a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_cor_is_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_cor_stt_cfm
		"Boolean calibration to deactivate AJCOR function (0) manually"
		VALUE
		0x80040a19
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_cor_stt_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_dt_open_slk_cfm
		"Boolean calibration to allow (=1) slack effect strategy with an open drivetrain (AJSPV 3 & 4 states)."
		VALUE
		0x8005a722
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_dt_open_slk_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_dt_slk_cfm
		"a_pc_paj_ctl_ajspvxx_xxx_xx_x_a/Boolean calibration to cut (0) slack effect strategy in AJMOD"
		VALUE
		0x80059d71
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_dt_slk_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_fast_cor_cfm
		"Boolean calibration to deactivate (=0) the boost of the curative anti-jerk function."
		VALUE
		0x8005a721
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_fast_cor_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_modu_stt_cfm
		"Boolean calibration to deactivate AJMOD function (0) manually"
		VALUE
		0x80059d70
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_modu_stt_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_modu_td_dec_cfm
		"Boolean calibration to block (=1) the decrease of td_acel in acceleration state, and so for td_decl"
		VALUE
		0x80059d6f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_modu_td_dec_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_no_drag_cfm
		"Boolean calibration to deactivate (=0) the strategy for drag error correction."
		VALUE
		0x8005a720
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_no_drag_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_slk_td_cfm
		"Boolean calibration to autorize (1) manually the slack effect for td parameter"
		VALUE
		0x80059d6e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_slk_td_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_spv_cut_cfm
		"Boolean calibration to select the tip-in condition in the case of a re-injection (=1) to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a71f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_spv_cut_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_spv_grd_cfm
		"Boolean calibration to select the driver conditions (=1 based on torque observation, = 0 based on pedal observation) to enable the boost of the curative anti-jerk function."
		VALUE
		0x8005a71e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_spv_grd_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_spv_stt_cfm
		"Boolean calibration to deactivate (=0) preventive et curative anti-jerk functions"
		VALUE
		0x8005a71d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_spv_stt_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ajs_tqe_slk_cfm
		"Boolean calibration to select the torque observed (=1 to select an estimation of the engine torque, =0 the filtered torque setpoint) to activate the slack-effect strategy."
		VALUE
		0x8005a71c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ajs_tqe_slk_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_alt_pwm_nok_cut_ena
		"cl_coo_ctl_chctlxx/ Allows to cut heaters if an invalid AlternatorLoad is received (= 1)"
		VALUE
		0x8005526b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_alt_pwm_nok_cut_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_alt_pwm_pres
		"cl_coo_ctl_chctlxx/ Alternator PWM load signal present"
		VALUE
		0x8005cf48
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_alt_pwm_pres 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_alt_typ
		"cl_coo_ctl_chctlxx/ Alternator type"
		VALUE
		0x8005cf47
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_alt_typ 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ant_coup_clos_clc_cfm
		"Determination of an anticipate coupler state when the coupler is closing"
		VALUE
		0x8005886a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ant_coup_clos_clc_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_antxxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ant_crt_slc_pres_cfm
		"AnticipatedCurrentShift information is provided by CAN"
		VALUE
		0x800585ea
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ant_crt_slc_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ant_gear_coup_cut_ct_ena
		"Consolidation of the gearbox ratio with the coupler state in egb configuration"
		VALUE
		0x8004331c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ant_gear_coup_cut_ct_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_apmp_ena_cfm
		"Cbx_apmp_ena_cfm"
		VALUE
		0x8005926c
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_bgin_clu_fail_ccp_ena
		"Enabling boolean for ccp clutch coherence"
		VALUE
		0x80059153
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_bgin_clu_fail_ccp_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_bgin_clu_fail_cfm
		"Choice of degraded calculation of clutch state"
		VALUE
		0x80058869
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_bgin_clu_fail_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_bgin_clu_fail_co_ena
		"Enabling boolean for co clutch coherence"
		VALUE
		0x80059152
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_bgin_clu_fail_co_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_bgin_clu_off_dg_cfm
		"Diag contactor always off activation"
		VALUE
		0x8006b23d
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_bgin_clu_off_dg_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_bgin_clu_on_dg_cfm
		"Diag contactor always on activation"
		VALUE
		0x8006b23c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_bgin_clu_on_dg_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_brk_ass_ena_cfm
		"Cbx_brk_ass_ena_cfm"
		VALUE
		0x80059364
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_brk_fail_ccp_ena
		"Enabling boolean for ccp brake coherence"
		VALUE
		0x80059151
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_brk_fail_ccp_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_brk_fail_co_ena
		"Enabling boolean for co brake coherence"
		VALUE
		0x80059150
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_brk_fail_co_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_cold_sta_cfm
		"booleen to inhibate vnt cold start state"
		VALUE
		0x80043398
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_cold_sta_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_comb_mod_bch_mod
		"Bench mode activation for combustion mode"
		VALUE
		0x8004ea72
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_comb_mod_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cru_blk_cfm
		"Cbx_cru_blk_cfm"
		VALUE
		0x8005935c
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cru_diag_add_on
		"Activate the cruise control diagnostic add-on (1= activated)"
		VALUE
		0x80059174
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_cru_diag_add_on 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dsbccxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cru_eng_dsb_wal_1_req_cfm
		"Configuration bit for cruise control deactivation by engine control on warning lamp level 1 request."
		VALUE
		0x8005917a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_cru_eng_dsb_wal_1_req_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dsbccxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cru_sl_eng_dsb_vld_cfm
		"Configuration bit for cruise control and speed limiter deactivation by engine control on IVLD"
		VALUE
		0x80059179
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_cru_sl_eng_dsb_vld_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cru_sl_lk_rls_ena
		"Connection detection with the release position authorized (1 = authorized)"
		VALUE
		0x8005882d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_cru_sl_lk_rls_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cru_sl_swi_chr_prmt
		"The CC/SL failure due to main switch incoherence is irreversible"
		VALUE
		0x8005882c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_cru_sl_swi_chr_prmt 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cru_sl_vs_cmp_prmt
		"The CC/SL failure due to vehicle speed incoherence is irreversible (1 = irreversible)"
		VALUE
		0x800401d4
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_cru_sl_vs_cmp_prmt 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_cur_ena_cfm
		"Cbx_cur_ena_cfm"
		VALUE
		0x8005935b
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_diag_dsb_egr_byp_blk_cfm
		"Calibration data for EGR bypass valve diagnosis configuration management"
		VALUE
		0x80043af5
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_diag_dsb_egr_byp_blk_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_diag_dsb_maf_reg_neg_cfm
		"Calibration data for maf reg neg err diagnosis configuration management"
		VALUE
		0x80043b69
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_diag_dsb_maf_reg_neg_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_diag_ena_npu_cfm
		"Calibration data for inhibition on NOx purge management"
		VALUE
		0x80045d8b
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_diag_ena_npu_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_diag_ena_npu_cfm_lkg
		"Calibration data for inhibition on NOx purge management for overload particulate filter"
		VALUE
		0x80046437
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_diag_ena_npu_cfm_lkg 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_diag_ena_on_efi_inj_sys
		"Boolean to activate diag ena even if exhaust injection system is already failed"
		VALUE
		0x80040120
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_diag_ena_on_efi_inj_sys 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbfulin_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cbx_diag_fuel_pres_cfm
		"DiagnoseFuelLow information is provided by CAN"
		VALUE
		0x80055bb8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_diag_fuel_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_diag_in_vvtc_ena_cam_crk_df
		"VVTC (aftersales) actuation tests allowd with detected failure on camshaft or crankshaft sensors"
		VALUE
		0x8006b21a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_diag_in_vvtc_ena_cam_crk_df 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_dly_ena_cfm
		"Cbx_dly_ena_cfm"
		VALUE
		0x800592fc
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_doc1_utp_pull_up
		"with or without pull up"
		VALUE
		0x80058128
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_doc1_utp_pull_up 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_doc_dtp_cfm
		"Catalyst downstream temperature sensor configuration"
		VALUE
		0x80043b7b
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_AtCatDgn_bool
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_doc_dtp_cfm 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_down_shf_blk_cur_cfm
		"Cbx_down_shf_blk_cur_cfm"
		VALUE
		0x8005935a
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_driv_sp_mv_upd_pdl_thd_cfm
		"Option for freezing driver setpoint mean value calculation under a pedal ratio threshold"
		VALUE
		0x80059197
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_driv_sp_mv_upd_pdl_thd_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_dt_tq_rat_grip_cfm
		"Boolean calibration permits to choose the driveline torque ratio calculation"
		VALUE
		0x8005a71b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_dt_tq_rat_grip_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_efi_pump_sldv_cfm
		"Switch for exhaust configuration (pump or solenoid valve)"
		VALUE
		0x80058f24
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_efi_pump_sldv_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_byp_comb_mod_npu
		"Calibration for bypass activation in npu mode"
		VALUE
		0x8006009a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_byp_comb_mod_npu 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_byp_comb_mod_pr
		"Calibration for bypass activation in pr mode"
		VALUE
		0x80060099
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_byp_comb_mod_pr 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_byp_comb_mod_rij_pp
		"Calibration for bypass activation in rij mode"
		VALUE
		0x80060098
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_byp_comb_mod_rij_pp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_byp_obd_mask_cfm
		"Calibration data for OBD service 06 confirmation management"
		VALUE
		0x80043af4
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_byp_obd_mask_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_byp_sta_1
		"First state of the egr cooler bypass"
		VALUE
		0x80060086
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_byp_sta_1 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_byp_sta_2
		"Second state of the egr cooler bypass"
		VALUE
		0x80060085
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_byp_sta_2 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_cut_it_clos
		"Flag for EGR cut-off authorization when inlet throttle is closed"
		VALUE
		0x80043b79
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_cut_it_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_cut_ovn_slow_pp
		"Calibration for slow closing in overrun shut-off in pp mode"
		VALUE
		0x8006150f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_cut_ovn_slow_pp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_cut_ovn_slow_pr
		"Calibration for slow closing in overrun shut-off in pr mode"
		VALUE
		0x8006150e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_cut_ovn_slow_pr 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_cut_ovn_slow_rij
		"Calibration for slow closing in overrun shut-off in rij mode"
		VALUE
		0x8006150d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_cut_ovn_slow_rij 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_cutt_cln_cfm
		"Calibration used to activate the cuttings release strategy"
		VALUE
		0x80062888
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_cutt_cln_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafstqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_fisa_cor_cfm
		"Calibration for the FMA correction choice"
		VALUE
		0x80067ec3
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_fisa_cor_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafstqx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egr_tqi_cfm
		"as_maf_spt_mafsrix/ Calibration for torque choice"
		VALUE
		0x80067ec2
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egr_tqi_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_egt_mnl_sel
		"Manual exhaust gaz treatment state selector [0:state machine / 1:manual]"
		VALUE
		0x80047130
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_egt_mnl_sel 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_bch_mod_ena
		"Enables the Bench Mode. If 1, the Bench Mode is activated."
		VALUE
		0x80058b9f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_bch_mod_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_blk_clos_cfm
		"Closed blocked EGR valve failure mode activation flag"
		VALUE
		0x80062887
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_blk_clos_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_blk_opn_cfm
		"Opened blocked EGR valve failure mode activation flag"
		VALUE
		0x80062886
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_blk_opn_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_obd_thd_cho
		"Indicates if the OBD threshold is higher than the emtv blk threshold during full closing."
		VALUE
		0x80058b2a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_obd_thd_cho 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_psn_ctl_sgn
		"Allow to change the sign of the variable Vxx_evp_reg."
		VALUE
		0x80058c10
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_psn_ctl_sgn 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_psn_fil_cho_1
		"Choice between the filtered position and the raw position. If 1, filtered."
		VALUE
		0x80058c0f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_psn_fil_cho_1 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_psn_ofs_cho
		"Choice between the first or the last offset for the reference. If 0, last offset."
		VALUE
		0x80058b9e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_psn_ofs_cho 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_psn_sp_ctl_sgn
		"Allow to change the sign of the variable Vxx_evp_sp_ctl_sgn"
		VALUE
		0x80058c0e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_psn_sp_ctl_sgn 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_sat_clos_req_pp
		"Calibration to mask the ability to activate the fresh air control if Vsx_emtv_pos_sat is true"
		VALUE
		0x800618c8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_sat_clos_req_pp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_sat_clos_req_pr
		"Calibration to mask the ability to activate the fresh air control if Vsx_emtv_pos_sat is true"
		VALUE
		0x80061bb8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_sat_clos_req_pr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_sat_clos_req_rij
		"Calibration to mask the ability to activate the fresh air control if Vsx_emtv_pos_sat is true"
		VALUE
		0x80061ea8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_sat_clos_req_rij 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_sens_typ_cfm
		"Indicates if the sensor technology obliges to adapt the signal with the sensor supply voltage."
		VALUE
		0x80056fa4
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_sens_typ_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_emtv_v_lim_ena
		"Enables the current limitation when the component is blocked."
		VALUE
		0x80058b29
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_emtv_v_lim_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ena_brk_cru_swi_cfm
		"Enabling boolean for safety strategy on brake  switch"
		VALUE
		0x8005914f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ena_brk_cru_swi_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ena_clu_cru_swi_cfm
		"Enabling boolean for safety strategy on clutch  switch"
		VALUE
		0x8005914e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ena_clu_cru_swi_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ena_reg_decl_resu_on
		"This calibration authorise or not the entry in regulation by pressing resume or set/+ ( 1 : enable / 0 : disable)"
		VALUE
		0x800401b1
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ena_reg_decl_resu_on 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_eng_spc_ac_dsb_cfm
		"Activation of engine specific strategy for air conditioning"
		VALUE
		0x8005cdc5
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_eng_spc_ac_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_eng_spc_alt_dsb_cfm
		"Activation of engine specific strategy for alternator"
		VALUE
		0x8005cdc4
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_eng_spc_alt_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_eng_spc_ptc_dsb_cfm
		"Activation of engine specific strategy for PTC"
		VALUE
		0x8005cdc3
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_eng_spc_ptc_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_eng_spc_thpl_dsb_cfm
		"Activation of engine specific strategy for coolant heaters"
		VALUE
		0x8005cdc2
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_eng_spc_thpl_dsb_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_eng_stop_csf_swi
		"Boolean to disable statemachine if engine is stopped"
		VALUE
		0x80067f81
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_eng_stop_csf_swi 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_eng_stop_mdf_cho
		"Choice of fan 1 or 2 during PWL (true : fan 2)"
		VALUE
		0x8006b0bc
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_eng_stop_mdf_cho 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_cold_cut_no_lk_cfm
		"Boolean of ex man pres sens no link diagnosis shut off in case of cold intake air temperature"
		VALUE
		0x80057dd0
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_cold_cut_no_lk_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_cold_cut_nok_cfm
		"Boolean of ex man pres sens plausibility diagnosis shut off in case of cold intake air temperature"
		VALUE
		0x80057dcf
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_cold_cut_nok_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_cold_cut_sens_h_cfm
		"Boolean of ex man pres sens high signal diagnosis shut off in case of cold intake air temperature"
		VALUE
		0x80057dce
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_cold_cut_sens_h_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_cold_cut_sens_l_cfm
		"Boolean of ex man pres sens low signal diagnosis shut off in case of cold intake air temperature"
		VALUE
		0x80057dcd
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_cold_cut_sens_l_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_max_lim_ena
		"Boolean used to enable exhaust pressure max limitation"
		VALUE
		0x80043b08
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_max_lim_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_no_lk_it_open_dsb
		"Flag to disable the state of the inlet throttle position for the no leak diagnosis"
		VALUE
		0x80057dcc
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_no_lk_it_open_dsb 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_nok_amp
		"Calibration to choose the atmospheric pressure information for NOK diagnosis"
		VALUE
		0x80057dcb
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_nok_amp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_sens_pres_cfm
		"Boolean calibration for switching between ex_prs sensor and model"
		VALUE
		0x80057d9a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_sens_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ex_prs_sp_tkof_cfm
		"Boolean which enable specific exhaust pressure setpoint for take off assistance"
		VALUE
		0x80060bb2
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ex_prs_sp_tkof_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monisft_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ext_ctrl_hot_test_vh_cdn_dsb
		"Disable vehicle safety conditions for external controls"
		VALUE
		0x80056e19
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ext_ctrl_hot_test_vh_cdn_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monisft_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ext_ctrl_pdl_cdn_ena
		"Enable pedals safety conditions for external controls"
		VALUE
		0x80056e18
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ext_ctrl_pdl_cdn_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_fail_dft_ini_req
		"Clear diagnostics information request"
		VALUE
		0x80056f92
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fail_dft_ini_req 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_fast_off_ena_cfm
		"Cbx_fast_off_ena_cfm"
		VALUE
		0x80059307
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_fast_off_kd_ena_cfm
		"Cbx_fast_off_kd_ena_cfm"
		VALUE
		0x80059306
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_fast_on_ena_cfm
		"Cbx_fast_on_ena_cfm"
		VALUE
		0x8005934e
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_adv_bch_mod
		"Bench mode activation for main advance"
		VALUE
		0x80050fbc
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_adv_bch_mod 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_bch_mod
		"Fuel mass splitting bench mode activation"
		VALUE
		0x8004c5ac
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_cor_off
		"Switching-off corrections of fuel mass splitting"
		VALUE
		0x8004c5ab
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_cor_off 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_efi_max_cho
		"Efi saturation maps configuration (choice between ttr/egaf or n/tqi)"
		VALUE
		0x80043d7e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_efi_max_cho 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_afterxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_faf_bch_mod
		"Bench mode activation for after injection quantity"
		VALUE
		0x80068182
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_faf_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_lpostxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_flp_bch_mod
		"Bench mode activation for late post injection quantity"
		VALUE
		0x80068c40
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_flp_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_mainxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_fma_bch_mod
		"Bench mode activation for main injection quantity"
		VALUE
		0x80068c44
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_fma_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_fp1_bch_mod
		"Bench mode activation for pre-injection 1 angle"
		VALUE
		0x80068e10
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_fp1_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_fp2_bch_mod
		"Bench mode activation for pre-injection 2 quantity"
		VALUE
		0x8004c5aa
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_fp2_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_fpo_bch_mod
		"Bench mode activation for post injection quantity"
		VALUE
		0x80068e14
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_fpo_bch_mod 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_lpos_acum_dsb_ocd
		"Late post injection accumulation disabled during oxydation catalyst diagnostic"
		VALUE
		0x8004980f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_lpos_acum_dsb_ocd 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_lpos_acum_dsb_pr
		"Late post injection accumulation disabled during pft regeneration"
		VALUE
		0x8004980e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_lpos_acum_dsb_pr 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_afterxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_taf_bch_mod
		"Bench mode activation for after injection separation"
		VALUE
		0x8006925e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_taf_bch_mod 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_tlp_bch_mod
		"Bench mode activation for late post injection angle"
		VALUE
		0x80069dec
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_tlp_bch_mod 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_tp1_bch_mod
		"Bench mode activation for pre-injection 1 separation"
		VALUE
		0x80053ee4
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_tp1_bch_mod 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2xx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_tp2_bch_mod
		"Bench mode activation for pre-injection 2 separation"
		VALUE
		0x800549bc
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_tp2_bch_mod 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_fms_tpo_bch_mod
		"Bench mode activation for post injection angle"
		VALUE
		0x80055250
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fms_tpo_bch_mod 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_schxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_free_shf_dsb_cfm
		"Cbx_free_shf_dsb_cfm"
		VALUE
		0x800401d6
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_schxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_fsl_cfm
		"(=1) Fixed Speed Limiter activated"
		VALUE
		0x800401a8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fsl_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_fsl_ena_cfm
		""
		VALUE
		0x800401d5
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_fsl_ena_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_gear_blk_cfm
		"Cbx_gear_blk_cfm"
		VALUE
		0x80059359
		RSA_RecordLayout_VALUE_UBYTE
		1
		VA_Bool_ON_OFF
		0
		1
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_glow_thpl_cut_ena
		"Allows to inhib pre post heating cut condition"
		VALUE
		0x8005526a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_glow_thpl_cut_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_i_set_is_cfm
		"Switch allowing to choose between a constant integral or a calculated integral on a brake pedal"
		VALUE
		0x8005ab49
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_i_set_is_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ic_maf_ex_cor_fail_cfm
		"Calibration to keep ok the validity status on icmaf when pressure anf temperature before turbine are not present"
		VALUE
		0x80056fc4
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ic_maf_ex_cor_fail_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ic_maf_maf_mdl_cfm
		"Calibration to allow in cylinder mass air flow estimation if model is calibrated"
		VALUE
		0x80056fc3
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ic_maf_maf_mdl_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ic_maf_mdl_cfm
		"Calibration to allow in cylinder mass air flow estimation if model is calibrated"
		VALUE
		0x80056fc2
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ic_maf_mdl_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_schedul_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_in_vvtc_abst_pres_cfm
		"Boolean indicating that intake VVTC strategies must be enabled (in configuration Nxx_in_vvtc_cho)"
		VALUE
		0x8005891e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_in_vvtc_abst_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_air_vld_spg_reg_cfm
		"Air intake system validity status inhibition in boost pressure strategy"
		VALUE
		0x80043397
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_air_vld_spg_reg_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_amp_vld_cfm
		"Inhibition of amp validity status for antisurge strategy"
		VALUE
		0x8005ece9
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_amp_vld_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_cmd_blk_clos_cfm
		"Turbine negative deviation stored confirmed failure inhibition in boost pressure strategy"
		VALUE
		0x80043396
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_cmd_blk_clos_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_emtv_vld_spg_cfm
		"EMTV validity status (blocked open) inhibition in boost pressure strategy"
		VALUE
		0x80043395
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_emtv_vld_spg_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_ex_prs_nok_cfm
		"Specific nok_0 exhaust manifold pressure validity status inhibition in boost pressure strategy"
		VALUE
		0x80043394
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_ex_prs_nok_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_inj_sys_vld_cfm
		"Injection system validity status inhibition in boost pressure strategy"
		VALUE
		0x80043393
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_inj_sys_vld_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_it_vld_spg_cfm
		"Inlet throttle validity status blocked closed inhibition in boost pressure strategy"
		VALUE
		0x80043392
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_it_vld_spg_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_spg_apl_down_cfm
		"Turbocharger negative deviation stored confirmed failure inhibition in boost pressure strategy"
		VALUE
		0x80043391
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_spg_apl_down_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_spg_apl_up_cfm
		"Turbocharger positive deviation stored confirmed failure inhibition in boost pressure strategy"
		VALUE
		0x80043390
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_spg_apl_up_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_spg_it_cut_cfm
		"Open loop activation in case of fail 2 spg sensor validity status inhibition in boost pressure strategy"
		VALUE
		0x8004338f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_spg_it_cut_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_inhi_vnt_diag_cfm
		"Inhibition of supercharger regulation deviation diagnostic in case of invalid component"
		VALUE
		0x8004338e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_inhi_vnt_diag_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ini_i_tco_cfm
		"Switch allowing to choose between an initialization of integral correction function of the losses or function of (Tco, gear ratio)"
		VALUE
		0x8005ab48
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ini_i_tco_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_ip_lght_tco_ovh_igk_off_ena
		"State if warning over heating lamp in on when igk is off"
		VALUE
		0x80059056
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ip_lght_tco_ovh_igk_off_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_lossxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_is_ad_eng_tql_cmf
		"add adaptive idle speed torques on engine torque losses or on minimum torque"
		VALUE
		0x800415e0
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_is_ad_eng_tql_cmf 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_is_blk_vh_run_cfm
		"Choice to activate the detection of engine speed hook when vehicle runs without engaged gear"
		VALUE
		0x8005aa6c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_is_blk_vh_run_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_is_cdn_i_act_cfm
		"Boolean authorizing the integral correction to regulate in the start phase and in state Cdn of ISR"
		VALUE
		0x8005ab47
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_is_cdn_i_act_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_is_int_ftc_n_cfm
		"Switch to decrease the integral according to the engine speed"
		VALUE
		0x8005ab46
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_is_int_ftc_n_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_schedul_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_is_loop_diag_cfm
		"Choice of Idle Speed loop diagnosis configuration"
		VALUE
		0x800413ec
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_is_loop_diag_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_is_run_vh_min_crp_cfm
		"Configuration of type detection to idel speed setpoint for vehicle running"
		VALUE
		0x8004142c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_is_run_vh_min_crp_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_is_t_ovs_slo
		"Calibration for slow egr valve closing"
		VALUE
		0x80062885
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_is_t_ovs_slo 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_bch_mod_ena
		"Enables the Bench Mode. If 1, the Bench Mode is activated."
		VALUE
		0x80058cb7
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_bch_mod_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_clos_slow
		"Calibration for slow egr valve closing"
		VALUE
		0x80043b78
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_clos_slow 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_frst_ofs_ena
		"Enables the first offset learning strategy."
		VALUE
		0x80058cb6
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_frst_ofs_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_frst_ofs_ena_1
		"Enables the first offset learning strategy cycle."
		VALUE
		0x80058cb5
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_frst_ofs_ena_1 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_frst_ofs_open_ena
		"Enables the first offset learning strategy."
		VALUE
		0x80058cb4
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_frst_ofs_open_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_it_ofs_clos_frst_dsb
		"Disables offset closed learning condition to allow throttle control"
		VALUE
		0x80056e31
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_ofs_clos_frst_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_ofs_last_ena
		"Enables to learn the offset at each key off."
		VALUE
		0x80058cb3
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_ofs_last_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_it_ofs_open_frst_dsb
		"Disables offset open learning condition to allow throttle control"
		VALUE
		0x80056e30
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_ofs_open_frst_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_pres_pp
		"Calibration for the shut-off related to inlet throttle default in pp mode"
		VALUE
		0x8006150c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_pres_pp 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_pres_rij
		"Calibration for the shut-off related to inlet throttle default in rij mode"
		VALUE
		0x8006150b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_pres_rij 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_psn_ctl_sgn
		"Allow to invert the sign of Vxx_it_psn_ctl."
		VALUE
		0x80058dac
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_psn_ctl_sgn 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_psn_fil_cho_1
		"Choice between the filtered position and the raw position. If 1, filtered."
		VALUE
		0x80058dab
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_psn_fil_cho_1 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_psn_ofs_cho
		"Choice between the first or the last offset for the reference. If 0, last offset."
		VALUE
		0x80058cb2
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_psn_ofs_cho 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_psn_sp_ctl_sgn
		"Boolean to change the sign of the variable Vxx_itp_sp_ctl."
		VALUE
		0x80058daa
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_psn_sp_ctl_sgn 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_sens_typ
		"Indicates if the sensor technology obliges to adapt the signal with the sensor supply voltage."
		VALUE
		0x80057cfe
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_it_sens_typ 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_temp_tqi_max_cor_pr_dsb
		"Boolean to inhibit of the air temperature correction on the atmospheric loop"
		VALUE
		0x8005b229
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_temp_tqi_max_cor_pr_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_temp_tqi_max_cor_rij_dsb
		"Boolean to inhibit of the air temperature correction on the atmospheric loop"
		VALUE
		0x8005b4eb
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_temp_tqi_max_cor_rij_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_it_v_lim_ena
		"Enables the current limitation when the component is blocked."
		VALUE
		0x80058c6e
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_it_v_lim_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_itcl_efl_ini_ena
		"Calibration used to enable MAF I part init in case of edge falling detection on Vsx_thr_air_reg"
		VALUE
		0x80063c1b
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_itcl_efl_ini_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_itcl_erg_ini_ena
		"Calibration used to enable MAF I part init in case of edge rising detection on Vsx_thr_air_reg"
		VALUE
		0x80063c1a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_itcl_erg_ini_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_itol_efl_ini_ena
		"Calibration used to enable MAF I part init in case of edge falling detection on Vsx_thr_sat_ena"
		VALUE
		0x80063c19
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_itol_efl_ini_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_itol_erg_ini_ena
		"Calibration used to enable MAF I part init in case of edge rising detection on Vsx_thr_sat_ena"
		VALUE
		0x80063c18
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_itol_erg_ini_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_maf_dyn_fail_2_cfm
		"Calibration to allow the failure 2 of the dynamic mass air flow information"
		VALUE
		0x80057409
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_maf_dyn_fail_2_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_maf_dyn_fil_cfm
		"Dynamic air mass flow filtering configuration"
		VALUE
		0x800573d4
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_maf_dyn_fil_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_maf_fail_2_cfm
		"Calibration to allow the failure 2 of the mass air flow information"
		VALUE
		0x80057408
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_maf_fail_2_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_maf_reg_fac_var_cfm
		"calibration to choose the variable for the correction of the maf regulator gains"
		VALUE
		0x80063c17
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_maf_reg_fac_var_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_maf_reg_neg_obd_mask_cfm
		"Calibration data for OBD service 06 configuration management"
		VALUE
		0x80043b68
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_maf_reg_neg_obd_mask_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_maf_vld_utp_reg
		"Switch disabling the mass air flow measure VI for the CSF upstream temp regulator"
		VALUE
		0x8004588f
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_maf_vld_utp_reg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mafs_plau_diag_cfm
		"Calibration to allow the diagnosis of mass air flow regarding the mass air flow estimation"
		VALUE
		0x80057407
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mafs_plau_diag_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mafs_pres_cfm
		"Calibration used to choose the mass air flow estimator"
		VALUE
		0x80057406
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mafs_pres_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_map_sens_pres_cfm
		"a_in_asi_iap_mapxxcs/ Presence of the manifold pressure sensor"
		VALUE
		0x800576c0
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_map_sens_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mapc_ad_calc
		"Bit calibration to decide either to use ambient pressure or a mean value."
		VALUE
		0x800577b9
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mapc_ad_calc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mapc_pres_cfm
		"Calibration to authorize the manifold pressure correction"
		VALUE
		0x800577b8
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mapc_pres_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_max_gear_cge_dly_ena_cfm
		"activation of max gear change delay diagnosis. Inactive only on bench (for tunning features)"
		VALUE
		0x80058787
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_max_gear_cge_dly_ena_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_max_n_fl_tkof_ant_coup_dsb
		"Disable the specific limitation during the take off on the condition open coupler"
		VALUE
		0x8005af54
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_max_n_fl_tkof_ant_coup_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_max_n_fl_tkof_ena
		"Boolean to activate the take off limitation"
		VALUE
		0x8005af53
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_max_n_fl_tkof_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_max_n_fl_tkof_ovn_tq_ena
		"Boolean to enable the torque engine speed limitation for take off limitation"
		VALUE
		0x8005af52
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_max_n_fl_tkof_ovn_tq_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mdf1_asd_comb_mod_req_ena
		"mdf1 activation for overheating protection for after sale service"
		VALUE
		0x8006b08d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mdf1_asd_comb_mod_req_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mdf1_comb_mod_req_2_ena
		"mdf1 activation for overheating protection when combustion mode = 2"
		VALUE
		0x8006b08c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mdf1_comb_mod_req_2_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mdf1_comb_mod_req_3_ena
		"mdf1 activation for overheating protection when regeneration"
		VALUE
		0x8006b08b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mdf1_comb_mod_req_3_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mdf2_asd_comb_mod_req_ena
		"mdf2 activation for overheating protection for after sale service"
		VALUE
		0x8006b08a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mdf2_asd_comb_mod_req_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mdf2_comb_mod_req_2_ena
		"mdf2 activation for overheating protection when combustion mode = 2"
		VALUE
		0x8006b089
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mdf2_comb_mod_req_2_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mdf2_comb_mod_req_3_ena
		"mdf2 activation for overheating protection when regeneration"
		VALUE
		0x8006b088
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mdf2_comb_mod_req_3_ena 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_mdl_ex_prs_fail_cfm
		"Enabling calibration boolean for the Pressure before turbine model"
		VALUE
		0x80057d9e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mdl_ex_prs_fail_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_min_avl_tqe_raw_cfm
		"Boolean calibration to change the minimum available torque: equal to engine torque losses (=0)"
		VALUE
		0x8005aff1
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_min_avl_tqe_raw_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_min_driv_tqe_cfm
		"Boolean calibration to deactivate the use of Vxx_min_driv_tqe in AJMOD filter"
		VALUE
		0x8005aff0
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_min_driv_tqe_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_min_lvl_rgn_ena_swi
		"Switch to disable regeneration authorization when mini gasoil level is on."
		VALUE
		0x8004712f
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_min_lvl_rgn_ena_swi 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_min_tq_mod_cfm
		"Boolean to active the minimum torque in the diesel configuration."
		VALUE
		0x8005afef
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_min_tq_mod_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_mnl_driv_spt_fac_cfm
		"Option bit for manually imposing driver sportivity factor during tuning"
		VALUE
		0x80059196
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mnl_driv_spt_fac_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_moni_id_10_it_sat
		"Replacement value of Vsx_thr_sat requested by Monitool to control identifier 10"
		VALUE
		0x80063bc3
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_moni_id_10_it_sat 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_moni_id_11_req
		"Replacement value requested by Monitool to control identifier 11"
		VALUE
		0x80063bc2
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_moni_id_11_req 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_moni_id_18_sub_val
		"Replacement value requested by Monitool to control identifier 18"
		VALUE
		0x80060084
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_moni_id_18_sub_val 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_moni_maf_reg_off
		"Replacement value requested by Monitool to disable the maf regulator"
		VALUE
		0x80063c16
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_moni_maf_reg_off 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_mpl_dec_slop_act
		"Activation of the decrease slopes arbitration strategy (0=One slope  1=multiple slopes)"
		VALUE
		0x8004142b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mpl_dec_slop_act 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ms_ofs_rgn_swi
		"Boolean to shut off the offset decrease computation during regeneration."
		VALUE
		0x8004668c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ms_ofs_rgn_swi 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_mux_alt_pwm_cfm
		"Multiplexed alternator load configuration"
		VALUE
		0x80058a92
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mux_alt_pwm_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clb2xcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_mux_clu_cnt_cfm
		"Choise using CAN data of begin clutch contactor"
		VALUE
		0x8005882e
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mux_clu_cnt_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcaplou_xxxm3x_data.c' */
/begin CHARACTERISTIC
		Cbx_mux_driv_pwt_sp_fail
		"Configuration of invalid value of Powertrain Setpoint CAN signal."
		VALUE
		0x8006b1fe
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Cbx_mux_driv_pwt_sp_fail 
    FORMAT "%6.3" 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_mux_mil_cfm
		"MIL configuration"
		VALUE
		0x8005912c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_mux_mil_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_ff_actr_0_cfm
		"Activation of engine speed limitation on state nok of fuel flow actuator validity status"
		VALUE
		0x8005af3d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_ff_actr_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_ff_actr_3_cfm
		"Activation of engine speed limitation on state fail_3 of fuel flow actuator validity status"
		VALUE
		0x8005af3c
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_ff_actr_3_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_ff_actr_4_cfm
		"Activation of engine speed limitation on state fail_4 of fuel flow actuator validity status"
		VALUE
		0x8005af3b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_ff_actr_4_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_ff_fct_0_cfm
		"Activation of engine speed limitation on state nok of fuel flow regulation validity status"
		VALUE
		0x8005af3a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_ff_fct_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_ff_fct_4_cfm
		"Activation of engine speed limitation on state fail_4 of fuel flow regulation validity status"
		VALUE
		0x8005af39
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_ff_fct_4_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_ff_fct_5_cfm
		"Activation of engine speed limitation on state fail_5 of fuel flow regulation validity status"
		VALUE
		0x8005af38
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_ff_fct_5_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_fprs_actr_0_cfm
		"Activation of engine speed limitation on state nok of fuel pressure actuator validity status"
		VALUE
		0x8005af37
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_fprs_actr_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_fprs_fct_0_cfm
		"Activation of engine speed limitation on state nok of fuel pressure regulation validity status"
		VALUE
		0x8005af36
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_fprs_fct_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_fprs_fct_3_cfm
		"Activation of engine speed limitation on state fail_3 of fuel pressure regulation validity status"
		VALUE
		0x8005af35
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_fprs_fct_3_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_fprs_fct_4_cfm
		"Activation of engine speed limitation on state fail_4 of fuel pressure regulation validity status"
		VALUE
		0x8005af34
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_fprs_fct_4_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_inj_0_cfm
		"Activation of engine speed limitation on state nok of injectors validity status"
		VALUE
		0x8005af33
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_inj_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_inj_ecu_0_cfm
		"Activation of engine speed limitation on state nok ok engine control ECU validity status"
		VALUE
		0x8005af32
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_inj_ecu_0_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_mpl_fail_cfm
		"Activation of engine speed limitation on multiple failure of fuel flow and fuel pressure regulations"
		VALUE
		0x8005af31
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_mpl_fail_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_sens_rail_prs_2_cfm
		"Activation of engine speed limitation on state fail_2 of rail pressure sensor validity status"
		VALUE
		0x8005af30
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_sens_rail_prs_2_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_lim_sens_rail_prs_cfm
		"Activation of engine speed limitation of rail pressure sensor validity status"
		VALUE
		0x8005af2f
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_lim_sens_rail_prs_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_ms_tqi_max_cor_pr_dsb
		"Boolean to inhibit of theCSF load correction on the atmospheric loop"
		VALUE
		0x8005b228
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_ms_tqi_max_cor_pr_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_ms_tqi_max_cor_rij_dsb
		"Boolean to inhibit of theCSF load correction on the atmospheric loop"
		VALUE
		0x8005b4ea
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_ms_tqi_max_cor_rij_dsb 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_n_mv_n_cfm
		"Boolean calibration to choose between a filtered raw engine speed (=1) or filtered engine speed (=0)"
		VALUE
		0x8005afee
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_mv_n_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_ivltqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_n_tq_fct_vld2_cfm
		"allow to choose torque validity level on Engine speed validity status"
		VALUE
		0x8004324a
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_n_tq_fct_vld2_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_no_ant_gear_fil_cfm
		"Boolean enabling the ratio filtering for ant gear detection"
		VALUE
		0x8006b244
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_no_ant_gear_fil_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_no_dly_bfr_nom_stt
		"Boolean to authorize direct nominal status after exhaust pressure sensor failure"
		VALUE
		0x8004338d
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_no_dly_bfr_nom_stt 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_npu_off_ini_ena
		"Calibration used to enable MAF I part init in case of end of  npu air structure use"
		VALUE
		0x80063c15
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_npu_off_ini_ena 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_obdserx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_obd_fail_dft_ini_req
		"Initialisation request of OBD data."
		VALUE
		0x8006b21c
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_obd_fail_dft_ini_req 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_obd_off_cfm
		"OBD system inhibition"
		VALUE
		0x80056cb0
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_obd_off_cfm 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_ocd_ena_cfm
		"Configuration switch for hidden OBD"
		VALUE
		0x80043b7a
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_AtCatDgn_bool
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_ocd_ena_cfm 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cbx_oil_dil_ini_mnl
		"Switch to initialize manually with specific value the oil dilution and the dil_max"
		VALUE
		0x8005526f
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_oil_dil_ini_mnl 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_schxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_oil_heat_abst_pres_cho
		"Choice manager of presence of oil vapours heater"
		VALUE
		0x8004014e
		RSA_RecordLayout_VALUE_UBYTE
		1
		RB_CONV_OneToOne
		0
		1
    DISPLAY_IDENTIFIER Cbx_oil_heat_abst_pres_cho 
	/* XmlToolChain::L2::FindAddresses : BitMask inserted according the name convention
	 *     none => 0x1 */
    BIT_MASK 0x1 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_on_ac_cor_cfm
		"Inhibition boolean of the condition on the AC clutch for the detection of a engine speed hook"
		VALUE
		0x8005aa6b
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_on_ac_cor_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_on_alt_cor_cfm
		"Inhibition boolean of the condition on the alternator power for the detection of an engine speed hook"
		VALUE
		0x8005aa6a
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_on_alt_cor_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cbx_on_mdf_cor_cfm
		"Inhibition boolean of the condition on the flans for the detection of a engine speed hook"
		VALUE
		0x8005aa69
		RSA_RecordLayout_VALUE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Cbx_on_mdf_cor_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
