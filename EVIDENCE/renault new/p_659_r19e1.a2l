/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_apmp_up_shf
		"Vbx_apmp_up_shf"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002950 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_arw_down
		"Vbx_arw_down"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002db8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_arw_down_raw
		"Vbx_arw_down_raw"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002db9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_arw_up
		"Vbx_arw_up"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002dbb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_arw_up_raw
		"Vbx_arw_up_raw"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002dbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_asd_mdf_comb_mod_req
		"after sale department combustion mode fan request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asd_mdf_comb_mod_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_asd_pft_dp_thd
		"Differential pressure threshold status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asd_pft_dp_thd 
    ECU_ADDRESS 0xd0002bcb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_asd_pft_n_mv_thd
		"Engine speed threshold status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asd_pft_n_mv_thd 
    ECU_ADDRESS 0xd0002bcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_asd_pft_tco_thd
		"Cooling temperature threshold status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asd_pft_tco_thd 
    ECU_ADDRESS 0xd0002bcd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_asd_pft_utp_ovh
		"Temperature before FAP overshoot detected failure"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asd_pft_utp_ovh 
    ECU_ADDRESS 0xd0002bce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_cdn
		"ASR conditions"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_msr_ack
		"ESP frame acknowledgement bit. this value is set to 1 if there is no request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_msr_ack 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002802 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_msr_cdn
		"ASR MSR authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_msr_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_msr_frm_abst_tmp
		"Absence of ESP frame reception"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_msr_frm_abst_tmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_msr_lk
		"This boolean is memorized when the first esp frame occurs"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_msr_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_prot_dft
		"Protocol error (complement and clock) in ASR regulation (slew rate activation)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_prot_dft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_espxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_reg
		"ASR in regulation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_asr_tqe_req_ok
		"Authorized ASR torque request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_asr_tqe_req_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oudgolmp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oudgolmp_milmgtx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_aut_eng_mil
		"Boolean indicating that the engine is in autonomous functioning"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_aut_eng_mil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002db4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_espxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ayc_reg
		"AYC in regulation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ayc_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_bduxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_bdu_ope
		"Boolean that indicates BDU opening"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_bdu_ope 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_seclcxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_bgin_clu_cnt_ena
		"Begin stroke sensor is functional"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_bgin_clu_cnt_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_seclcxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_bgin_clu_cnt_on
		"Begin stroke sensor is activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_bgin_clu_cnt_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_bgin_clu_off_nok
		"Incoherency confirmed when the begin clutch contactor is always OFF"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_bgin_clu_off_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_bgin_clu_on_nok
		"Incoherency confirmed when the begin clutch contactor is always ON"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_bgin_clu_on_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_bgin_clu_pdl_on
		"Begin stroke robustified information is 'pedal pressed'"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_bgin_clu_pdl_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027f9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_blk_n
		"Engine speed hooked above of idle setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_blk_n 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_bpkxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_bpk
		"Automatic or manual parking brake detected"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_bpk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_brk
		"State of the break switch ( 1 if pushed)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_brk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ee5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_brk_pdl_vld_fail
		"Brake pedal states validity indicator is in the limp home data status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_brk_pdl_vld_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000291b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_brk_pdl_vld_nok
		"Brake pedal states validity indicator is in the invalid data status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_brk_pdl_vld_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000291c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_can_diag
		"Mux diagnostic activation indicator for network (CAN bus) failure detection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_can_diag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_can_diag_bus_fail
		"Mux diagnostic activation indicator for network (CAN bus) failure detection."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_can_diag_bus_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_can_diag_ecm
		"ECM reception diagnostic indicator"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_can_diag_ecm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_can_diag_raw
		"Raw Mux diagnostic activation indicator"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_can_diag_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_ccu_pws_typ_bc
		"Indicates the BCM power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ccu_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_cdn_pft_utp_mv_clc
		"boolean enabling particulate filter upstream temperature mean value calculation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cdn_pft_utp_mv_clc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_slicoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_clc_sli_ena
		"Primary shaft speed/Engine speed ratio enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_clc_sli_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_clock
		"Indicates if the number of the request (tool) is the same as the ECU"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_clock 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002774 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_clos_it_ena
		"Flag for throttle activation requirement in case of EGR valve default."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_clos_it_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000265d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_clos_it_ena_egr_wpmp
		"Flag for throttle activation in case of EGR water pump default"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_clos_it_ena_egr_wpmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002660 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_clos_it_ena_emtv
		"Flag for throttle activation in case of EGR valve default"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_clos_it_ena_emtv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002661 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_cmb_mdl_int_rst
		"Integrator reset signal"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cmb_mdl_int_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_com_err
		"Flag indicates if there is a security timeout or security clock problem"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_com_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002775 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_act_ok
		"Logic indicating if combustion mode 8 is running or has run at least once during the test"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_act_ok 
    ECU_ADDRESS 0xd0002ba3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_npu
		"Nox purge mode autorised = 1 forbiden =0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_npu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_ocd
		"Oxidation catalyst diagnosis mode autorised = 1 forbiden =0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_ocd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_pp
		"Particule filter protection mode autorised = 1 forbiden =0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_pp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_pr
		"Particule filter regeneration mode authorized = 1 forbidden = 0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_req_ena
		"Enable requirement combustion mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_req_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000269d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_airslop_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_req_no_trs
		"indicates that no transition on the combustion mode has occured"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_req_no_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_airslop_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_req_trs
		"indicates that a transition on the combustion mode has occured"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_req_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a59 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_rij
		"Regular injection mode autorised = 1 forbiden =0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcms.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcms_combsta_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_slop_on
		"One or more combustion switch slop on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_spr
		"Start particule filter regeneration mode autorised = 1 forbiden =0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_spr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_spu
		"Sox purge mode autorised = 1 forbiden =0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_spu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000269e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_mod_sta
		"Starting mode autorised = 1 forbiden =0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_mod_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_comb_ocd_req
		"OBD combustion mode request"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_comb_ocd_req 
    ECU_ADDRESS 0xd0002bb9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_cond_cdntgt_act
		"Booleen indicating the activation of scheduler"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cond_cdntgt_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_cond_chgtend_act
		"Booleen indicating the activation of scheduler chgtend 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cond_chgtend_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c27 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_cond_chgtend_act_load
		"Booleen indicating the activation of scheduler chgtend 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cond_chgtend_act_load 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnsucx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_cond_rgnsuc_act
		"Booleen indicating the activation of scheduler for increment of regeneration succes counters when a regeneration succes is seen"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vxx_pft_rgn_ok_nr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c4d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_crk
		"Crankshaft signal"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_crk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_crk_syn
		"Set to ON after the first long tooth"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_crk_syn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d29 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_crsh_det
		"A crash has been detected"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_crsh_det 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000293e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_acc_virt_driv_on
		"Accelerator pedal request overrun by a cruise control virtual driver (CC/ACC only)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_acc_virt_driv_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000260d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_act
		"Initialize the CC servo-control speed reference"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_brk_det
		"Braking detected for cruise control"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_brk_det 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000291d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_brk_det_sudn
		"Sudden braking detected for cruise control"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_brk_det_sudn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000291e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_clu_abst_fil
		"Filtered clutch pedal status information absence"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_clu_abst_fil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000291f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_clu_navl_fil
		"Filtered unavailable clutch pedal status information"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_clu_navl_fil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002920 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_cmf_cut
		"Comfortable stop of the speed regulation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_cmf_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_cmp_bgin_clu
		"CC safety failure due to wired clutch information"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_cmp_bgin_clu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000290d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_cmp_forc_pres
		"CC safety failure due to force setpoint presence"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_cmp_forc_pres 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000290e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_safetyx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_cmp_open_brk
		"CC safety failure due to brake clutch information"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_cmp_open_brk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000290f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_dgn_eprm_writ_off
		"Boolean that indicates the write-on-the-flight storage in EEPROM on cruise control activation or deactivation is inhibited"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_dgn_eprm_writ_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000293f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_dgn_eprm_writ_on
		"Boolean that indicates the write-on-the-flight storage in EEPROM on cruise control activation or deactivation is enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_dgn_eprm_writ_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002940 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_diag_ena
		"1 : Means the diag is enable (Cbx_cru_diag_add_on == 1 and Vbx_crsh_end_rec_eprm == 0)  / 0 : means it is disable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_diag_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002941 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dsbccxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_eng_dsb
		"Engine control request for cruise control abnormal deactivation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_eng_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000294a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dsbccxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_eng_dsb_sys
		"Engine control request for cruise control system deactivation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_eng_dsb_sys 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000294b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_mstr
		"Arbitrated powertrain setpoint equal to Cruise Control setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_mstr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_mstr_prev
		"Arbitrated powertrain setpoint equal to Cruise Control setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_mstr_prev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_acel_blk
		"The SET+ button is blocked"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_acel_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_dacn_bit0
		"bit 0 of Vxx_cru_sl_dacn"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_dacn_bit0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002942 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_dacn_bit1
		"bit 1 of Vxx_cru_sl_dacn"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_dacn_bit1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002943 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_decl_blk
		"The SET- button is blocked"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_decl_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_kmh_mph_cge
		"The displayed speed unit has changed during CC/SL activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_kmh_mph_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002603 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_lk_ena
		"Enable cruise control and speed limiter option detection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_lk_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_new_lk_ena
		"Authorization to connect cruise control and speed limiter options (=1 enable)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_new_lk_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_oor_vs
		"Vehicle speed outside the speed acceptance domain of CC/SL"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_oor_vs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002604 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_resu_blk
		"The RESUME button is blocked"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_resu_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_susp_blk
		"The SUSPEND button is blocked"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_susp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_svkl_act
		"Control loop active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_svkl_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_warn
		"Cruise control and speed limiter warning (overspeed)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_warn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_warn_prev
		"Previous value of the cruise control and speed limiter warning (overspeed)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_warn_prev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025f1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_warn_raw
		"Stateflow output: Cruise control and speed limiter warning (overspeed)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_warn_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_sl_whl_cmd_blk
		"One of the CC/SL steering wheel switches is inferred blocked"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_sl_whl_cmd_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cru_smal_vs_sp_rat
		"Vehicle speed is too small in comparison on the requested speed to enter in speed regulation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cru_smal_vs_sp_rat 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002605 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_csl_mstr
		"Arbitrated powertrain setpoint equal to Costumer Speed limiter setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_csl_mstr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cut_cdn
		"Flag of injection cut condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cut_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00019a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cut_ct
		"Detected if the injection cut request is coming of powertrain torque setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cut_ct 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002626 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cut_dly_off_trs_3
		"transition 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cut_dly_off_trs_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00019a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cut_dly_on_trs_2
		"transition 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cut_dly_on_trs_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00019aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_cut_off_dly_trs_1
		"transition 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_cut_off_dly_trs_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00019ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_ddcm_pws_typ_bc
		"Indicates the DDCM power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ddcm_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_det_acel_pdl_rdcy_loss
		"Detected loss of redundancy on accelerator pedal sensor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_det_acel_pdl_rdcy_loss 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_ac_prs_h
		"Air conditioning pressure sensor open circuit detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ac_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d2d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_ac_prs_l
		"Air conditioning pressure sensor short circuit detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ac_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_chr
		"Accelerator pedal consistency detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_secu_1
		"Detection of the conditions accelerator pedal safety case N°1 (before breaking)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_secu_2
		"Detected failure of accelerator pedal safety case N°2 (reversible or irreversible downgraded mode)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_tot
		"Total loss of accelerator pedal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_v1_h
		"Accelerator pedal track 1 high signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_v1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_v1_l
		"Accelerator pedal track 1 low signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_v1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_v2_h
		"Accelerator pedal track 2 high signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_v2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_acel_pdl_v2_l
		"Accelerator pedal track 2 low signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_acel_pdl_v2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_agb_data_chr
		"AGB data coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_agb_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_agb_data_seq_ctr
		"AGB data clock detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_agb_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_agb_data_tout
		"AGB data time-out detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_agb_data_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_agb_no_frm
		"AGB Missing Message detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_agb_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_amp_reg_chr
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_bgin_clu_nok
		"Wire begin clutch contactor detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_cata_nok_cge
		"Detected failure of DOC"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_cata_nok_cge 
    ECU_ADDRESS 0xd0002ba4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_comb_trs_tout
		"The transition of combustion confirmed failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_comb_trs_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000269f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_comb_trs_tout_old
		"Old failure time out of transition mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_comb_trs_tout_old 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_crk_no_sig
		"no crankshaft signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002809 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_cru_sl_swi_chr
		"CCSL Main Switch Coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_cru_vs_cmp
		"CCSL mux vehicle speed Coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002606 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_cru_whl_cmd_nok
		"CCSL steering wheel switched blocked button detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_cru_whl_cmd_oc_scw
		"CCSL steering switches open circuit detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_cru_whl_cmd_oor
		"CCSL Steering Wheel Command Switch invalid value detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_doc1_utp_chr
		"doc1_utp_chr detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cd9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_doc1_utp_h
		"doc_1_utp_h detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_doc1_utp_l
		"doc1_utp_l detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cdb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_egr_byp_blk
		"EGR bypass blocked detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000264d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_emtv_flow_meca
		"Blocked emtv during full closing request (OBD failure) detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000285c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_emtv_reg_blk
		"Blocked EMTV during regulation detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000285d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_emtv_reg_blk_open
		"Blocked emtv during full closing request detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000285e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_amp
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_amp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_amp_chr
		"Ambient pressure sensor coherency failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_amp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_amp_h
		"Ambient pressure sensor high signal failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_amp_l
		"Ambient pressure sensor low signal failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_ex_prs_no_lk
		"Ex man pres sens no link detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cbb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_ex_prs_nok
		"Ex man pres sens plausibility detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_map_h
		"Manifold pressure sensor high signal failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_map_l
		"Manifold pressure sensor low signal failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_map_nok
		"Manifold pressure sensor nok failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_rup
		"Pftrelprs sensor detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_rup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_rup_dirt_lkg
		"Pftrelprs sensor dynamic plausibility failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_rup_h
		"Pftrelprs sensor SRC high failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_rup_l
		"Pftrelprs sensor SRC low failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ena_rup_nok
		"Pftrelprs sensor static plausibility failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ena_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_esp_data_chr
		"ESP torque request coherency detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_esp_data_seq_ctr
		"ESP frame sequence counter detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_esp_no_frm
		"The engine control has lost communication with ESP"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ex_prs_nok
		"Ex man pres plausibility detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cbd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_ip_lght_tco_ovh
		"Warning over heating lamp detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_it_reg_blk
		"Blocked IT during regulation detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_it_reg_blk_clos
		"IT Blocked closed during full opening detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_it_reg_blk_open
		"IT Blocked open during full closing detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_maf_reg_neg_err
		"MAF regulation negative error detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002655 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_mafs_apl_down
		"Mass air flow sensor low drift detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002798 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_mafs_apl_up
		"Mass air flow sensor high drift detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002799 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_map_nok_apc
		"Manifold pressure sensor nok detected failure during APC"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_map_nok_apc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_map_nok_isr
		"Manifold pressure sensor nok detected failure during ISR"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_map_nok_isr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_oil_dil_nok
		"Oil dilution overshoot detected failure"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_oil_dil_nok 
    ECU_ADDRESS 0xd0002c8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_dirt
		"Detected failure of CSF : error path for overload particulate filter"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000266a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_dirt_lkg
		"Detected failure of CSF : error path for heavy load particulate filter"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_no_lk
		"Detected failure of CSF : error path for ruptured particulate filter."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_nok_cge
		"Detected failure of CSF: error path for ruptured particulate filter."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_rgn_dirt
		"Maximum regeneration error reached detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c29 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_utp_chr
		"pft_utp_chr detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ce3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_utp_h
		"pft_utp high signal detected failure."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_utp_l
		"pft_utp low signal detected failure."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ce5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_utp_neg_err
		"Fault for CSF upstream temperature regulator negative deviation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bbb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_pft_utp_pos_err
		"Fault for CSF upstream temperature regulator positive deviation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_rup_dirt_lkg
		"Pftrelprs dynamic plausibility detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_rup_nok
		"Pftrelprs sensor static plausibility detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_emtv_nok
		"EMTV sensor Plausibility detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002795 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ex_prs
		"Ex man pres sens detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ex_prs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ex_prs_elec
		"Ex man pres sens detected electrical failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ex_prs_elec 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cbf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_it_nok
		"IT sensor Plausibility detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_maf
		"Mass air flow sensor signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_maf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_tco
		"engine cooling temperature sensor detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_tco 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcomcsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_tco_sig_mcut
		"Engine cooling temperature sensor signal momentarily implausible or discontinuous detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_tia
		"Intake air temperature detected and enabled failure for output freezing"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_tia 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ups
		"Upstream proportional sensor detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ups 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ups_heat
		"Heater powerstage detected failure"
		UBYTE
		RB_CONV_OuCboUeg_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ups_heat 
    ECU_ADDRESS 0xd0002b7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ups_lamb
		"Nerst cell detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ups_lamb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cfb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ups_pump
		"Pump current IP detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ups_pump 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ups_virt
		"Virtual ground detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ups_virt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cfd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_sens_ups_wire
		"Sensor lines detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_sens_ups_wire 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_spg_cmd_blk_clos
		"Negative deviation of the turbine detected failure (exhaust pressure deviation)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_spg_cmd_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_spg_reg_apl_down
		"Negative deviation of the turbocharger detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_spg_reg_apl_up
		"Positive deviation of the turbocharger detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a13 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_tbf_fct_apl_down
		"temperature before particulate filter too low detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_tbf_fct_apl_up
		"temperature before particulate filter too high detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_tbt_chr
		"tbt_chr detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_tbt_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ce9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_tbt_h
		"tbt high signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_tbt_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_tbt_l
		"tbt low signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_tbt_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ceb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_tbt_reg_neg_pr
		"Loop deviation too cold in PR mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_tbt_reg_neg_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_tbt_reg_neg_rij
		"Loop deviation too cold in RIJ mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_tbt_reg_neg_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_thpl1_ena
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_thpl1_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_thpl2_ena
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_thpl2_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_thpl3_ena
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_thpl3_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_thpl4_ena
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_thpl4_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_thpl_alt_pwm
		"Flag of detected value of default state on THPL Alt PWM diagnostic"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_thpl_alt_pwm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_thpl_ena
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_thpl_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d59 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_unk_thpl1_chr
		"Thpl 1 coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_unk_thpl2_chr
		"Thpl 2 coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_unk_thpl3_chr
		"Thpl 3 coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_unk_thpl4_chr
		"Thpl 4 coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d5d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_unk_thpl_chr
		"Thpl coherence detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ups_ecu
		"ECU hardware error detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ups_ecu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ups_heat
		"Heater powerstage detected failure"
		UBYTE
		RB_CONV_OuCboUeg_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ups_heat 
    ECU_ADDRESS 0xd0002b7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ups_tip
		"Sensitive element temperature detected failure"
		UBYTE
		RB_CONV_OuCboUeg_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ups_tip 
    ECU_ADDRESS 0xd0002b7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upsdgxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_df_ups_uo2_ro2
		"Analog signal or upstream sensor control detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_ups_uo2_ro2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_vb_h
		"Battery voltage above max threshold detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002819 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_df_vb_l
		"Battery voltage below min threshold detected failure counter saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_df_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000281a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_cutt
		"Detected cutting during the current driving cycle"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_cutt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002854 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_cutt_1
		"Detected cutting during the current driving cycle. It can rise to 1 only during the offset check."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_cutt_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000285f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_flow_meca_1
		"Blocked emtv during full closing request (OBD failure) detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_flow_meca_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002860 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_ofs
		"Offset Learning detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_ofs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002855 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_ofs_no_norm
		"First offset learning detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002861 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_reg_blk_open_1
		"Blocked emtv during full closing request detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_reg_blk_open_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002862 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_reg_clos_tco
		"Blocked emtv in closed position during regulation detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_reg_clos_tco 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002863 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_reg_dirt
		"Dirty EMTV near the closed thrust detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002864 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_reg_neg
		"Detected failure of a component blocked during a closing in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_reg_neg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002865 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_reg_neg_open
		"Detected failure of a blocked component in open position while closing in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_reg_neg_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002866 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_reg_pos
		"Detected failure of a component blocked during an opening in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_reg_pos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002867 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_emtv_reg_pos_open
		"Detected failure of a blocked component in open position while opening in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_emtv_reg_pos_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002868 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_cutt
		"Detected cutting during the current driving cycle."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_cutt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_cutt_1
		"Detected cutting during the current driving cycle. It rises to one only during the offset check."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_cutt_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_ofs
		"Detected failure during offset learning."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_ofs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_ofs_clos_frst
		"First offset learning (closed offset) detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_ofs_clos_frst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_ofs_open_frst
		"First offset learning (open offset) detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_ofs_open_frst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_clos
		"Blocked IT in closed position during regulation  detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_dirt
		"IT thrusts too dirty detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_neg
		"Detected failure of a component blocked during a closing in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_neg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_neg_clos
		"Detected failure of a blocked IT in closed position, during regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_neg_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_neg_open
		"Detected failure of a blocked component in open position while closing in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_neg_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_open
		"Blocked IT in open position, during regulation detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_pos
		"Detected failure of a component blocked during an opening in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_pos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_pos_clos
		"Detected failure of a  blocked component in closed position during an opening in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_pos_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_dft_it_reg_pos_open
		"Detected failure of a  blocked component in open position during an opening in regulation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_it_reg_pos_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_dft_sta
		"Flag indicating a starter activated but driven state not detected"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dft_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_byp_done
		"Diagnosis completed status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_byp_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000264e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_byp_fail
		"EGR bypass diagnosis failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_byp_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000264f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_egr_byp_req
		"EGR cooler bypass valve request activation and deactivation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_egr_byp_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002653 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_acel_pdl_chr
		"Accelerator pedal consistency diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_acel_pdl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_acel_pdl_secu_2
		"Accelerator pedal safety case N°2 diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_acel_pdl_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_act
		"Flag indicating that all conditions on actuators are satisfied"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000279a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_amb
		"Flag indicating that ambient conditions are satisfied for air mass flow drift diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_amb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000279b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_amp_reg_chr
		"Ambient pressure sensor coherency diagnostic information available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_amp_reg_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_cata_nok_cge
		"Enable status of diagnosis"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_cata_nok_cge 
    ECU_ADDRESS 0xd0002ba5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_comb_bas_req
		"Boolean indicates a request of combustion mode for OBD analysis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_comb_bas_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_crk_no_sig
		"no crankshaft signal diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000280a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_cru
		"Diag Authorization for Cruise Control"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_cru 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002922 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_cru_sl
		"Diag Authorization for Cruise Control and Speed limiter"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_cru_sl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002923 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_egr_byp_blk
		"EGR bypass diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002650 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_emtv_ofs
		"Offset Learning diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_emtv_ofs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000287e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_emtv_reg_err
		"Blocked during regulation diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_emtv_reg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000287f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_ex_prs_no_lk
		"Ex man pres sens no link diagnostic information available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_ex_prs_nok
		"Ex man pres sens plausibility diagnostic information available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_it_ofs
		"Enables the diagnosis of the learnt offset."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_it_ofs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_it_reg_err
		"Enables the regulation diagnosis (component blocked during regulation)."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_it_reg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_maf_reg_neg_err
		"MAF regulation negative error diagnostic authorisation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002656 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_mafs_plau
		"Flag indicating that all conditions are satisfied for air mass flow sensor drift diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_mafs_plau 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000279c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_map_nok_apc
		"Manifold pressure sensor nok diagnostic information available during APC"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_map_nok_apc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_map_nok_isr
		"Manifold pressure sensor nok diagnostic information available during ISR"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_map_nok_isr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_oil_dil_nok
		"Oil dilution overshoot diagnosis authorization"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_oil_dil_nok 
    ECU_ADDRESS 0xd0002c8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_pft_stt
		"Enable status of diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_pft_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bdd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_pft_up_prs_obd_max
		"Flag of enabling CSF differential pressure SRC diagnosis."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_pft_up_prs_obd_max 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000266b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_pft_utp_neg_err
		"CSF up temp regulation : diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_pft_utp_pos_err
		"CSF up temp regulation : diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bbd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_rup_dirt_lkg
		"Flag for enabling pftrelprs sensor dynamic plausibility diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_rup_nok
		"Flag for enabling pftrelprs sensor static plausibility diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ccb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_tbf_fct_apl_down
		"temperature before particulate filter too low diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_tbf_fct_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_tbf_fct_apl_up
		"temperature before particulate filter too high diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_tbf_fct_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_unk_thpl1_chr
		"Thpl 1 coherence diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_unk_thpl1_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d5f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_unk_thpl2_chr
		"Thpl 2 coherence diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_unk_thpl2_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_unk_thpl3_chr
		"Thpl 3 coherence diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_unk_thpl3_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_unk_thpl4_chr
		"Thpl 4 coherence diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_unk_thpl4_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_unk_thpl_chr
		"Thpl coherence diagnosis authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_unk_thpl_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d63 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_vb_h
		"Battery voltage above max threshold diagnosis information available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_vb_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000281b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_vb_l
		"Battery voltage below min threshold diagnosis information available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_vb_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000281c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ena_zone
		"Flag indicating that working zone conditions are satisfied for air mass flow sensor drift diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ena_zone 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000279d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_1
		"Bit 1 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_10
		"Bit 10 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_10 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_2
		"Bit 2 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_3
		"Bit 3 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_4
		"Bit 4 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_7
		"Bit 7 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_8
		"Bit 8 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_ov_polu_zon_rls_stt_9
		"Bit 9 of release status of particulate filter for malfunction diagnosis on extra pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_ov_polu_zon_rls_stt_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_pft_rls_stt_zon_1
		"Bit 5 of diagnosis release status on pollu zone : authorizes the criteria calculation for Zone 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_pft_rls_stt_zon_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002be9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_pft_rls_stt_zon_2
		"Bit 6 of diagnosis release status on pollu zone : authorizes the criteria calculation for Zone 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_pft_rls_stt_zon_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_pft_rls_stt_zon_3
		"Bit 5 of diagnosis release status on extra pollu zone : authorizes the criteria calculation for Zone 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_pft_rls_stt_zon_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002beb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_pft_rls_stt_zon_4
		"Bit 6 of diagnosis release status on extra pollu zone : authorizes the criteria calculation for Zone 4"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_pft_rls_stt_zon_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_1
		"Bit 1 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_10
		"Bit 10 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_10 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_2
		"Bit 2 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_3
		"Bit 3 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_4
		"Bit 4 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_7
		"Bit 7 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_8
		"Bit 8 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_polu_zon_rls_stt_9
		"Bit 9 of release status of particulate filter for malfunction diagnosis on pollu zones"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_polu_zon_rls_stt_9 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_moni_abrt
		"Monitool eabort"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_moni_abrt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002776 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_moni_ena
		"Communication layer is authorizing Monitool"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_moni_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002777 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_moni_end
		"Monitool end"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_moni_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002778 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_ndec_abrt
		"ISR routine aborted status (for decrease)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_ndec_abrt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_ndec_ena
		"ISR routine activation status (for decrease)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_ndec_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dcc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_ndec_end
		"ISR routine activation status (for decrease)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_ndec_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dgissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_ninc_abrt
		"ISR routine aborted status (for increase)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_ninc_abrt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dcb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_ninc_ena
		"ISR routine activation status (for increase)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_ninc_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dcd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_ninc_end
		"ISR routine activation status (for increase)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_ninc_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dcf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_rpft_abrt
		"rpft routine aborded status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_rpft_abrt 
    ECU_ADDRESS 0xd0002bcf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_rpft_ena
		"rpft routine activation status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_rpft_ena 
    ECU_ADDRESS 0xd0002bd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_rpft_end
		"rpft routine completed status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_rpft_end 
    ECU_ADDRESS 0xd0002bd1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_stac_abrt
		"Static test routine aborted status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_stac_abrt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002782 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_stac_ena
		"Static test routine activation status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_stac_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002783 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_stac_end
		"Static test routine completed status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_stac_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002784 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_tefi_abrt
		"tefi routine aborded status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_tefi_abrt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_tefi_ena
		"tefi routine activation status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_tefi_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_diag_sta_tefi_end
		"tefi routine completed status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_diag_sta_tefi_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_dly_ini
		"Vbx_dly_ini"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002953 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_doc1_utp_dev_cdn
		"flag of deviation diagnostic condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_doc1_utp_dev_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_doc1_utp_diag_cdn
		"flag of diagnosis condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_doc1_utp_diag_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cdd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_doc1_utp_diag_swi_pup_stt
		"state of pull up commutation (0:100k, 1:1k)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_doc1_utp_diag_swi_pup_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_drag_red_agb
		"Drag reduction mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_drag_red_agb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027eb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_driv_sp_grd_mv_upd_ena
		"Condition for updating driver activity mean value calculation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_driv_sp_grd_mv_upd_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002db6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_driv_sp_mv_upd_ena
		"Condition for updating driver setpoint mean value calculation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_driv_sp_mv_upd_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002db7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_dspl_vs_abst_fil
		"Displayed vehicle speed received on the CAN network not present after a filtering time"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dspl_vs_abst_fil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002607 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dsplvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_dspl_vs_in_mph
		"The vehicule speed used for CC/SL is in mph"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dspl_vs_in_mph 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000281d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_dspl_vs_navl_fil
		"Displayed vehicle speed received on the CAN network not available after a filtering time"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dspl_vs_navl_fil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002608 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_dynssxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_dyn_is_n_sp_rst
		"Boolean indicating if an overshoot of engine speed in Cdn and Act states"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_dyn_is_n_sp_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ear_out_lim_hit_max
		"The output of egr air regulation hits the max limited value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ear_out_lim_hit_max 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ear_out_lim_hit_min
		"The output of egr air regulation hits the min limited value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ear_out_lim_hit_min 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dgtdvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ecu_pres
		"Production control unit is present"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ecu_pres 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d2f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_efi_purg_act
		"Boolean indicating that purge is active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_efi_purg_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_efi_purg_act_dly
		"Boolean indicating that purge is active delayed by the exhaust fuel line opening time"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_efi_purg_act_dly 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d3d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_efi_purg_cdn
		"Boolean indicating if purge conditions are fulfilled"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_efi_purg_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_efi_purg_dem
		"Boolean indicating a purge request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_efi_purg_dem 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d3f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_efi_purg_t_rst
		"Boolean requesting reset of time elapsed since purge start"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_efi_purg_t_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_efi_purg_wht_rst
		"Boolean requesting reset of fuel purge weight"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_efi_purg_wht_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d41 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_egb_conf_ena
		"Booleen permettant d'activer le bloc de surveillance du protocole en couple avec une TA"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egb_conf_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_egb_neut
		"Electronic GearBox is in a configuration equivalent to Neutral for a manual gearbox."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egb_neut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_byp
		"Flag of EGR bypass state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_byp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_byp_act
		"Flag of EGR bypass state before Monitool switch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_byp_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbscmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_byp_act_req
		"For for egr cooler bypass requests consolidation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_byp_act_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_byp_cmd
		"Flag of EGR bypass activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_byp_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_byp_dist_cmd
		"Anti-jamming function command"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_byp_dist_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_byp_mod_ena
		"Flag of bypass authorization depending on combustion mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_byp_mod_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_cut_ovn_slow
		"Variable fot the choice of the closing mode (fast or slow) in case of overrun shut-off"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_cut_ovn_slow 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_cut_tqi_tco_ena
		"Flag based on engine speed and gear engaged to take the tco correction in fast accel determination"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_cut_tqi_tco_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_egr_pws_rtn
		"Request to retain the EGR power supply"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_egr_pws_rtn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002880 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_windxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_el_bk_wind
		"Electric backlite  idle speed setpoint acceleration request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_el_bk_wind 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_el_csm_clc_ena
		"electric balance protection Idle speed setpoint calculation enabled"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_el_csm_clc_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000236c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_windxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_el_wind_is_acel
		"Electric windshield  idle speed setpoint acceleration request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_el_wind_is_acel 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d27 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_clos
		"Flag indicating that the component is closed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002856 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_clos_ok
		"Indicates that the EMTV is closed."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_clos_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002887 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_clos_ok_trg
		"Indicates that a closing has been done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_clos_ok_trg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002888 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_clos_req
		"Indicates a closing request."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_clos_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002881 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_crt_val_neg
		"Indicates that the negative threshold for the current limitation strategy has been reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_crt_val_neg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002869 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_crt_val_pos
		"Indicates that the positive threshold for the current limitation strategy has been reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_crt_val_pos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000286a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_cutt_res
		"Indicates that a reset of the detected failure Vbx_df_emtv_cutt is requested."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_cutt_res 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000286b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_diag_ofs_done
		"Indicates that the diagnosis of the offset is done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_diag_ofs_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002857 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_eprm_rst_tool
		"Indicates EEPROM reset asked by Diag Tools"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_eprm_rst_tool 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000286c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_eitcaes_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_it_sp_slop_on
		"Setpoint of emtv or inlet throttle position is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_it_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_lacq
		"Indicates that the EMTV is lacquered."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_lacq 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000286d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_ofs_clos_frst
		"Indicates the success of the first closed thrust learning. Stored in Sbx_emtv_ofs_clos_frst_eprm."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_ofs_clos_frst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002882 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_ofs_clos_frst_eprm
		"Inverse value Vbx_emtv_ofs_clos_frst_1_eprm. If 0, first offset done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_ofs_clos_frst_eprm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002889 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_ofs_done
		"Indicates that offset learning has been correctly completed."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_ofs_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000288a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_ofs_ena
		"Allows offset learning."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_ofs_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000288b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_ofs_fail
		"Indicates that the offset learning has failed."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_ofs_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000288c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_ofs_ok
		"Indicates that the offset learning conditions are OK."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_ofs_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000288d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_opn_fail_ena
		"Final command for opening EMTV failure mode activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_opn_fail_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002657 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_opn_fail_req
		"Global blocked EMTV failure mode request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_opn_fail_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_blk_h
		"Indicates, during full closing, if the position is higher than the maximum allowed threshold."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_blk_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000286e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_cho
		"Throttle position choice (1, throttle position, 0, open loop)."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_cho 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002883 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_clos
		"Indicates, in the case of a component blocked during  regulation, if it is closed or not."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000286f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_mv_tot_ena
		"Allows the calculation of the mean value of the position during Offset Learning."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_mv_tot_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002884 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_epolcco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_sp_cho_slop_on
		"The setpoint of the egr valve position choice is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_sp_cho_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_stab
		"Indicates the stability of the position, during the Offset Learning."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_stab 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002794 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_stab_det
		"Indicates if a new position reference has to be taken in order to check the stability."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_stab_det 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002796 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_psn_stab_ena
		"Enables the check of the position stability."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_psn_stab_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002885 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_pwl_ok
		"Indicates that the Power Latch conditions are OK."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_pwl_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000288e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_reg_blk_chk_ena
		"Enables the closing ratio calculation during a closing request (used in full_closing_diagnosis)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_reg_blk_chk_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002870 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_reg_blk_chk_ok
		"Enables the check of the closing ratio to detect a failure  (used in full_closing_diagnosis)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_reg_blk_chk_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002871 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_reg_blk_chk_stop
		"Stop the full closing diagnosis when the closing test has been successful."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_reg_blk_chk_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002872 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_sat_clos_req_co
		"enables the maf regulation by the inlet throttle when the emtv is saturated (consolidation)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_sat_clos_req_co 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a63 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_sat_clos_req_pp
		"enables the maf regulation by the inlet throttle when the emtv is saturated in pp mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_sat_clos_req_pp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_sat_clos_req_pr
		"enables the maf regulation by the inlet throttle when the emtv is saturated in pr mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_sat_clos_req_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_sat_clos_req_rij
		"enables the maf regulation by the inlet throttle when the emtv is saturated in rij mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_sat_clos_req_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_sens_pws_nok
		"Indicates an abnormal sensor power supply voltage."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_sens_pws_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002797 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_sp_max_slop_on
		"The EGR valve saturation position threshold is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_sp_max_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_emtvpsp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_sp_slop_on
		"Setpoint of emtv position is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_trt_zon
		"Indicates that the emtv is near the closed thrust."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_trt_zon 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002895 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_v_lim_down
		"Indicates that the maximum negative command voltage is reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_v_lim_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002896 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_v_lim_req
		"Indicates that a voltage limitation is needed to protect the H bridge from over current."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_v_lim_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002858 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_v_sp_cho
		"Voltage setpoint choice (if one, regulation mode, if 0, open loop)."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_v_sp_cho 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002886 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_emtv_vb_nok
		"Indicates an abnormal battery voltage that prevents a good component driving."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_emtv_vb_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002873 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_seclcxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_end_clu_cnt_on
		"End stroke sensor is activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_end_clu_cnt_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027f1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_aut_fan
		"Engine in autonomous state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_aut_fan 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eb7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_aut_fm
		"Current autonomous engine detection state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_aut_fm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_engreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_eng_crk_wait
		"Active during waiting for engine conditions before cranking (preheating, system initialization, ... )"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_crk_wait 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_ena
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_mdf1
		"Fan 1 activation request from water temperature or engine management"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_mdf1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_mdf1_dly
		"Boolean to maintan the engine coolant ECU supply during watching for engine stop"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_mdf1_dly 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eb9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_mdf1_req
		"Fan 1 activation request from water temperature or engine management"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_mdf1_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ebe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_mdf2
		"Fan 2 activation request from water temperature or engine management"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_mdf2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_mdf2_req
		"Fan 2 activation request from water temperature or engine management"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_mdf2_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ebf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_off_mdf1
		"Fan 1 activation request (engine off)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_off_mdf1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ebb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_eng_run
		"Boolean indicating running engine"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_run 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxbc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_eng_spc_acs_dsb
		"Accessories deactivation request for engine specific strategies"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_spc_acs_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_stop
		"Current stopped engine detection state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_synchro_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_eng_syn
		"Engine synchronization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_eng_syn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000280c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbssxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_etun_egr_byp_req
		"Flag of EGR bypass activation request for tuning needs or antijamming"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_etun_egr_byp_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_ctl_lih
		"Request of exhaust pressure limp home control due to boost pressure sensor failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_ctl_lih 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002633 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_lim_i_init
		"Initialisation condition in case of exhaust pressure limitation activation / desactivation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_lim_i_init 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_prs_fail_tran_req
		"Confirmed request of transient saturation (in case of exhaust pressure sensor failure only)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_prs_fail_tran_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002634 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_prs_lim_req
		"Confirmed request of exhaust pressure limitation strategy activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_prs_lim_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002635 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_prs_lim_sp_cor_ena_pr
		"Full load detection used to switch between a corrected  exhaust pressure setpoint and a basic exhaust pressure setpoint in pr"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_prs_lim_sp_cor_ena_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_prs_lim_sp_cor_ena_rij
		"Full load detection used to switch between a corrected  exhaust pressure setpoint and a basic exhaust pressure setpoint in rij"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_prs_lim_sp_cor_ena_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_prs_lim_sp_slop_on
		"Slop on flag indicating that combustion mode change is not finished"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_prs_lim_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002654 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_prs_pres
		"Exhaust pressure sensor presence signal"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_prs_pres 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002636 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_reg_apl_down
		"Turbine negative deviation sample flag (exhaust pressure deviation)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a14 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ex_reg_int_rst
		"Flag of reset of the exhaust pressure criteria integration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ex_reg_int_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a15 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monisft_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ext_ctrl_ena
		"External controls safety authorization flag"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ext_ctrl_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002773 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_evntmgr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ext_ctrl_test_act
		"External controls tests activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ext_ctrl_test_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_fail_pws_acel_pdl_v1
		"Failure on power supply of accelerator pedal track 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fail_pws_acel_pdl_v1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_fail_pws_acel_pdl_v2
		"Failure on power supply of accelerator pedal track 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fail_pws_acel_pdl_v2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_fil_rst
		"Vbx_fil_rst"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd000295b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_act_aftr
		"after injection activation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_act_aftr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_act_lpos1
		"late post injection 1 activation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_act_lpos1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002685 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_act_lpos2
		"late post injection 2 activation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_act_lpos2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002686 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_act_main
		"main injection activation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_act_main 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002689 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_act_pinj1
		"pre-injection 1 activation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_act_pinj1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_act_pinj2
		"pre-injection 2 activation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_act_pinj2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000268d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_act_post
		"post injection activation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_act_post 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_adv_slop_on
		"advance of main slop on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_adv_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_aftr_shf
		"after modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_aftr_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_bch_mod
		"Fuel mass splitting bench mode activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_bch_mod 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002695 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_cor_off
		"Switching-off corrections of fuel mass splitting"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_cor_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002696 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_efiactx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_efi_off_pr
		"Exhaust fuel injector switched off during pft regeneration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_efi_off_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ext_tq_forb_comb_trs
		"External torque request to forbid combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ext_tq_forb_comb_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_inj_nr_ok
		"Autorisation of after injection towards global number of realizable injections"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_inj_nr_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_main_ok
		"state of system check for residual main quantity due to  after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_main_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_min_ok
		"state of system check for minimum quantity of after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_ok
		"state of system check for quantity of  after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_ok_rij
		"boolean activation for after injection during rij mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_ok_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ad5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_shf
		"after quantity modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_shf_main
		"after modified by the system at main possible step"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_shf_main 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_afterxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_faf_slop_on
		"After injection quantity is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_faf_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ace 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fim_main_min_ok
		"state of system check for minimum quantity of main injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fim_main_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000268b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fim_main_shf
		"Main injection quantity modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fim_main_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ad7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp1_min_ok
		"State of system check for minimum quantity of late post injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp1_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002679 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp2_inj_nr_ok
		"Autorisation of late post injection 2 towards global number of realizable injections"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp2_inj_nr_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000267a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp2_min_ok
		"State of system check for minimum quantity of late post injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp2_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000267b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp2_ok
		"State of system check for quantity of late post injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp2_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000267c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp_inj_nr_ok
		"Autorisation of late post injection towards global number of realizable injections"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp_inj_nr_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000267d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp_min_ok
		"state of system check for minimum quantity of  late post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000267e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp_ok
		"state of system check for quantity of  late post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002687 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp_shf
		"Late post modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000267f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_lpostxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_flp_slop_on
		"Late post injection quantity is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_flp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ad6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp1_inj_nr_ok
		"Autorisation of pre-injection 1 towards global number of realizable injections"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp1_inj_nr_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002abd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp1_main_ok
		"state of system check for residual main quantity due to pre-injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp1_main_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002abe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp1_min_ok
		"state of system check for minimum quantity of pre-injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp1_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002abf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp1_ok
		"State of system check for minimum quantity of pre-injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp1_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002abb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp1_shf
		"pinj1 quantity modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp1_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp1_slop_on
		"Pre injection 1 timing is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp1_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ad8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp1_tr_on
		"The transistion of combustion mode is running for the pre injection 1 quantity"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp1_tr_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002698 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp2_inj_nr_ok
		"Autorisation of pre-injection 2 towards the global number of injection realizable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp2_inj_nr_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002691 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp2_main_ok
		"state of system check for residual main quantity due to pre-injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp2_main_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000268e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp2_min_ok
		"state of system check for minimum quantity of pre-injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp2_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002692 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp2_ok
		"State of system check for quantity of pre-injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp2_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000268f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp2_shf
		"pinj2 quantity modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp2_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002693 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp2_slop_on
		"Pre injection 2 quantity is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp2_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002697 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fp2_tr_on
		"The transistion of combustion mode is running for the pre injection 2 quantity"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fp2_tr_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002699 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_inj_nr_ok
		"Autorisation of post injection towards global number of realisable injections"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_inj_nr_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_lamb_ok
		"Lambda regulation authorized by injection system check"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_lamb_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_main_ok
		"state of system check for residual main quantity due to  post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_main_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_min_ok
		"state of system check for minimum quantity of  post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_ok
		"state of system check for quantity of  post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_shf
		"post quantity modified"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_shf_main
		"post quantity modified at main possible step"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_shf_main 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002acb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_fpo_slop_on
		"Post injection quantity is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_fpo_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ad9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_lpos1_shf
		"late post 1 modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_lpos1_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002688 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_lpos2_shf
		"Late post 2 separationmodified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_lpos2_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_lposact_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_lpos_off_pr
		"Late post injection swiched off during pft regeneration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_lpos_off_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_lpos_shf
		"late post modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_lpos_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002680 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_no_pinj
		"No activation of any pre inejction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_no_pinj 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000269a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_pinj1_ok
		"Activation of the pre injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_pinj1_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000269b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_pinj1_shf
		"pinj1 modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_pinj1_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002abc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_pinj2_ok
		"Activation of the pre injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_pinj2_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000269c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_pinj2_shf
		"pinj2 modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_pinj2_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002690 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_post_shf
		"post modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_post_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcms.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcms_fmsslpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_slop_on
		"Fuel mass splitting slop on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002adc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_taf_max_nok
		"state not ok of system check for minimum separation of after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_taf_max_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002add 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_taf_min_nok
		"state not ok of system check for minimum angle of after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_taf_min_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ade 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_taf_ok
		"state of system check for angle of after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_taf_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002adf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_taf_shf
		"after angle modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_taf_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_afterxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_taf_slop_on
		"After separation is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_taf_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_aftersc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_aftr_min_ok
		"State of system check for minimum duration of after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_aftr_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ab8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_lpos1_min_ok
		"state of system check for minimum duration of late post injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_lpos1_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002681 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_lpos2_min_ok
		"state of system check for minimum duration of late post injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_lpos2_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002682 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_lpos_min_ok
		"state of system check for minimum duration of  late post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_lpos_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002683 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_main_min_ok
		"state of system check for minimum duration of main injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_main_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000268c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_pinj1_min_ok
		"state of system check for minimum duration of pre-injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_pinj1_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_pinj2_min_ok
		"state of system check for minimum duration of pre-injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_pinj2_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002694 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_ti_post_min_ok
		"state of system check for minimum duration of  post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_ti_post_min_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002acc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp2_min_nok
		"state not ok of system check for minimal angle of late post 2 injection."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp2_min_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp2_min_nxt_cyl_nok
		"state not ok of system check for minimal angle of late post injection 2 due to the first injection of the next cylinder"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp2_min_nxt_cyl_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp2_ok
		"state of system check for angle of late post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp2_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp2_shf_tlp1
		"state of system check for shifted late post injection 1 due to the absolute position of late post injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp2_shf_tlp1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp_max_nok
		"state not ok of system check for maximal angle of late post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp_max_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp_min_nok
		"state not ok of system check for minimal angle of late post injection."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp_min_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp_ok
		"state of system check for angle of late post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp_shf
		"late post angle modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ae5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tlp_slop_on
		"Late post injection angle is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tlp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aeb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp1_max_nok
		"state not ok of system check for maximum separation of pre-injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp1_max_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp1_min_nok
		"state not ok of system check for minimum separation for pre-injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp1_min_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp1_ok
		"state of system check for separation of pre-injection 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp1_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj1sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp1_shf
		"pinj1 separation modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp1_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp1_slop_on
		"Pre injection 1 timing is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp1_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp2_max_nok
		"state not ok of system check for maximal separation of pre-injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp2_max_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp2_min_nok
		"statenot okof system check for minimal separation of pre-injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp2_min_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp2_ok
		"State of system check for minimum separation of pre-injection 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp2_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_pinj2sc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp2_shf
		"pinj2 separation modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp2_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2xx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tp2_slop_on
		"Pre injection 2 separation is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tp2_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tpo_max_nok
		"state not ok of system check for maximal angle (min separation) of post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tpo_max_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tpo_min_nok
		"state of system check for minimal angle (max separation) of post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tpo_min_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tpo_ok
		"state of system check for angle of post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tpo_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tpo_shf
		"post angle modified by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tpo_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_tpo_slop_on
		"Post injection angle is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_tpo_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_wish_flp2
		"state of system check for minimum quantity of late post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_wish_flp2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002684 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_fms_wish_max_post_ok
		"state of the system for a possible after wished quantity injected according to the torque model"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fms_wish_max_post_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002acd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_forc_gear_1
		"Vbx_forc_gear_1"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002959 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_free_shf_dft
		"Vbx_free_shf_dft"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002956 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_schxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_free_shf_dsb
		"Vbx_free_shf_dsb"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd000260c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbfulin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_frm_min_fuel
		"First CAN frame received"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_frm_min_fuel 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_frz
		"Vbx_frz"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd000295c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_schxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_fsl_cfm
		"Fixed Speed Limiter activated."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fsl_cfm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_fslsvxx_stbxxx_data.c' */
/begin MEASUREMENT
		Vbx_fsl_mstr
		"Arbitrated powertrain setpoint equal to Fixed Speed Limiter setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_fsl_mstr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002903 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_gear_cge_max_n
		"gear change indicator light flag"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_gear_cge_max_n 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_gear_stab
		"Ratio is stabilised"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_gear_stab 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_gear_vld_nok_fail
		"Gear engaged validity indicator is in the invalidity status invalid data or limp home data"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_gear_vld_nok_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002921 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_h_prs_ac_dsb
		"AC compressor inhibition due to high pressure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_h_prs_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_htg_dsb
		"Boolean indicating heating glow plug command disable (default to 1)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_htg_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_i_dsb
		"Integrator inhibit"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_i_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invficri_keyxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_igk
		"Ignition key signal"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_igk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002817 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_igk_on_sta_pws
		"Ignition key OR Power up event"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_igk_on_sta_pws 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002caf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_in_cam_lvl
		"Consolidated intake camshaft level"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_in_cam_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002803 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_schedul_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_in_vvt_cfm
		"Boolean indicating that intake VVT strategies must be activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_in_vvt_cfm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ini_drv
		"Initialization conditions with switch boolean"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ini_drv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ini_rel_err_fil
		"Conditions of reinitialisation of the filter on the relative error"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ini_rel_err_fil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000281e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ini_tout
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ini_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_rdncata_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_int_mfo_cata_nok_cge
		"Lack efficiency of oxidation catalyst diagnostic internal memorised obd failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_int_mfo_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_rdnmgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_int_mfo_egr
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_int_mfo_egr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_rdnpftx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_int_mfo_pft
		"CSF diagnostic internal memorised failue"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_int_mfo_pft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ip_dft_lght_tco
		"Water temperature alert lamp."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ip_dft_lght_tco 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_clatoxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ip_lght_tco_ovh_igk_off_ena
		"ou_clo_coo_clatoxx/over heating lamp set of snapshot data identifiers"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ip_lght_tco_ovh_igk_off_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d4b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_ip_pws_typ_bc
		"Indicates the CLUSTER power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ip_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_is_act
		"Booleen indicating if ISR calculation is authorised"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_is_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_is_blk_n_cdn
		"All conditions for the detection of engine speed hook are reunited"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_is_blk_n_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dc9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_hookxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_is_blk_vh
		"Detect if vehicle runs without engaged gear"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_is_blk_vh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_ctlfacx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_is_fac_cho
		"Boolean allowing to fall over on specific PID coefficients"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_is_fac_cho 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_schedul_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_is_loop_diag_cfm
		"Idle Speed loop diagnosis configuration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_is_loop_diag_cfm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_is_n_stab_ini
		"Initialisation of stability engine"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_is_n_stab_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_is_run_vh_min_crp
		"Detection vehicle running/creeping to specific setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_is_run_vh_min_crp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_blk_chk_ena
		"Enables the closing/opening ratio calculation during full closing or opening request."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_blk_chk_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_blk_chk_ok
		"Enables the check of the closing/opening  ratio to detect a failure - full_closing_opening_diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_blk_chk_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_blk_chk_stop
		"Stop the full closing/opening diagnosis when the test has been successful."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_blk_chk_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_clos_open_req
		"Indicates that a full closing or a full opening is requested."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_clos_open_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_clos_req
		"Indicates a closing request."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_clos_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_clos_spg_ok
		"Validity status of boost pressure dependant of inlet throttle position"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_clos_spg_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_crt_val_neg
		"Indicates that the negative threshold for the current limitation strategy has been reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_crt_val_neg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_crt_val_pos
		"Indicates that the positive threshold for the current limitation strategy has been reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_crt_val_pos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_cutt_res
		"Indicates that a reset of the detected failure Vbx_df_it_cutt is requested."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_cutt_res 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_diag_ofs_done
		"Indicates that the offset learning is done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_diag_ofs_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_diag_ofs_done_clos
		"Indicates that the closed offset learning is done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_diag_ofs_done_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_diag_ofs_done_open
		"Indicates that the open offset learning is done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_diag_ofs_done_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_eprm_rst_tool
		"EEPROM reset asked by a diagnostic tool"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_eprm_rst_tool 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_hbdg_nok
		"Failure on the Hbridge of the IT"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_hbdg_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_clos_frst
		"Indicates if the next closed thrust learning is the first one or not. Stored in Sbx_it_ofs_clos_frst"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_clos_frst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002898 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_clos_frst_0
		"Indicates if the next closed thrust learning is the first one or not. Stored in Sbx_it_ofs_clos_frst"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_clos_frst_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_clos_frst_1
		"Inverse value of Vbx_it_ofs_clos_frst_eprm. If 0, learning done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_clos_frst_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_clos_frst_2
		"Indicates that the first learning of the closed pos. has been done. If 1, learning is done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_clos_frst_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_clos_open
		"Rises to one when a closing or an opening is ordered."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_clos_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_clos_open_trg
		"Indicates that a closing or an opening is requested."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_clos_open_trg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_done
		"Indicates that the offset learning was correctly completed."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_ena
		"Boolean to allow offset learning."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_fail
		"Indicates that the offset learning failed."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_frst
		"Indicates that a first offset learning is currently completing."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_frst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_ok
		"Indicates that the offset learning conditions are OK."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_open_frst
		"Indicates wether the current open thrust learning is the first learning or not."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_open_frst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002899 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_open_frst_0
		"Indicates wether the current open thrust learning is the first learning or not."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_open_frst_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_open_frst_1
		"Inverse value of Vbx_it_ofs_open_frst_eprm. If 0, learning done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_open_frst_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_ofs_open_frst_2
		"Indicates that the first learning of the open pos. has been done. If 1, learning is done."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_ofs_open_frst_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_open
		"Flag indicating that the IT is considered as open."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000289a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_open_0
		"Flag indicating that the IT is considered as opened."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_open_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_pres
		"Flag of shut-off related to inlet throttle default"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_pres 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_cho
		"Throttle position choice (1, throttle position, 0, open loop)."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_cho 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028d9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_clos
		"Indicates, in the case of a component blocked during  regulation, if it is closed or not."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_frst_ofs_ena
		"Indicates that the first offset activation is processing."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_frst_ofs_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_mv_tot_ena
		"Boolean to allow the calculation of the mean value of the position for Offset Learning."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_mv_tot_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_reg_ol_sp_slop_on
		"Pwm command for inlet throttle is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_reg_ol_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_stab
		"Indicates the stability of the position, during the Offset Learning."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_stab 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_stab_det
		"Indicates if a new position reference has to be taken in order to check the stability."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_stab_det 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_psn_stab_ena
		"Boolean to enable the check of the position stability."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_psn_stab_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_pws_req
		"Request to maintain the power latch."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_pws_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000289b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_pws_req_0
		"Request to maintain the power latch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_pws_req_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_sat_sp_ena_pp
		"Flag of the enabling the it_sat setpoint computation in pp mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_sat_sp_ena_pp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcpr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_sat_sp_ena_pr
		"Flag of the enabling the it_sat setpoint computation in pr mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_sat_sp_ena_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_sat_sp_ena_rij
		"Flag of the enabling the it_sat setpoint computation in rij mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_sat_sp_ena_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itolcco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_sat_val_slop_on
		"The inlet throttle open loop control value is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_sat_val_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a87 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_sens_pws_nok
		"Indicates an abnormal sensor power supply voltage."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_sens_pws_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_sp_swi_frst_ofs
		"Indicates if the position setpoint is bypassed by the first offset sequence."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_sp_swi_frst_ofs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_trt_typ
		"Indicates which thrust is learnt (1 : closed one ; 0 : open one)."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_trt_typ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028dd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_trt_zon
		"Indicates that the IT is near the closed or the open thrust."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_trt_zon 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_v_lim_down
		"Indicates that the maximum negative command voltage was reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_v_lim_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_v_lim_req
		"Indicates that a voltage limitation is needed to protect the H bridge from over current."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_v_lim_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itregul_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_v_lim_up
		"Indicates that the maximum positive command voltage was reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_v_lim_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_v_sp_cho
		"Voltage setpoint choice (if one, regulation mode, if 0, open loop)."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_v_sp_cho 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_it_vb_nok
		"Indicates an abnormal battery voltage that prevents a good component driving."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_it_vb_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_l_eng_tqe
		"The minmum torque isn't saturated by the low engine minimum torque."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_l_eng_tqe 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_l_prs_ac_dsb
		"AC compressor inhibition due to low pressure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_l_prs_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_load_stop_min_dist_cond
		"Minimum distance on charging state condition active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_load_stop_min_dist_cond 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c2a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_load_stop_min_t_cond
		"Minimum time on charging state condition active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_load_stop_min_t_cond 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c2b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_long_crk_req
		"Long cranking request (request = 1)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_long_crk_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_loss_acel_pdl_v1
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_loss_acel_pdl_v1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_maf_i_reg_frz
		"Flag for freezing the I part of the maf regulator"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_maf_i_reg_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_maf_i_reg_on
		"Flag of the maf I part regulation activity"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_maf_i_reg_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_maf_p_reg_on
		"Flag of the maf P part regulation activity"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_maf_p_reg_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mafcxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_maf_reg_off
		"State flag for egr maf regulation (=1 maf reg off)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_maf_reg_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_mfldvol_stbxxd_data.c' */
/begin MEASUREMENT
		Vbx_maf_sp_npu_slop_on
		"The setpoint of the air mass flow and the EGR mass flow are in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_maf_sp_npu_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafscox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_maf_stat_sp_slop_on
		"The static setpoint of the mass air flow is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_maf_stat_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_postscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_main_post_inj_sat_min
		"Post injection cut off due to minimum quantity not reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_main_post_inj_sat_min 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ac7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mapc_ad_ena
		"Flag to allow mean value calculation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mapc_ad_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mapc_ad_end
		"Flag to allow storage of the manifold pressure correction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mapc_ad_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mapc_cdn_ok
		"Flag indicating that ambiant conditions for MAP correction learning are satisfied"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mapc_cdn_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mapc_eng_stop
		"Flag indicating an engine stopped"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mapc_eng_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mapc_it_psn_ok
		"Flag indicating an inlet throttle position right for plausibility diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mapc_it_psn_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mapc_no_fail_apc
		"No failure detected for diagnostic during APC"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mapc_no_fail_apc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mapc_no_fail_isr
		"No failure detected for diagnostic during ISR"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mapc_no_fail_isr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_max_n_fl_tkof_act
		"Specific limitation during the take off (idiot start)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_max_n_fl_tkof_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_max_n_fl_tkof_cdn
		"Condition for the specific limitation during the take off"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_max_n_fl_tkof_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029d9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_max_prot_spg_tqe_act
		"Maximum effective torque limitation for supercharger protection activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_max_prot_spg_tqe_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_max_rams_tqe_1_on
		"Safety torque limitation level 1 activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_max_rams_tqe_1_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000261b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_max_rams_tqe_2_on
		"Safety torque limitation level 2 activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_max_rams_tqe_2_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000261c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_max_rams_tqe_3_on
		"Safety torque limitation level 3 activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_max_rams_tqe_3_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000261d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdf1
		"Fan 1 activation request from water temperature or engine management"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ebc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdf1_cmd
		"Low speed engine fan command"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf1_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdf1_cmd_dly
		"Low speed engine fan delayed command"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf1_cmd_dly 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002900 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mdf1_comb_mod_req
		"combustion mode fan 1 request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf1_comb_mod_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eaf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdf2
		"Fan 2 activation request from water temperature or engine management"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ebd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdf2_cmd
		"High speed engine fan command"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf2_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002901 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdf2_cmd_dly
		"High speed engine fan delayed command"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf2_cmd_dly 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002902 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanrqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mdf2_comb_mod_req
		"combustion mode fan 2 request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf2_comb_mod_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcoospt_cteaubc_data.c' */
/begin MEASUREMENT
		Vbx_mdf2_reg
		"High temperature mode regulation authorisation for Mdf2."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf2_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdf_pws
		"The engine coolant function wishes that the ECU remains supplied."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdf_pws 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ec0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mdl_maf_dyn_ok
		"Intermediate dynamic mass air flow from model validity status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdl_maf_dyn_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mdl_tra_acel_ok
		"The value of the transverse acceleration is valid"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mdl_tra_acel_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002821 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mil_ecu_req
		"MIL activation request of engine control unit"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mil_ecu_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dglpgin_stbxxx_data.c' */
/begin MEASUREMENT
		Vbx_mil_gcu_req
		"MIL activation request of lpg control unit"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mil_gcu_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ece 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_mil_prmt_req
		"MIL illumination gobal request status (0 switch off, 1 switch on)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mil_prmt_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002caa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgmltin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mil_tcu_req
		"MIL activation request of transmission control unit"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mil_tcu_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002af1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbfulin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_min_fuel_navl
		"Minimum level of fuel level from DiagnoseFuelLow is not available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_min_fuel_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_appl_err
		"Applicative error flag"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_appl_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002780 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_moni_as_req
		"Activation of the identifiers 10, 13, 15 or 1a control"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_as_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_dbl_nok
		"Indicates if an identifier is duplicated in the request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_dbl_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002779 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_id_nok
		"Indicates if the requested identifiers are not ok (not supported or duplicated)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_id_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000277a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_nr_tot_id_nok
		"Indicates if the number of the requested identifiers is higher than 15"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_nr_tot_id_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000277b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_oor
		"Indicates whether at least a replacement value requested for a component is out of range"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000277c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_read_req_done
		"Indicates when the data extraction is finished"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_read_req_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000277d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_req_analyse
		"Trigger request analyse"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_req_analyse 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000277e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_req_data_changed
		"Request changed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_req_data_changed 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000277f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_moni_stop_diag
		"Monitool requests to stop all required diagnostics"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_moni_stop_diag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002781 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[100]
		"Activation of the identifier 64"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_64_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002759 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[101]
		"Activation of the identifier 65"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_65_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000275a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[102]
		"Activation of the identifier 66"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_66_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000275b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[103]
		"Activation of the identifier 67"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_67_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000275c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[104]
		"Activation of the identifier 68"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_68_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000275d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[105]
		"Activation of the identifier 69"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_69_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000275e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[106]
		"Activation of the identifier 6a"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_6a_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000275f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[107]
		"Activation of the identifier 6b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_6b_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002760 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[108]
		"Activation of the identifier 6c"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_6c_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002761 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[109]
		"Activation of the identifier 6d"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_6d_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002762 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[10]
		"Activation of the identifier 0a"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_0a_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[110]
		"Activation of the identifier 6e"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_6e_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002763 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[111]
		"Activation of the identifier 6f"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_6f_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002764 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[112]
		"Activation of the identifier 70"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_70_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002765 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[113]
		"Activation of the identifier 71"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_71_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002766 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[121]
		"Activation of the identifier 79"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_79_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000276e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[16]
		"Activation of the identifier 10"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_10_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002705 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[17]
		"Activation of the identifier 11"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_11_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002706 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[19]
		"Activation of the identifier 13"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_13_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002708 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[1]
		"Activation of the identifier 01"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_01_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[20]
		"Activation of the identifier 14"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_14_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002709 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[24]
		"Activation of the identifier 18"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_18_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000270d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[25]
		"Activation of the identifier 19"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_19_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000270e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[26]
		"Activation of the identifier 1a"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_1a_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000270f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[27]
		"Activation of the identifier 1b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_1b_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002710 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[28]
		"Activation of the identifier 1c"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_1c_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002711 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[29]
		"Activation of the identifier 1d"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_1d_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002712 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[30]
		"Activation of the identifier 1e"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_1e_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002713 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[31]
		"Activation of the identifier 1f"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_1f_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002714 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
