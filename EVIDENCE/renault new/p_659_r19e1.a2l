/*
_______________________________________________________________________________
     ____    ____
     \   |  |   /       _______             ___              _
      \  \  /  /    _  (__   __)_      _   / _ \ _   _      (_)
       \  \/  / \  / | _  | | /  \ __ | | / / \_\ |_| | __  | | _   _
        \    /|  \/  || | | |/ /\ \  \| | | |   |  _  |/  \ | || \ | |
        /    \| |\/| || | | |\ \/ //\ \ |_| |  _| | | | /\ \| ||  \| |
       /  /\  \_|  |_|| |_| | \__/ \/ /____)\_/ /_| |_|/==\ \_|| |\  |
      /  /  \  \      |____)|     \__/     \___/    /_/    \_\ |_| \_|
     /___|  |___\

                                 XmlToolChain
             Bosch SW     ________________________   Customer SW 
         _______________ /                        \________________
   _ ___/               /    __________________    \               \___ _
       /    ___________/    /_    \      /    _\    \ __________    \
   _ _/    /_    \    /    /  \    \    /    /  \    \    /    _\    \_ _
     /    /  \    \   \    \   \    \  /    /   /    /   /    /  \    \
     \    \   \    \   \    \__/    /__\    \__/    /   /    /   /    /
      \    \__/    /____\_____/    /    \    \_____/____\    \__/    /
   _ __\_____/    /               /______\               \    \_____/__ _
                 /_______________/        \_______________\
   _ ___________/                                          \___________ _

                                     v0.04
                                    =======
                                      ===

                        Miguet Sebastien (DGS-EC/ECP5-RN)
                         e-mail  : sebastien.miguet@fr.bosch.com
                         Tel     : +33 1 40 10 7 666
                         Address : Robert Bosch France SAS
                                   32, Av Michelet
                                   F-93404 Saint-Ouen
                                   France

         (c) 2007-2008 Robert Bosch France SAS, all rights reserved

    ______________________________________________________________
   /\   ________________________________________________________  \
  /  \  \______________________________________________________/\  \
 /    \__\     ______    ______    ______    ______    __  __  \ \__\
 \    /__/    /\  __ \  /\  __ \  /\  ___\  /\  ___\  /\ \/\ \  \/__/
  \   \       \ \ \_\ \ \ \ \/\ \ \ \ \__/_ \ \ \__/  \ \ \_\ \     \
   \   \       \ \  __ \ \ \ \ \ \ \ \____ \ \ \ \     \ \  __ \     \
    \   \       \ \ \_\ \ \ \ \_\ \ \/__/_\ \ \ \ \____ \ \ \ \ \     \
     \   \  ___  \ \_____\ \ \_____\  /\_____\ \ \_____\ \ \_\ \_\     \__
      \   \/\  \  \/_____/  \/_____/  \/_____/  \/_____/  \/_/\/_/    /\  \ 
       \     \  \_____________________________________________________\_\  \
        \     \_____________________________________________________________\
         \    /                                                             /
          \  /                   * Invented for Life *                     /
           \/_____________________________________________________________/


_______________________________________________________________________________

 */
ASAP2_VERSION  1 4
/* Erstellt von DAMOS++ V3.17-1 Win2000 */
/begin PROJECT P_659 "EMS2010"
  /begin HEADER ""
    VERSION    "r19e1_"
    PROJECT_NO P_659
  /end HEADER

  /begin MODULE DIM ""

  /begin A2ML 
/************************************************************************************/
/*                                                                                  */
/*   ASAP2 meta language for XCP protocol layer V1.0                                */
/*                                                                                  */
/*   2003-03-03                                                                     */
/*                                                                                  */
/*   Vector Informatik, Schuermans                                                  */
/*                                                                                  */
/*   Datatypes:                                                                     */
/*                                                                                  */
/*   A2ML       ASAP2             Windows      description                          */
/*   -------------------------------------------------------------------------------*/
/*   uchar      UBYTE             BYTE         unsigned 8 Bit                       */
/*   char       SBYTE             char         signed 8 Bit                         */
/*   uint       UWORD             WORD         unsigned integer 16 Bit              */
/*   int        SWORD             int          signed integer 16 Bit                */
/*   ulong      ULONG             DWORD        unsigned integer 32 Bit              */
/*   long       SLONG             LONG         signed integer 32 Bit                */
/*   float      FLOAT32_IEEE                   float 32 Bit                         */
/*                                                                                  */
/************************************************************************************/
/*********************** start of PROTOCOL_LAYER ****************************/

struct Protocol_Layer {     /* At MODULE */

  uint;                                /* XCP protocol layer version */
                                       /* e.g. "1.0" = 0x0100            */

  uint;                                /* T1 [ms] */
  uint;                                /* T2 [ms] */
  uint;                                /* T3 [ms] */
  uint;                                /* T4 [ms] */
  uint;                                /* T5 [ms] */
  uint;                                /* T6 [ms] */
  uint;                                /* T7 [ms] */

  uchar;                               /* MAX_CTO */
  uint;                                /* MAX_DTO */

  enum {                               /* BYTE_ORDER */
    "BYTE_ORDER_MSB_LAST"  = 0,
    "BYTE_ORDER_MSB_FIRST" = 1
  };

  enum {                               /* ADDRESS_GRANULARITY */
    "ADDRESS_GRANULARITY_BYTE"    = 1,
    "ADDRESS_GRANULARITY_WORD"    = 2,
    "ADDRESS_GRANULARITY_DWORD"   = 4
  };

  taggedstruct {                       /* optional                     */

    ("OPTIONAL_CMD" enum {             /* XCP-Code of optional command */
                                       /* supported by the slave       */

      "GET_COMM_MODE_INFO"       = 0xFB,
      "GET_ID"                   = 0xFA,
      "SET_REQUEST"              = 0xF9,
      "GET_SEED"                 = 0xF8,
      "UNLOCK"                   = 0xF7,
      "SET_MTA"                  = 0xF6,
      "UPLOAD"                   = 0xF5,
      "SHORT_UPLOAD"             = 0xF4,
      "BUILD_CHECKSUM"           = 0xF3,
      "TRANSPORT_LAYER_CMD"      = 0xF2,
      "USER_CMD"                 = 0xF1,
      "DOWNLOAD"                 = 0xF0,
      "DOWNLOAD_NEXT"            = 0xEF,
      "DOWNLOAD_MAX"             = 0xEE,
      "SHORT_DOWNLOAD"           = 0xED,
      "MODIFY_BITS"              = 0xEC,
      "SET_CAL_PAGE"             = 0xEB,
      "GET_CAL_PAGE"             = 0xEA,
      "GET_PAG_PROCESSOR_INFO"   = 0xE9,
      "GET_SEGMENT_INFO"         = 0xE8,
      "GET_PAGE_INFO"            = 0xE7,
      "SET_SEGMENT_MODE"         = 0xE6,
      "GET_SEGMENT_MODE"         = 0xE5,
      "COPY_CAL_PAGE"            = 0xE4,
      "CLEAR_DAQ_LIST"           = 0xE3,
      "SET_DAQ_PTR"              = 0xE2,
      "WRITE_DAQ"                = 0xE1,
      "SET_DAQ_LIST_MODE"        = 0xE0,
      "GET_DAQ_LIST_MODE"        = 0xDF,
      "START_STOP_DAQ_LIST"      = 0xDE,
      "START_STOP_SYNCH"         = 0xDD,
      "GET_DAQ_CLOCK"            = 0xDC,
      "READ_DAQ"                 = 0xDB,
      "GET_DAQ_PROCESSOR_INFO"   = 0xDA,
      "GET_DAQ_RESOLUTION_INFO"  = 0xD9,
      "GET_DAQ_LIST_INFO"        = 0xD8,
      "GET_DAQ_EVENT_INFO"       = 0xD7,
      "FREE_DAQ"                 = 0xD6,
      "ALLOC_DAQ"                = 0xD5,
      "ALLOC_ODT"                = 0xD4,
      "ALLOC_ODT_ENTRY"          = 0xD3,
      "PROGRAM_START"            = 0xD2,
      "PROGRAM_CLEAR"            = 0xD1,
      "PROGRAM"                  = 0xD0,
      "PROGRAM_RESET"            = 0xCF,
      "GET_PGM_PROCESSOR_INFO"   = 0xCE,
      "GET_SECTOR_INFO"          = 0xCD,
      "PROGRAM_PREPARE"          = 0xCC,
      "PROGRAM_FORMAT"           = 0xCB,
      "PROGRAM_NEXT"             = 0xCA,
      "PROGRAM_MAX"              = 0xC9,
      "PROGRAM_VERIFY"           = 0xC8

    })*;

    "COMMUNICATION_MODE_SUPPORTED" taggedunion { /* optional modes supported */
       "BLOCK" taggedstruct {
          "SLAVE";                  /* Slave Block Mode supported  */
          "MASTER" struct {         /* Master Block Mode supported */
             uchar;  /* MAX_BS */
             uchar;  /* MIN_ST */
          };
       };
       "INTERLEAVED" uchar;    /* QUEUE_SIZE */
    };

    "SEED_AND_KEY_EXTERNAL_FUNCTION" char[256];  /* Name of the Seed&Key function */
                                                 /* including file extension      */
                                                 /* without path                  */
  };

}; /********************* end of PROTOCOL_LAYER *****************************/

/***************************** start of DAQ *********************************/
struct Daq {                         /* DAQ supported, at MODULE*/
  enum {                             /* DAQ_CONFIG_TYPE */
    "STATIC"  = 0,
    "DYNAMIC" = 1
  };

  uint;                               /* MAX_DAQ */
  uint;                               /* MAX_EVENT_CHANNEL */
  uchar;                              /* MIN_DAQ */

  enum {                            /* OPTIMISATION_TYPE */
    "OPTIMISATION_TYPE_DEFAULT"            = 0,
    "OPTIMISATION_TYPE_ODT_TYPE_16"        = 1,
    "OPTIMISATION_TYPE_ODT_TYPE_32"        = 2,
    "OPTIMISATION_TYPE_ODT_TYPE_64"        = 3,
    "OPTIMISATION_TYPE_ODT_TYPE_ALIGNMENT" = 4,
    "OPTIMISATION_TYPE_MAX_ENTRY_SIZE"     = 5
  };

  enum {                           /* ADDRESS_EXTENSION */
    "ADDRESS_EXTENSION_FREE" = 0,
    "ADDRESS_EXTENSION_ODT"  = 1,
    "ADDRESS_EXTENSION_DAQ"  = 3
  };


  enum {                           /* IDENTIFICATION_FIELD */
    "IDENTIFICATION_FIELD_TYPE_ABSOLUTE"              = 0,
    "IDENTIFICATION_FIELD_TYPE_RELATIVE_BYTE"         = 1,
    "IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD"         = 2,
    "IDENTIFICATION_FIELD_TYPE_RELATIVE_WORD_ALIGNED" = 3
  };


  enum {                        /* GRANULARITY_ODT_ENTRY_SIZE_DAQ */
    "GRANULARITY_ODT_ENTRY_SIZE_DAQ_BYTE"    = 1,
    "GRANULARITY_ODT_ENTRY_SIZE_DAQ_WORD"    = 2,
    "GRANULARITY_ODT_ENTRY_SIZE_DAQ_DWORD"   = 4,
    "GRANULARITY_ODT_ENTRY_SIZE_DAQ_DLONG"   = 8
  };

  uchar;                              /* MAX_ODT_ENTRY_SIZE_DAQ */

  enum {                              /* OVERLOAD_INDICATION */
    "NO_OVERLOAD_INDICATION"    = 0,
    "OVERLOAD_INDICATION_PID"   = 1,
    "OVERLOAD_INDICATION_EVENT" = 2
  };

  taggedstruct {                      /* optional */
    "PRESCALER_SUPPORTED";
    "RESUME_SUPPORTED";

    block "STIM" struct {             /* STIM supported */

      enum {                      /* GRANULARITY_ODT_ENTRY_SIZE_STIM */
        "GRANULARITY_ODT_ENTRY_SIZE_STIM_BYTE"   = 1,
        "GRANULARITY_ODT_ENTRY_SIZE_STIM_WORD"   = 2,
        "GRANULARITY_ODT_ENTRY_SIZE_STIM_DWORD"  = 4,
        "GRANULARITY_ODT_ENTRY_SIZE_STIM_DLONG"  = 8
      };

      uchar;                          /* MAX_ODT_ENTRY_SIZE_STIM */

      taggedstruct {                  /* bitwise stimulation */
        "BIT_STIM_SUPPORTED";
      };
    };

    block "TIMESTAMP_SUPPORTED" struct {
      uint;                           /* TIMESTAMP_TICKS */
      enum { /* TIMESTAMP_SIZE */
        "NO_TIME_STAMP" = 0,
        "SIZE_BYTE"     = 1,
        "SIZE_WORD"     = 2,
        "SIZE_DWORD"    = 4
      };
      enum { /* RESOLUTION OF TIMESTAMP */
        "UNIT_1NS"   = 0,
        "UNIT_10NS"  = 1,
        "UNIT_100NS" = 2,
        "UNIT_1US"   = 3,
        "UNIT_10US"  = 4,
        "UNIT_100US" = 5,
        "UNIT_1MS"   = 6,
        "UNIT_10MS"  = 7,
        "UNIT_100MS" = 8,
        "UNIT_1S"    = 9
      };
      taggedstruct {
        "TIMESTAMP_FIXED";
      };
    };

    "PID_OFF_SUPPORTED";

    /************************ start of DAQ_LIST *************************/

    (block "DAQ_LIST" struct {          /* DAQ_LIST                    */
                                        /* multiple possible           */
      uint;                             /* DAQ_LIST_NUMBER             */
      taggedstruct {                            /* optional */
        "DAQ_LIST_TYPE" enum {
          "DAQ"      = 1,               /* DIRECTION = DAQ only     */
          "STIM"     = 2,               /* DIRECTION = STIM only    */
          "DAQ_STIM" = 3                /* both directions possible */
                                        /* but not simultaneously   */
        };

        "MAX_ODT"         uchar;        /* MAX_ODT         */
        "MAX_ODT_ENTRIES" uchar;        /* MAX_ODT_ENTRIES */

        "FIRST_PID" uchar;              /* FIRST_PID for this DAQ_LIST */
        "EVENT_FIXED" uint;             /* this DAQ_LIST always        */
                                        /* in this event               */
        block "PREDEFINED" taggedstruct { /* predefined                */
                                          /* not configurable DAQ_LIST */
           (block "ODT" struct {
                   uchar;                   /* ODT number */
                   taggedstruct {
                       ("ODT_ENTRY" struct {
                                   uchar;   /* ODT_ENTRY number            */
                                   ulong;   /* address of element                 */
                                   uchar;   /* address extension of element */
                                   uchar;   /* size of element [AG]                */
                                   uchar;   /* BIT_OFFSET                          */
                         })*;
                   }; /* end of ODT_ENTRY */
            })*; /* end of ODT */
         }; /* end of PREDEFINED */
      };
    })*;/********************* end of DAQ_LIST ***************************/

    /************************* start of EVENT ****************************/

    (block "EVENT" struct {             /* EVENT               */
                                        /* multiple possible   */
      char[101];                        /* EVENT_CHANNEL_NAME       */
      char[9];                          /* EVENT_CHANNEL_SHORT_NAME */
      uint;                             /* EVENT_CHANNEL_NUMBER     */

      enum {
        "DAQ"      = 1,                 /* only DAQ_LISTs         */
                                        /* with DIRECTION = DAQ   */
        "STIM"     = 2,                 /* only DAQ_LISTs         */
                                        /* with DIRECTION = STIM  */
        "DAQ_STIM" = 3                  /* both kind of DAQ_LISTs */
      };

      uchar;                            /* MAX_DAQ_LIST */
      uchar;                            /* TIME_CYCLE   */
      uchar;                            /* TIME_UNIT    */
      uchar;                            /* PRIORITY     */

    })*;/******************** end of EVENT ********************************/

  }; /* end of optional at DAQ */

}; /************************* end of DAQ *************************************/


/**************************** start of DAQ_EVENT *****************************/

taggedunion Daq_Event {         /* at MEASUREMENT */
   "FIXED_EVENT_LIST" taggedstruct {
      ("EVENT" uint)* ;
   };
   "VARIABLE" taggedstruct {
      block "AVAILABLE_EVENT_LIST" taggedstruct {
         ("EVENT" uint)*;
      };
      block "DEFAULT_EVENT_LIST" taggedstruct {
         ("EVENT" uint)*;
      };
   };
}; /************************* end of DAQ_EVENT *******************************/


/**************************** start of PAG ***********************************/

struct Pag {                  /* PAG supported, at MODULE */
  uchar;                      /* MAX_SEGMENTS */
  taggedstruct {              /* optional */
    "FREEZE_SUPPORTED";
  };

}; /************************* end of PAG *************************************/


/**************************** start of PGM ***********************************/

struct Pgm {                  /* PGM supported, at MODULE */

  enum {
    "PGM_MODE_ABSOLUTE"                = 1,
    "PGM_MODE_FUNCTIONAL"              = 2,
    "PGM_MODE_ABSOLUTE_AND_FUNCTIONAL" = 3
  };
  uchar;                               /* MAX_SECTORS */
  uchar;                               /* MAX_CTO_PGM */

  taggedstruct {                       /* optional                */
    (block "SECTOR" struct {           /* SECTOR                  */
                                       /* multiple possible       */
      char[101];                       /* SECTOR_NAME             */
      uchar;                           /* SECTOR_NUMBER           */
      ulong;                           /* Address                 */
      ulong;                           /* Length                  */
      uchar;                           /* CLEAR_SEQUENCE_NUMBER   */
      uchar;                           /* PROGRAM_SEQUENCE_NUMBER */
      uchar;                           /* PROGRAM_METHOD          */
    })*; /* end of SECTOR */

    "COMMUNICATION_MODE_SUPPORTED" taggedunion { /* optional modes supported */
       "BLOCK" taggedstruct {
          "SLAVE";                  /* Slave Block Mode supported  */
          "MASTER" struct {         /* Master Block Mode supported */
             uchar;  /* MAX_BS_PGM */
             uchar;  /* MIN_ST_PGM */
          };
       };
     "INTERLEAVED" uchar;    /* QUEUE_SIZE_PGM */
     };
  };
}; /************************** end of PGM *************************************/


/***************************** start of SEGMENT *******************************/

struct Segment {               /* at MEMORY_SEGMENT */
  uchar;                               /* SEGMENT_NUMBER     */
  uchar;                               /* number of pages    */
  uchar;                               /* ADDRESS_EXTENSION  */
  uchar;                               /* COMPRESSION_METHOD */
  uchar;                               /* ENCRYPTION_METHOD  */

  taggedstruct {                       /* optional           */
    block "CHECKSUM" struct {
      enum {                           /* checksum type      */
        "XCP_ADD_11"       =   1,
        "XCP_ADD_12"       =   2,
        "XCP_ADD_14"       =   3,
        "XCP_ADD_22"       =   4,
        "XCP_ADD_24"       =   5,
        "XCP_ADD_44"       =   6,
        "XCP_CRC_16"       =   7,
        "XCP_CRC_16_CITT"  =   8,
        "XCP_CRC_32"       =   9,
        "XCP_USER_DEFINED" = 255
      };

      taggedstruct {
        "MAX_BLOCK_SIZE"              ulong ;    /* maximum block size            */
                                                 /* for checksum calculation      */
        "EXTERNAL_FUNCTION" char[256];           /* Name of the Checksum function */
                                                 /* including file extension      */
                                                 /* without path                  */
      };
    };

    (block "PAGE" struct {               /* PAGES for this SEGMENT */
                                         /* multiple possible      */
      uchar;                             /* PAGE_NUMBER            */

      enum {            /* ECU_ACCESS_TYPE */
          "ECU_ACCESS_NOT_ALLOWED"      = 0,
          "ECU_ACCESS_WITHOUT_XCP_ONLY" = 1,
          "ECU_ACCESS_WITH_XCP_ONLY"    = 2,
          "ECU_ACCESS_DONT_CARE"        = 3
       };

      enum {       /* XCP_READ_ACCESS_TYPE */
          "XCP_READ_ACCESS_NOT_ALLOWED"      = 0,
          "XCP_READ_ACCESS_WITHOUT_ECU_ONLY" = 1,
          "XCP_READ_ACCESS_WITH_ECU_ONLY"    = 2,
          "XCP_READ_ACCESS_DONT_CARE"        = 3
       };

      enum {      /* XCP_WRITE_ACCESS_TYPE */
          "XCP_WRITE_ACCESS_NOT_ALLOWED"      = 0,
          "XCP_WRITE_ACCESS_WITHOUT_ECU_ONLY" = 1,
          "XCP_WRITE_ACCESS_WITH_ECU_ONLY"    = 2,
          "XCP_WRITE_ACCESS_DONT_CARE"        = 3
      };
      taggedstruct {
        "INIT_SEGMENT" uchar; /* references segment that initialises this page */
      };

    })*; /* end of PAGE */

    (block "ADDRESS_MAPPING" struct {  /* multiple possible   */
                         ulong;        /* source address      */
                         ulong;        /* destination address */
                         ulong;        /* length              */
    })*;

    "PGM_VERIFY" ulong; /* verification value for PGM */
  }; /* end of optional */

}; /************************** end of SEGMENT *********************************/

/*********************** start of Common Parameters ***************************/

taggedstruct Common_Parameters {

  block "PROTOCOL_LAYER" struct Protocol_Layer;

  block "SEGMENT" struct Segment;

  block "DAQ" struct Daq;
  block "PAG" struct Pag;
  block "PGM" struct Pgm;

  block "DAQ_EVENT" taggedunion Daq_Event;

}; /******************** end of Common Parameters *****************************/
/************************************************************************************/
/*                                                                                  */
/* ASAP2 meta language for XCP on CAN V1.0                                          */
/*                                                                                  */
/* 2003-03-03                                                                       */
/*                                                                                  */
/* Vector Informatik, Schuermans                                                    */
/*                                                                                  */
/* Datatypes:                                                                       */
/*                                                                                  */
/* A2ML ASAP2 Windows description                                                   */
/* ---------------------------------------------------------------------------------*/
/* uchar UBYTE BYTE unsigned 8 Bit                                                  */
/* char SBYTE char signed 8 Bit                                                     */
/* uint UWORD WORD unsigned integer 16 Bit                                          */
/* int SWORD int signed integer 16 Bit                                              */
/* ulong ULONG DWORD unsigned integer 32 Bit                                        */
/* long SLONG LONG signed integer 32 Bit                                            */
/* float FLOAT32_IEEE float 32 Bit                                                  */
/*                                                                                  */
/************************************************************************************/
/************************ start of CAN **********************************************/
struct CAN_Parameters { /* At MODULE */
  uint; /* XCP on CAN version */
        /* e.g. "1.0" = 0x0100 */
  taggedstruct { /* optional */
    "CAN_ID_BROADCAST" ulong; /* Auto detection CAN-ID */
                              /* master -> slaves */
                              /* Bit31= 1: extended identifier */
    "CAN_ID_MASTER" ulong;    /* CMD/STIM CAN-ID */
                              /* master -> slave */
                              /* Bit31= 1: extended identifier */
    "CAN_ID_SLAVE" ulong;     /* RES/ERR/EV/SERV/DAQ CAN-ID */
                              /* slave -> master */
                              /* Bit31= 1: extended identifier */
    "BAUDRATE" ulong;         /* BAUDRATE [Hz] */
    "SAMPLE_POINT" uchar;     /* sample point */
                              /* [% complete bit time] */
    "SAMPLE_RATE" enum {
      "SINGLE" = 1,           /* 1 sample per bit */
      "TRIPLE" = 3            /* 3 samples per bit */
    };
    "BTL_CYCLES" uchar;       /* BTL_CYCLES */
                              /* [slots per bit time] */
    "SJW" uchar;              /* length synchr. segment */
                              /* [BTL_CYCLES] */
    "SYNC_EDGE" enum {
      "SINGLE" = 1,           /* on falling edge only */
      "DUAL" = 2              /* on falling and rising edge */
    };
    "MAX_DLC_REQUIRED";       /* master to slave frames */
                              /* always to have DLC = MAX_DLC = 8 */
    (block "DAQ_LIST_CAN_ID" struct { /* At IF_DATA DAQ */
      uint;                   /* reference to DAQ_LIST_NUMBER */
      taggedstruct {          /* exclusive tags */
                              /* either VARIABLE or FIXED */
        "VARIABLE";
        "FIXED" ulong;        /* this DAQ_LIST always */
                              /* on this CAN_ID */
      };
    })*;
  };
};/************************* end of CAN ***********************************/
/****************************************************************************/
/*                                                                          */
/*   ASAP2 meta language for XCP on USB V1.0                                */
/*   Assumes ASAP2 V1.4 or later                                            */
/*                                                                          */
/*   2003-12-16                                                             */
/*                                                                          */
/*   XCP on USB working group                                               */
/*                                                                          */
/*   Datatypes:                                                             */
/*                                                                          */
/* A2ML   ASAP2                 Windows         description                        */
/* ------------------------------------------------------------------------ */
/* uchar  UBYTE                 BYTE                 unsigned 8 Bit                     */
/* char   SBYTE                 char                 signed 8 Bit                       */
/* uint   UWORD                 WORD                 unsigned integer 16 Bit            */
/* int    SWORD                 int                 signed integer 16 Bit              */
/* ulong  ULONG                 DWORD                 unsigned integer 32 Bit            */
/* long   SLONG                 LONG                 signed integer 32 Bit              */
/* float  FLOAT32_IEEE                        float 32 Bit                       */
/****************************************************************************/
/************************ start of USB **************************************/
struct ep_parameters {
    uchar;                         /* ENDPOINT_NUMBER, not endpoint address */
    enum {
        "BULK_TRANSFER"         = 2,     /* Numbers according to USB spec.  */
        "INTERRUPT_TRANSFER"    = 3
    };
    uint;                                /* wMaxPacketSize: Maximum packet  */
                                         /* size of endpoint in bytes       */
    uchar;                               /* bInterval: polling of endpoint  */

    enum {                               /* Packing of XCP Messages         */
        "MESSAGE_PACKING_SINGLE"    = 0, /* Single per USB data packet      */
        "MESSAGE_PACKING_MULTIPLE"  = 1, /* Multiple per USB data packet    */
        "MESSAGE_PACKING_STREAMING" = 2  /* No restriction by packet sizes  */
    };
    enum {                               /* Alignment mandatory for all     */
        "ALIGNMENT_8_BIT" = 0,           /* packing types                   */
        "ALIGNMENT_16_BIT"= 1,
        "ALIGNMENT_32_BIT"= 2,
        "ALIGNMENT_64_BIT"= 3
    };

    taggedstruct {                       /* Optional */
        "RECOMMENDED_HOST_BUFSIZE" uint; /* Recommended size for the host   */
                                         /* buffer size. The size is defined*/
                                         /* as multiple of wMaxPacketSize.  */
    };
}; /* end of ep_parameters */



struct USB_Parameters {
    uint;                                /* XCP on USB version  */
                                         /* e.g. "1.0" = 0x0100 */

    uint;                                /* Vendor ID                       */
    uint;                                /* Product ID                      */
    uchar;                               /* Number of interface             */


    enum {
        "HEADER_LEN_BYTE"       = 0,
        "HEADER_LEN_CTR_BYTE"   = 1,
        "HEADER_LEN_FILL_BYTE"  = 2,
        "HEADER_LEN_WORD"       = 3,
        "HEADER_LEN_CTR_WORD"   = 4,
        "HEADER_LEN_FILL_WORD"  = 5
    };

    /* OUT-EP for CMD and                                                   */
    /* STIM (additional USB Endpoints may also be specified)                */
    taggedunion {
        block "OUT_EP_CMD_STIM" struct ep_parameters;
    };

    /* IN-EP for RES/ERR,                                                   */
    /* DAQ (additional USB Endpoints may also be specified)                 */
    /* and EV/SERV (if not specified otherwise)                             */
    taggedunion {
       block "IN_EP_RESERR_DAQ_EVSERV" struct ep_parameters;
    };
                                   /* ----------- Begin of optional ------- */

    taggedstruct {                       /* Optional */
        "ALTERNATE_SETTING_NO" uchar;    /* Number of alternate setting     */

                                         /* String Descriptor of XCP        */
                                         /* interface                       */
        "INTERFACE_STRING_DESCRIPTOR" char [101];
                                         /* multiple OUT-EP's for STIM      */
        (block "OUT_EP_ONLY_STIM" struct ep_parameters)*;
                                         /* multiple IN-EP's for DAQ        */
        (block "IN_EP_ONLY_DAQ" struct ep_parameters)*;
                                         /* only one IN-EP for EV/SERV      */
        block "IN_EP_ONLY_EVSERV" struct ep_parameters;

        /* Not associated DAQ-Lists are assigned per default to             */
        /* OUT_EP_CD_STIM / IN_EP_RESERR_DAQ_EVSERV                         */
        (block "DAQ_LIST_USB_ENDPOINT" struct {
            uint;                  /* reference to DAQ_LIST_NUMBER          */
            taggedstruct {         /* only mentioned if not VARIABLE        */
                "FIXED_IN" uchar;  /* this DAQ list always                  */
                                   /* ENDPOINT_NUMBER, not endpoint address */
                "FIXED_OUT" uchar; /* this STIM list always                 */
                                   /* ENDPOINT_NUMBER, not endpoint address */
            };
        })*; /* end of DAQ_LIST_USB_ENDPOINT */
    }; /* end of optional */

};/************************* end of USB ***********************************/

    block "IF_DATA" taggedunion if_data {
/***************************************************************************/
/*                                                                         */
/*   ASAP2 Meta Language for Bypass                                        */
/*   assumes ASAP2 V1.31                                                   */
/*                                                                         */
/*   AML Version V1.0, 05.04.2000                                          */
/*                                                                         */
/*   Change History:                                                       */
/*                                                                         */
/*   Version  Date        Author               Modification                */
/*   ===================================================================   */
/*   V1.0     05.04.2000  K5/ESQ2-Ocker        first release               */
/*   -------------------------------------------------------------------   */
/*   V0.3     02.03.2000  K5/ESQ2-Ocker        changed order of KP_BLOB    */
/*                                             parameters;                 */
/*                                             meaning of SOURCE_ID        */
/*                                             changed;                    */
/*                                             editorial modifications     */
/*   -------------------------------------------------------------------   */
/*   V0.2     14.02.2000  K5/ESQ2-Ocker        + source identifier         */
/*   -------------------------------------------------------------------   */
/*   V0.1     06.12.1999  K5/ESQ2-Ocker        initial draft               */
/*                                                                         */
/*   Robert Bosch GmbH, K5/ESQ2-Ocker                                      */
/*                                                                         */
/***************************************************************************/

"ASAP1B_Bypass" taggedstruct {

    (block "SOURCE" struct {
        struct {
            char[101];  /* source name                                     */
            int;        /* period definition: basic scaling unit in CSE    */
                        /* defined in ASAP1b (CSE = code for scaling unit) */
            long;       /* period definition: rate in scaling units        */
        };
        taggedstruct {
            block "QP_BLOB" struct {
                uint;   /* source identifier                               */
            };
        };
    })*;

    block "TP_BLOB" struct {
        uint;           /* Bypass Version, High Byte: Version              */
                        /*                 Low Byte : subversion (dec.)    */
        uint;           /* Blob Version,   High Byte: Version              */
                        /*                 Low Byte : subversion (dec.)    */
    };

    block "DP_BLOB" struct {
    };

    block "PA_BLOB" struct {
    };

    block "KP_BLOB" struct {
        taggedstruct {

            "BUFFER_OFFSET"    char[256];  /* parameter value represents   */
                                           /* switch: 0 = bypass disabled, */
                                           /*         1 = bypass enabled   */

            "SOURCE_ID"        char[256];  /* parameter value represents   */
                                           /* stimulus channel             */

            "BIT_OFFSET"       char[256];  /* parameter value represents   */
                                           /* mask in case of bit objects  */

            "POSSIBLE_SOURCES" ( uint )*;  /* list of all channels, where  */
                                           /* intervention point is usable */
                         /* special cases:                                 */
                         /* empty list = intervention point is defined,    */
                         /*              but unusable                      */
                         /* keyword omitted = intervention point is usable */
                         /*                   in all available channels    */
        };
    };

}; /* end of taggedstruct "ASAP1B_Bypass" */

/****************************************************************************/
/*                                                                          */
/*   ASAP2 Meta Language for CCP CAN Calibration Protocol V2.1              */
/*   Assumes ASAP2 V1.3 or later                                            */
/*                                                                          */
/*   AML Version V2.4, 27.04.1999                                           */
/*                                                                          */
/*   Vector Informatik, Zaiser                                              */
/*   Hewlett Packard, Krueger                                               */
/*   ETAS, Maier                                                            */
/*   SIEMENS Automotive, Stuhler                                            */
/*                                                                          */
/*   Datatypes:                                                             */
/*                                                                          */
/*   A2ML       ASAP2          Windows  Erlaeuuterung                       */
/*   ----------------------------------------------------------------       */
/*   uchar      UBYTE          BYTE     unsigned 8 Bit                      */
/*   char       SBYTE          char     signed 8 Bit                        */
/*   uint       UWORD          WORD     unsigned integer 16 Bit             */
/*   int        SWORD          int      signed integer 16 Bit               */
/*   ulong      ULONG          DWORD    unsigned integer 32 Bit             */
/*   long       SLONG          LONG     signed integer 32 Bit               */
/*   float      FLOAT32_IEEE            float 32 Bit                        */
/*                                                                          */
/****************************************************************************/

"ASAP1B_CCP" taggedstruct {

    /* Beschreibung der DAQ-Listen */
    (block "SOURCE" struct {

      struct {
        char [101];   /* Name of the DAQ-List (data acquisition list),
                         measurement source .        */

                      /* If the DAQ-Liste only supports one fixed ECU 
                         sampling rate, it can be declared below
                         to achieve compatibility with the ASAP2 standard.
                         Otherwise description of the possible ECU
                         sampling rates in QP_BLOB      */
        int;          /* Period definition : Basic scaling unit in 
                         CSE defined in ASAP1b (CSE=Code for Scaling Unit) */
        long;         /* Period definition : Rate in Scaling Units */
      };


      taggedstruct {

        "DISPLAY_IDENTIFIER" char[32];

        block "QP_BLOB" struct {

          uint;	               /* Number of the DAQ-List 0..n               */

          taggedstruct {
            "LENGTH" uint;     /* Length of the DAQ-Liste, maximum number of
                                  the useable ODTs                          */

            "CAN_ID_VARIABLE"; /* CAN-Message-ID is variable                */

            "CAN_ID_FIXED" ulong;
                               /* CAN-Message-ID of the DTOs is fixed,
                                  Default DTO
                                  Bit31 = 1: extended Identifier
                                  Bit31 = 0: standard Identifier            */

                               /* Not applied if the ECU uses the DTM-Id    */

            ("RASTER" uchar )*;
                               /* Supported CCP Event Channel Names
                                  of this DAQ List */

            ("EXCLUSIVE" int )*;
                               /* Exclusion of other DAQ-Lists              */

            "REDUCTION_ALLOWED";
                               /* Data reduction possible                   */

            "FIRST_PID" uchar; /* First Packet ID (PID) of the DAQ List     */
          };
        };
      };
    } )*;


    /* Description of the available ECU Sampling Rates (Event Channels)      */
    (block "RASTER" struct {

       char [101];   /* CCP Event Channel Name                               */
       char [9];     /* Short Display Name of the Event Channel Name         */
       uchar;        /* Event Channel No., used for CCP START_STOP)          */
       int;          /* Period definition :  basic scaling unit in CSE
                        as defined in ASAP1b                                 */
       long;         /* ECU sample rate of the event channel,
                        period definition based on the basic scaling unit    */

       taggedstruct {
         ("EXCLUSIVE" uchar )*;
                     /* Exclusion of other CCP Event Channels                */
       };

    } )*;

    /* Group several event channels to form one combined event */
    /* e.g. group all cylinder synchronous events to one combined element */
    (block "EVENT_GROUP" struct {

       char [101];   /* Event group name */
       char [9];     /* Short name for the event group */
       taggedstruct {
         ("RASTER" uchar )*;
       };
                     /* all event channels beloging to group
                        (CCP Event Channel Numbers for START_STOP)               */
    } )*;


    /* Description of the authentification process */
    block "SEED_KEY" struct {
       char[256];    /* Name of the Seed&Key DLL for CAL Priviledge,
                        including file-Extension without path */
       char[256];    /* Name of the Seed&Key DLL for DAQ Priviledge,
                        including file-Extension without path */
       char[256];    /* Name of the Seed&Key DLL for PGM Priviledge,
                        including file-Extension without path */
    };


/* Description of the checksum calculation process */
    block "CHECKSUM" struct {
       char[256];    /* Name of the Checksum DLL representing the ECU Algorithm, 
                        including file-Extension without path */
};


block "TP_BLOB" struct {

      uint;	  /* CCP Version,       High Byte: Version
                                    Low Byte : subversion (dec.)            */
      uint;	  /* Blob-Version,      High Byte: Version
                                    Low Byte : subversion (dec.)            */
      ulong;	  /* CAN-Message ID for 'Transmitting to ECU (CRM)'
                                    Bit31 = 1: extended Identifier
                                    Bit31 = 0: standard Identifier          */
      ulong;	  /* CAN-Message ID for 'Receiving from ECU (DTM)'
                                    Bit31 = 1: extended Identifier
                                    Bit31 = 0: standard Identifier          */
      uint;	  /* Logical CCP-Address of the (station address)           */
      uint;	  /* Byte order of Multiple-byte-items
                                    1 = high Byte first, 2 = low byte first */
      taggedstruct {

        block "CAN_PARAM" struct {
          uint;                  /* Quartz freq. of the elec. control unit  */
          uchar;                 /* BTR0                                    */
          uchar;                 /* BTR1                                    */
        };

        "BAUDRATE" ulong;        /* Baud rate in Hz.                        */
        "SAMPLE_POINT" uchar;    /* sampling point of time in percent       */
        "SAMPLE_RATE" uchar;     /* number of samples per Bit (1 oder 3)    */
        "BTL_CYCLES" uchar;      /* number of BTL-cycles                    */
        "SJW" uchar;             /* SJW-parameter in BTL-cycles             */
        "SYNC_EDGE" enum {
           "SINGLE" = 0,         /* Synchronisation only on fallende edge   */
           "DUAL" = 1            /* Synchr. on falling and rising edge      */
        };

        "DAQ_MODE" enum {        /* mode of cylcic data acquisition         */
           "ALTERNATING" = 0,    /* ECU is sending one ODT per cycle        */
           "BURST" = 1           /* ECU is sending a complete DAQ           */
        };

        "BYTES_ONLY";            /* ECU supports max. elements of one Byte size */
                                 /* otherwise ECU supports different dataTypes  */

        "RESUME_SUPPORTED";      /* ECU supports the Resume function            */

        "STORE_SUPPORTED";       /* ECU supports the Store function             */

        "CONSISTENCY" enum {
           "DAQ" = 0,            /* consistency of a complete DAQ ist guaranteed */
           "ODT" = 1             /* consistency of a complete ODT ist guaranteed */
        };

        "ADDRESS_EXTENSION" enum {  /* address extension                      */
           "DAQ" = 0,               /* ECU supports only one Address extension
                                       within an DAQ                    */
           "ODT" = 1                /* ECU supports only one Address extension
                                       within an ODT                    */
        };

        block "CHECKSUM_PARAM" struct {
          uint;	           /* checksum calculation procedure
                               standard types not yet defined,
                               if greater of equal 1000 : manufacturer specific  */

          ulong;               /* Maximum block length used by an ASAP1a-CCP
                                  command, for checksum calculation procedure  */

          taggedstruct {
            "CHECKSUM_CALCULATION" enum {
               "ACTIVE_PAGE" = 0,
               "BIT_OR_WITH_OPT_PAGE" = 1
            };
          };
        };

        (block "DEFINED_PAGES" struct {
           struct {
              uint;            /* Logical No. of the memory page (1,2,..)   */
              char[101];       /* Name of the memory page                   */
              uint;            /* Adress-Extension of the memory page (only
                                  Low Byte significant)                     */
              ulong;           /* Base address of the memory page           */
              ulong;           /* Length of the memory page in Bytes        */
           };
           taggedstruct {
             "RAM";              /* memory page in RAM */
             "ROM";              /* memory page in ROM */
             "FLASH";            /* memory page in FLASH */
             "EEPROM";           /* memory page in EEPROM */
             "RAM_INIT_BY_ECU";  /* memory page is initialised by ECU start-up */
             "RAM_INIT_BY_TOOL"; /* RAM- memory page is initialised by the MCS */
             "AUTO_FLASH_BACK";  /* RAM memory page is automatically flashed back */
             "FLASH_BACK";       /* feature available to flash back the RAM memory page */
             "DEFAULT";          /* memory page is standard (fallback mode) */
           };
        } ) *;

        ( "OPTIONAL_CMD"  uint )*; /* CCP-Code of the optional command available
                                      in the ECU. It is recommended to declare all
                                      non-standard ECU commands here */

      };

    };

/* for CHARACTERISTIC and AXIS_PTS and MEMORY_LAYOUT */
    "DP_BLOB" struct {
      uint;	/* Address extension of the calibration data
                   (only Low Byte significant) */
      ulong;	/* Base address of the calibration data */
      ulong;	/* Number of Bytes belonging to the calibration data  */
    };

/* for MEASUREMENT */
    "KP_BLOB" struct {
      uint;	/* Address extension of the online data
                   (only Low Byte significant) */
      ulong;	/* Base address of the online data   */
      ulong;	/* Number of Bytes belonging to the online data (1,2 or 4) */
      taggedstruct {
         ("RASTER" uchar )*;
                /* Array of event channel initialization values */
       };
    };
};

  
/****************************************************************************/
/*                                                                          */
/*   ASAP2 Meta description for ETK                                         */
/*   - only applicable with ASAP2 V1.3 -                                    */
/*                                                                          */
/*   Used data types:                                                       */
/*                                                                          */
/*   A2ML       ASAP2          Windows  Explanation                         */
/*   ---------------------------------------------------------              */
/*   uchar      UBYTE          BYTE     unsigned 8 Bit                      */
/*   char       SBYTE          char     signed 8 Bit                        */
/*   uint       UWORD          WORD     unsigned integer 16 Bit             */
/*   int        SWORD          int      signed integer 16 Bit               */
/*   ulong      ULONG          DWORD    unsigned integer 32 Bit             */
/*   long       SLONG          LONG     signed integer 32 Bit               */
/*   float      FLOAT32_IEEE            float 32 Bit                        */
/*                                                                          */
/*  Changes:                                                                */
/*  26.04.99 Hn  closing bracket at 'ADDRESS_MAPPING' added,                */
/*               Keyword 'RESERVED' changed to 'RESERVED_DISTAB_MEMORY'     */
/*                                                                          */
/*  06.07.99 Hn  (V1.0.1) closing bracket at 'ADDRESS_MAPPING' changed to'}'*/
/*                                                                          */
/*  03.07.00 Hn  (V1.1.0) New element 'ETK_PRESENCE_CHECK' added to TP-Blob */
/*                                                                          */
/*  03.07.01 Hn  (V1.2.0) New element 'COLDSTART_HANDSHAKE' added to TP-Blob*/
/*                        Parameter 'PBA' deleted                           */
/*                        New parameter 'InterFaceSpeed' added              */
/*                                                                          */
/*                        New QP-Blob for 32 trigger measurement/bypass     */
/*                                                                          */
/*  11.01.02 Lug (V1.3.0) RESERVED_DISTAB_MEMORY' section expanded          */
/*                        New TP_BLOB Version 0x01000101                    */
/*                                                                          */
/*  12.07.02 Wnl (V1.4.0) New QP-BLOB Version 0x00000101                    */
/*                        Parameter 'Max. Read Variables' added             */
/*                        Parameter 'Max. Write Variables' added            */
/*                                                                          */
/*  02.10.02 Wnl (V1.4.0) KP_Blob extension                                 */
/*                        - enum for address location                       */
/*                        - default RASTER                                  */
/*                                                                          */
/*  10.09.03 Wnl (V1.5.0) New TP_BLOB Version 0x00000102:                   */
/*                        New Parameter for CODE_CHK                        */
/*                          PERMANENT_RESET / NO_RESET                      */
/*                        New TP_BLOB entry OVERLAY_CONFIG_TABLE            */
/*                       - CODE_CHK maxByte 4 -> 32                         */
/*                                                                          */
/*  12.04.05 Wnl (V1.6.0) New TP_BLOB Version 0x01000103:                   */
/*                        New TP_BLOB entry CAL_WAKEUP                      */
/*                        New TP_BLOB entry PAGE_SWITCH_METHOD              */
/*                                                                          */
/****************************************************************************/

/****************************************************************************/
/*                                                                          */
/* For a correct working of the ETK, the following MEMORY_SEGMENTs have to  */
/* be specified in the section 'MOD_PAR' of the ASAP2 file:                 */
/*                                                                          */
/*  /begin MEMORY_SEGMENT                                                   */
/*     Dataxxxx ""  DATA FLASH <mem. location> <address> <size> <mirrors>   */
/*  /end MEMORY_SEGMENT                                                     */
/*                                                                          */
/*  /begin MEMORY_SEGMENT                                                   */
/*     Codexxxx ""  CODE FLASH <mem. location> <address> <size> <mirrors>   */
/*  /end MEMORY_SEGMENT                                                     */
/*                                                                          */
/*  /begin MEMORY_SEGMENT                                                   */
/*     ExRAM "ExRAM for DISTAB" VARIABLES RAM EXTERN <address><size><mirrors>*/
/*  /end MEMORY_SEGMENT                                                     */
/*                                                                          */
/*  Remark: All data included in a hex file, but not specified by a memory  */
/*          segment will be ignored inside the application program and lost */
/*          when generating hex file export                                 */
/*                                                                          */
/****************************************************************************/

"ETK" taggedstruct
{
  /* Description of an address mapping between addresses in the view of the */
  /* EPROM of the ECU (and ASAP2) and the addresses in the scope of the ETK */
  /* IF_DATA section used with MEMORY_SEGMENT (can be missing if no         */
  /* differences between the 2 views)                                       */

  ("ADDRESS_MAPPING" struct
    {
     ulong;              /* Start address of MEMORY_SEGMENT                 */
     ulong;              /* mapped start address for ETK                    */
     ulong;              /* Length of mapped address range                  */
    }
   )*;                   /* multiple use of ADDRESS_MAPPING is possible     */
                         /* (even each MEMORY_SEGMENT)                      */


  (block "SOURCE" struct
  {
  /* Description of the acquisition (trigger) levels supplied by the ECU,   */
  /* 3 is max. no. for ETK                                                  */

    struct
    {
      char [100];        /* Source name                                     */
      int;               /* CSE unit according to Asap1b (minimal period    */
                         /* duration) of the acqisition raster              */
      long;              /* Minimal period number measured in the CSE unit  */
    };
    taggedstruct
    {
      "QP_BLOB" struct
      {
      /* Description of additional information needed by the ETK device     */
      /* driver to collect the measurement data from a certain              */
      /* acquisition raster                                                 */
        uint;            /* version number, high byte must be >=1 to be     */
                         /* able to distinguish old versions without        */
                         /* version numbers current value: 0x101 (V1.1)     */
        uint;            /* hardware trigger number (1..32)                 */
        enum {           /* trigger type                                    */
          "DIRECT"=1,
          "INDIRECT"=2
        };
        uint;            /* raster priority (1..32), higher number = higher */
                         /* priority                                        */
        enum {           /* assigned application                            */
          "MEASUREMENT"=0,
          "BYPASS"=1
        };
        ulong;           /* address of trigger flag (only valid if trigger  */
                         /* type INDIRECT)                                  */
        uint;            /* maximum length of display table in bytes        */
        ulong;           /* start address of display table                  */
        ulong;           /* output address of display table                 */
        uint;            /* max. size of bypass receive table               */
        ulong;           /* start address of address table for bypass       */
                         /* output - Xpass compatible Bypass only !!        */
        ulong;           /* output address of the bypass table              */
        ulong;           /* worst case minimum raster time in us            */
                         /* (1000 = 1ms raster)                             */
        uint;            /* maximum read variables                          */
        uint;            /* maximum write variables                         */
      };
    };
  })*;                   /* SOURCE can be used several times                */

  block "TP_BLOB" struct
  {
  /* Description of additional information needed to configure the ETK      */
  /* device driver for measurement and calibration                          */

    ulong;               /* Version number of the TP-Blob; uppermost byte   */
                         /* is always != 0, so that informations cannot be  */
                         /* mixed up with older blob versions (trigger      */
                         /* address was previously at the first position    */
                         /* and had max. 24 Bit)                            */
                         /* current value: 0x01000102                       */
    enum {               /* fix comm speed on ETK line to 8/100 MBit/s      */
      "INTERFACE_SPEED_8MBIT"   = 1,
      "INTERFACE_SPEED_100MBIT" = 2
    };
    ulong;               /* ETKP: RESET_CFG parameter only for PPC family   */

    taggedstruct {

      "DISTAB_CFG" struct
      {
        uint;            /* Type of display table (13 recommended,   DSPTAB */
                         /* 12, 11, 20 only for old projects)               */
        uint;            /* Data type display table: 1=byte 2=word  DAT_MOD */
                         /* additional code table for distab 13 depending   */
                         /* on bus width / bus access                       */
                         /* (see distab 13 spec. for more information)      */
        uint;            /* Byte order 1 = high first, 2 = low first    RFG */
        ulong;           /* Trigger segment address                TRGSEGAD */
        ulong;           /* Trigger configuration  (special code)   TRG_CFG */
        taggedstruct {
          "TRG_MOD" ( uchar)*; /* Dyn. length for                   TRG_MOD */
                               /* (special code)                            */
        };
      };

      "CODE_CHK" struct
      {
      /* A check, whether program and data are matching can be performed,   */
      /* if the ECU copies a certain 'program identifier' (e.g. the code    */
      /* checksum) into the external RAM and the same identifier is stored  */
      /* in the data range. The ETK driver can read and compare both        */
      /* identifier and issue an error message, if the both identifiers do  */
      /*  not match.                                                        */

        ulong;           /* ETK: address of program identifier in the data  */
                         /* range PRG_DATA                                  */
        uint;            /* ETK: length of program identifier in the data   */
                         /* range (max. 32 bytes)                           */
        ulong;           /* ETK: address of program identifier in the       */
                         /* external RAM PRG_ERAM                           */
        uint;            /* ETK: length of program identifier in the        */
                         /* external RAM (max. 32 bytes)                    */
        /* If all parameters contain 0x0 values, no check is performed      */

        taggedstruct {
          "ERROR_BEHAVIOR" enum {       /* reaction of MC tool to ECU when  */
            "PERMANENT_RESET" = 0,      /* code check fails                 */
            "NO_RESET"        = 1
          };
        };
      };

      "ETK_CFG" ( uchar)*; /* ETK_CFG parameters (dyn. length)              */
      /* Description of ETK configuration parameters, as configured with    */
      /* the ETK configuration tool                                         */

      ( "EMU_DATA" struct
      {
      /* Additional description of data ranges overwriting the              */
      /* MEMORY_SEGMENT description                                         */

        ulong;           /* Start address                                   */
        ulong;           /* Length in bytes                                 */
        enum {           /* Memory attribute                                */
          "INTERN"  = 0,
          "EXTERN"  = 1
        };
                         /* Description of offsets to additional data       */
                         /* ranges where the contents of this data range    */
                         /* are mirrored                                    */
        ulong;           /* Mirror offset 1                                 */
        ulong;           /* Mirror offset 2                                 */
        ulong;           /* Mirror offset 3                                 */
        ulong;           /* Mirror offset 4                                 */
        ulong;           /* Mirror offset 5                                 */
                         /* Mirror offsets of -1 indicate that there is no  */
                         /* mirror offset                                   */
      })*;

      ( "EMU_CODE" struct
      {
      /* Additional description of code ranges overwriting the              */
      /* MEMORY_SEGMENT description                                         */

        ulong;           /* Start address                                   */
        ulong;           /* Length in bytes                                 */
        enum {           /* Memory attribute                                */
          "INTERN"  = 0,
          "EXTERN"  = 1
        };
        ulong;           /* Mirror offset 1                                 */
        ulong;           /* Mirror offset 2                                 */
        ulong;           /* Mirror offset 3                                 */
        ulong;           /* Mirror offset 4                                 */
        ulong;           /* Mirror offset 5                                 */
      })*;

      ( "EMU_RAM" struct
      {
      /* Additional description of external RAM ranges overwriting the      */
      /* MEMORY_SEGMENT description                                         */

        ulong;           /* Start address                                   */
        ulong;           /* Length in bytes                                 */
        enum {           /* Memory attribute                                */
          "INTERN"  = 0,
          "EXTERN"  = 1
        };
        ulong;           /* Mirror offset 1                                 */
        ulong;           /* Mirror offset 2                                 */
        ulong;           /* Mirror offset 3                                 */
        ulong;           /* Mirror offset 4                                 */
        ulong;           /* Mirror offset 5                                 */
      })*;

      ( "RESERVED_DISTAB_MEMORY" struct
      {
      /* Description of 'reserved ranges' (especially in the data or code   */
      /* ranges; e.g. location of the display tables) that are excluded     */
      /* from checksum verification. If the 3 display tables stand close    */
      /* together, the size of the reserved memory is calculated by the     */
      /* following formula:                                                 */
      /*          size = (highest start address of the 3 distabs)           */
      /*                  + ((size of this distab) + 2) * 4                 */
      /*                  - (lowest start address of the 3 distabs)         */

        ulong;           /* Start address                                   */
        ulong;           /* Length in bytes                                 */
        enum {           /* Location                                        */
          "INTERN"  = 0,
          "EXTERN"  = 1
        };
        enum {           /* application                                     */
          "MEASUREMENT" = 0,
          "BYPASS"      = 1
        };
        enum {           /* usage                                           */
          "CHECKSUM_EXCLUDE_ONLY" = 0,
          "ECU_DISTAB_INPUT"      = 1,
          "ECU_DISTAB_OUTPUT"     = 2,
          "ECU_DISTAB_INOUT"      = 3
        };
        ulong;           /* Mirror offset 1                                 */
        ulong;           /* Mirror offset 2                                 */
        ulong;           /* Mirror offset 3                                 */
        ulong;           /* Mirror offset 4                                 */
        ulong;           /* Mirror offset 5                                 */
      })*;

      "ETK_MAILBOX" struct
      {
      /* Description of the ETK mailbox that is used for communication      */
      /* between the ECU and the application program (e.g. for programming  */
      /* data into the ECU flash)                                           */

        ulong;           /* Test pattern for the ECU to detect a valid      */
                         /* mailbox                                         */
        enum {           /* Memory page (code, data, external RAM) used for */
                         /* communication from application program to ECU   */
          "CODE"  = 1,
          "DATA"  = 2,
          "EXRAM" = 3
        };
        ulong;           /* Base address of buffer for communication appl.  */
                         /* program -> ECU                                  */
        ulong;           /* Length of buffer for comunication appl.         */
                         /* program -> ECU                                  */
        enum {           /* Memory page (code, data, external RAM) used for */
                         /* communication from ECU to application program   */
          "CODE"  = 1,
          "DATA"  = 2,
          "EXRAM" = 3
        };
        ulong;           /* Base address of buffer for communication        */
                         /* ECU -> appl. program                            */
        ulong;           /* Length of buffer for comunication               */
                         /* ECU -> appl. program                            */
      };

      block "ETK_PRESENCE_CHECK" struct
      {
        ulong;           /* address of ETK recognition pattern              */
        taggedstruct {
          "ETK_PATTERN" (uchar)*; /* Dyn. length for pattern                */
        };
      };

      block "COLDSTART_HANDSHAKE" struct
      {
        ulong;           /* address of ETKS cold start pattern              */
        taggedstruct {
          "WAIT" ( uchar)*;   /* Dyn. length for 'wait' pattern             */
        };
        taggedstruct {
          "READY" ( uchar)*; /* Dyn. length for 'ready' pattern             */
        };
      };

      "CAL_WAKEUP" taggedstruct {
        "CAL_WAKEUP_PIN" ulong;     /* 1 = wake up enabled, 0 = disabled    */
        "CAL_TOOL_PRESENT" struct {
               ulong;               /* address for the pattern              */
               ulong;               /* pattern                              */
               ulong;               /* ECU timeout for shut down in s       */
        };
      };
    };
    taggedunion {
      "OVERLAY_CONFIG_TABLE" struct {
        ulong;           /* OCT_Type         Type of table                  */
        ulong;           /* OCT_StartAddress Start address of table         */
        ulong;           /* OCT_Length       max Length of table in byte    */
        taggedstruct {
          "AUTOSTART_BEHAVIOR" enum {
            "LAST_ACTIVE_PAGE" = 0, /* Table to be filled by INCA with info */
                                    /* for the current active page          */
            "ALWAYS_WP"        = 1, /* Table to be filled by INCA always    */
                                    /* with info for working page           */
            "ALWAYS_RP"        = 2  /* Table to be filled by INCA always    */
                                    /* with info for reference page         */
          };
        };
      };
      "PAGE_SWITCH_METHOD" struct {
        ulong;                      /* version                              */
        taggedstruct {
          "MAILBOX" struct {
            ulong;           /* MBX_Version                                 */
                             /* Version of mailbox                          */
            ulong;           /* MBX_PageSetupTime                           */
                             /* max time the ECU needs to set up page in ms */
            ulong;           /* MBX_StartAddress                            */
                             /* Start address of table                      */
          };

          "AUTOSTART_BEHAVIOR" enum {
            "LAST_ACTIVE_PAGE" = 0, /* Table to be filled by INCA with info */
                                    /* for the current active page          */
            "ALWAYS_WP"        = 1, /* Request field to be filled by INCA   */
                                    /* always with info for working page    */
            "ALWAYS_RP"        = 2  /* Request field to be filled by INCA   */
                                    /* always with info for reference page  */
          };

          "OCT_WORKINGPAGE" struct {
            ulong;       /* OCT_Type         Type of table                  */
            ulong;       /* OCT_StartAddress Start address of table         */
            ulong;       /* OCT_Length       max Length of table in byte    */
          };

          "OCT_REFERENCEPAGE" struct {
            ulong;       /* OCT_Type         Type of table                  */
            ulong;       /* OCT_StartAddress Start address of table         */
            ulong;       /* OCT_Length       max Length of table in byte    */
          };
        };
      };
    };
  };

  "DP_BLOB" struct
  {
  /* for CHARACTERISTIC and AXIS_PTS and MEMORY_LAYOUT                      */

    ulong;               /* start address for example of a map              */
    ulong;               /* length of the map                               */
  };

  "KP_BLOB" struct
  {
    ulong;               /* Start address of measurement variable           */
    enum {               /* Address location                                */
      "INTERN"  = 0,
      "EXTERN"  = 1
    };
    uint;                /* Size of measurement in bytes                    */
    taggedstruct {
      ("RASTER" uchar )*;/* Array of event channel initialization values    */
    };
  };
};
/**************************************************************************/
/*                                                                        */
/*   ASAP2-Meta-Description for KWP2000 protokoll                         */
/*   ASAP-Version:              V1.4                                      */
/*   ETAS KWP2000-AML-Version:  V02.02 (this file "KWP2000_V0201.AML")    */
/*   TP-BLOB Version:           V02.00                                    */
/*                                                                        */
/*------------------------------------------------------------------------*/
/*   ETAS-Hs 2.3.01                                                       */
/*   - definition of version 2.0                                          */
/*   - Integration of parameters for  KWP on CAN                          */
/*------------------------------------------------------------------------*/
/*   Ruo 20.08.2002:                                                      */
/*    -  deleted retundant information in QP BLOB                         */
/*       "uint;           /* sampling period [ms]"                        */
/*------------------------------------------------------------------------*/
/*   RB-Aberfeld 13.02.03                                                 */
/*   - Add Header information                                             */
/*   - wrap definition of "block "ADDRESS" struct {}" into a              */
/*     taggedstruct {}                                                    */
/*------------------------------------------------------------------------*/
/*   ETAS-Ruo 06.03.2003                                                  */
/*   - added version information                                          */
/*   - replaced german explanation                                        */
/*------------------------------------------------------------------------*/
/*   ETAS-Ruo 13.10.2003                                                  */
/*   - exchanged 5Baud by Stimulation_5Baud                               */
/*   - exchanged KLINE+CAN by KLINE_AND_CAN                               */
/*   - supported with INCA V4.0.4                                         */
/*------------------------------------------------------------------------*/
/*   Used datatypes:                                                      */
/*                                                                        */
/*   A2ML       ASAP2          Windows  Explaination                      */
/*   ---------------------------------------------------------            */
/*   uchar      UBYTE          BYTE     unsigned 8 Bit                    */
/*   char       SBYTE          char     signed 8 Bit                      */
/*   uint       UWORD          WORD     unsigned integer 16 Bit           */
/*   int        SWORD          int      signed integer 16 Bit             */
/*   ulong      ULONG          DWORD    unsigned integer 32 Bit           */
/*   long       SLONG          LONG     signed integer 32 Bit             */
/*   float      FLOAT32_IEEE            float 32 Bit                      */
/*                                                                        */
/**************************************************************************/

"ASAP1B_KWP2000"  taggedstruct {

   /* bei MEMORY_SEGMENT (optional)              */
   /* ADDRESS_MAPPING can be multiple and partly */
   ("ADDRESS_MAPPING" struct
      {
      ulong;        /* Starting address acc.. MEMORY_SEGMENT                */
      ulong;        /* mapped starting address                              */
      ulong;        /* length of range to be mapped                         */
      }
   )*;


   ("SEED_KEY"      /* Description of the Seed & Key process                */
   char[256]        /* name of Seed&Key DLL for application, incl. path and extension */
   )*;


   (block "SOURCE" struct {
      struct {
         char [100];       /* Name              */
         int;              /* CSE-units         */
         long;             /* min periode       */
      };
      taggedstruct {
         "QP_BLOB" struct {
             enum {            /* Physical layer Information  */
               "KLINE"      = 1,
               "CAN"        = 2,
               "KLINE_AND_CAN"  = 3
             };
             enum {        /* Measurement mode of ECU: Block with         */
                           /* local Id or single by address or freerunning*/
                "ADDRESSMODE"           = 1,
                "BLOCKMODE"                = 2,
                "FREERUNNINGMODE" = 3
             };
             uint;           /* Block mode: local identifier     */
             uint;           /* max. no of signals                    */
             uint;           /* max. no of bytes                     */
             ulong;         /* CAN-ID for EUDTP            */
             uint;           /* Raster ID for EUDTP           */
         };
      };
   }
   )*;

   block "TP_BLOB" struct {
      uint;      /* Blob version, High byte: version   */
                 /*  Low byte : sub version (decimal.) */
                 /* current version 0x0200             */
      enum {     /* KWP2000 version                    */
         "VDA_1996" = 1
      };
      enum {     /* byte order in measurements and characteristics  */
         "MSB_FIRST" = 1,
         "MSB_LAST"  = 2
      };

      taggedstruct {
         "K_LINE" struct {
            enum {    /* KW INI: stimulation mode of ECU: WuP or 5 baud */
               "WuP"   = 1,
               "Stimulation_5Baud" = 2
            };
            uint;       /* ECU address on K-line                        */
            uint;       /* tester address on K-Line                     */
         };
      };


      taggedstruct {
         block "CAN" struct {
            ulong;              /* Baudrate [Hz]                          */
            char;               /* Sample point [% complete bit time]     */
            char;               /* 1 or 3 samples per bit                 */
            char;               /* BTL_CYCLES [slots/bit time]            */
            char;               /* SJW length synchr. segm. in BTL_CYCLES */
            char;               /* SYNC_EDGE                              */

            taggedstruct {
               block "ADDRESS" struct {
                  ulong;        /* CAN_ID ECU(or gateway)->INCA           */
                  ulong;        /* CAN_ID INCA->ECU(or gateway)           */
                  taggedstruct {
                     "TGT_ECU"  uint;   /* Extended/remote address ECU    */
                     "TGT_INCA" uint;   /* Extended address INCA          */
                  };
               };
            };

            taggedstruct {
               "NETWORK_LIMITS" struct {
                  char;        /* WFT_MAX (max. waitframes)               */
                  uint;        /* XDL_MAX (max. datalength)               */
               };
            };

            taggedstruct {
               "START_STOP" uint;   /* Start_stop FREE_RUNNING :          */
                                    /* routine number                     */
            };

         };
      };


      taggedstruct {
         "DATA_ACCESS" struct {
            ulong;        /* ECU address type qualifier for Flash page    */
            ulong;        /* ECU address type qualifier for RAM page      */
            uint;         /* 1: Read access on ECU flash data             */
            uint;         /* 1: Verify access on ECU flash code           */
            uint;         /* 1: Read access on ECU flash code             */
            uint;         /* 1: Upload and download only on active page   */
         };


         block "CHECKSUM" struct {
            ulong;        /* check sum type qualifier (see table)         */
            uint;         /* 1: check sum calculation only on active page */
            uint;         /* No of local routine for check sum            */
            enum {        /* result of checksum routine delivered by      */
               "RequestRoutineResults" = 0,
               "StartRoutine"          = 1,
               "CodedResult"           = 2
            };
            taggedstruct {
               "RNC_RESULT" ( uchar )*; /* only at 'RequestRoutineResults':*/
                                        /* result codes, that sign 'calculation in progress' */
            };
         };


         block "COPY" struct {
            enum {       /* ECU mode for copying Flash into RAM            */
               "RAM_InitByECU"   = 0x10,
               "RAM_InitByTool"  = 0x20
            };
            uint;               /* diagnostic mode for copy Flash  to RAM */
            taggedstruct {
               "COPY_PARA" ( uchar )*;/* list of add. Param for StartDiag */
            };
         };


         block "FLASH" struct {
            enum {                 /* ECU mode for copying RAM into Flash */
               "NOFLASHBACK"     = 0x00,
               "AUTOFLASHBACK" = 0x40,
               "TOOLFLASHBACK"  = 0x80
            };
            uint;        /* No of local routine for copy RAM into flash   */
            enum {       /* result of copy routine delivered by           */
               "RequestRoutineResults" = 0,
               "StartRoutine"          = 1,
               "CodedResult"           = 2
            };
            taggedstruct {
               "COPY_FRAME" ( uchar )*; /* list of frames to be copied    */
               "RNC_RESULT" ( uchar )*; /* only at'RequestRoutineResults':*/
                                        /* result codes, that sign 'copy in progress'*/
            };
         };


         (block "DIAG_BAUD" struct {    /* Baudrate switch:               */
            ulong;                      /* BaudRate                       */
            uint;                       /* DiagMode                       */
            taggedstruct {
               "BD_PARA" ( uchar )*;    /* bytes for ECU baudrate switch  */
            };
         }
         )*;


         block "TIME_DEF" struct {      /* Timing parameter:              */
            taggedstruct {
               ("KWP_TIMING" struct {
                  uint;                 /* p1        [ms]                */
                  uint;                 /* p2Min     [ms]                */
                  uint;                 /* p2MAX     [ms]                */
                  uint;                 /* p3Min     [ms]                */
                  uint;                 /* p3MAX     [ms]                */
                  uint;                 /* p4        [ms]                */
               }
               )*;
            };

            taggedstruct {
               ("USDTP_TIMING" struct {
                  uint;                 /* As [ms]                       */
                  uint;                 /* Bs [ms]                       */
                  uint;                 /* Cr [ms]                       */
               }
               )*;
            };
         };


         ( "SECURITY_ACCESS" struct { /* Parameter for Seed&Key:         */
            uint;   /* Access mode for KWP2000 service 27h               */
            uint;   /* method of seed&key calculation (see table)        */
            uint;   /* delaytime in sec from stimulation to seed request */
         }
         )*;


         block "PAGE_SWITCH" struct {
            enum {                         /* ECU mode for switching pages         */
               "ESCAPE_CODE"   = 0x80,
               "LOCAL_ROUTINE" = 0x31
            };
            taggedstruct {
               "ESCAPE_CODE_PARA_SET"  ( uchar )*;
               "ESCAPE_CODE_PARA_GET"  ( uchar )*;
               block "ROUTINE_PARA" struct {
                  uint;               /* No of local routine for page switching    */
                  enum {              /* result of switching routine delivered by  */
                     "RequestRoutineResults" = 0,
                     "StartRoutine"          = 1,
                     "CodedResult"           = 2
                  };
                  taggedstruct {
                     "RNC_RESULT" ( uchar )*;    /*only at'RequestRoutineResults': */
                                                 /* result codes, that sign 'switching in progress' */
                  };
               };
               "PAGE_CODE" ( uchar )*;           /* codes for RP and WP            */
            };
         };
      };
   };


   "DP_BLOB" struct {
      ulong;                        /* Start address                               */
      ulong;                        /* Size of characteristic in bytes             */
   };

   "KP_BLOB" struct {
      ulong;                        /* Start address                               */
      enum {                        /* Address location                            */
         "INTERN"  = 0,
         "EXTERN"  = 1
      };
      uint;                         /* Size of measurement in bytes                */
   };
};

/************* start of XCP on different Transport Layers *******************/

"XCP" struct {

  taggedstruct Common_Parameters ; /* default parameters */

  taggedstruct { /* transport layer specific parameters  */
                 /* overruling of the default parameters */

    block "XCP_ON_USB" struct {

      struct USB_Parameters ;                   /* specific for USB      */
      taggedstruct Common_Parameters;           /* overruling of default */

    };

  };

};/************* end of XCP on different Transport Layers ********************/


    }; 
  /end A2ML

  /begin MOD_PAR "EMS2010"
    VERSION "r19e1_"
    ADDR_EPK 0x80040078
    EPK "35/1/EDC17_CP19/15/P_659//r19e1_///"
    CUSTOMER_NO "15"
    USER ""
    PHONE_NO ""
    ECU "EDC17_CP19"
    CPU_TYPE "TriCore"
    /begin MEMORY_SEGMENT Pst80004000 "" RESERVED FLASH INTERN 0x80004000 0xBC78 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80004000
                /* mapping addr */ 0x4000
                /* length       */ 0xBC78
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst8000FC78 "" RESERVED FLASH INTERN 0x8000FC78 0x8C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8000FC78
                /* mapping addr */ 0xFC78
                /* length       */ 0x8C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80080000 "" CODE FLASH INTERN 0x80080000 0xF7F74 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80080000
                /* mapping addr */ 0x80000
                /* length       */ 0xF7F74
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80177F74 "" RESERVED FLASH INTERN 0x80177F74 0x8C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80177F74
                /* mapping addr */ 0x177F74
                /* length       */ 0x8C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst8007FB74 "" RESERVED FLASH INTERN 0x8007FB74 0x8C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8007FB74
                /* mapping addr */ 0x7FB74
                /* length       */ 0x8C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80020000 "" CODE FLASH INTERN 0x80020000 0x1FF74 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80020000
                /* mapping addr */ 0x20000
                /* length       */ 0x1FF74
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst8003FF74 "" RESERVED FLASH INTERN 0x8003FF74 0x8C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8003FF74
                /* mapping addr */ 0x3FF74
                /* length       */ 0x8C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80010000 "" CODE FLASH INTERN 0x80010000 0x3F74 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80010000
                /* mapping addr */ 0x10000
                /* length       */ 0x3F74
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80013F74 "" RESERVED FLASH INTERN 0x80013F74 0x8C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80013F74
                /* mapping addr */ 0x13F74
                /* length       */ 0x8C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80000000 "" CODE FLASH INTERN 0x80000000 0x3F74 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80000000
                /* mapping addr */ 0x0
                /* length       */ 0x3F74
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80003F74 "" RESERVED FLASH INTERN 0x80003F74 0x8C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80003F74
                /* mapping addr */ 0x3F74
                /* length       */ 0x8C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80018000 "" RESERVED FLASH INTERN 0x80018000 0x7E74 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80018000
                /* mapping addr */ 0x18000
                /* length       */ 0x7E74
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst8001FE74 "" RESERVED FLASH INTERN 0x8001FE74 0x18C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8001FE74
                /* mapping addr */ 0x1FE74
                /* length       */ 0x18C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80014000 "" RESERVED FLASH INTERN 0x80014000 0x3E74 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80014000
                /* mapping addr */ 0x14000
                /* length       */ 0x3E74
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst80017E74 "" RESERVED FLASH INTERN 0x80017E74 0x18C -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80017E74
                /* mapping addr */ 0x17E74
                /* length       */ 0x18C
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst8000FD04 "" RESERVED FLASH INTERN 0x8000FD04 0x2FC -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8000FD04
                /* mapping addr */ 0xFD04
                /* length       */ 0x2FC
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Pst8007FC00 "" RESERVED FLASH INTERN 0x8007FC00 0x400 -1 -1 -1 -1 -1 

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8007FC00
                /* mapping addr */ 0x7FC00
                /* length       */ 0x400
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Dst80040000 "" DATA FLASH INTERN 0x80040000 0x3FB74 -1 -1 -1 -1 -1 

        /begin IF_DATA ETK
            ADDRESS_MAPPING
                /* origin addr  */ 0x80040000
                /* mapping addr */ 0x80040000
                /* length       */ 0x3FB74
        /end IF_DATA

        /* AsapMLCFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x80040000
                /* mapping addr */ 0x40000
                /* length       */ 0x3FB74
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram8FF20000 "" VARIABLES RAM INTERN 0x8FF20000 0x2000 -1 -1 -1 -1 -1 

        /* AsapMLRFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8FF20000
                /* mapping addr */ 0x320000
                /* length       */ 0x2000
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT Ram8FF22000 "" CALIBRATION_VARIABLES RAM INTERN 0x8FF22000 0x2000 -1 -1 -1 -1 -1 

        /* AsapMLRFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0x8FF22000
                /* mapping addr */ 0x322000
                /* length       */ 0x2000
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamC0000000 "" VARIABLES RAM INTERN 0xC0000000 0x2000 -1 -1 -1 -1 -1 

        /* AsapMLRFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0xC0000000
                /* mapping addr */ 0x400000
                /* length       */ 0x2000
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamD0000000 "" VARIABLES RAM INTERN 0xD0000000 0xE000 -1 -1 -1 -1 -1 

        /* AsapMLRFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0xD0000000
                /* mapping addr */ 0x500000
                /* length       */ 0xE000
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamD4000000 "" VARIABLES RAM INTERN 0xD4000000 0x4000 -1 -1 -1 -1 -1 

        /* AsapMLRFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0xD4000000
                /* mapping addr */ 0x600000
                /* length       */ 0x4000
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0060000 "" VARIABLES RAM INTERN 0xF0060000 0x3000 -1 -1 -1 -1 -1 

        /* AsapMLRFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0xF0060000
                /* mapping addr */ 0x660000
                /* length       */ 0x3000
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin MEMORY_SEGMENT RamF0050000 "" VARIABLES RAM INTERN 0xF0050000 0x2000 -1 -1 -1 -1 -1 

        /* AsapMLRFm - KWP2000 */
        /begin IF_DATA ASAP1B_KWP2000
            ADDRESS_MAPPING
                /* origin addr  */ 0xF0050000
                /* mapping addr */ 0x650000
                /* length       */ 0x2000
        /end IF_DATA
    /end MEMORY_SEGMENT

    /begin CALIBRATION_METHOD
      /* name calibration methode         */ "DataSetId"
      /* version calibration metode       */ 256
      /begin CALIBRATION_HANDLE
        /* adr data set id characteristic */ 0x8006EFE6
      /end CALIBRATION_HANDLE
    /end CALIBRATION_METHOD

    /begin CALIBRATION_METHOD
      /* Method name              */    "FixedSizeMoveableEmuRAM"
      /* Method version           */    1

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    1
        /* Original RAM Address   */    0x8FF24000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    2
        /* Original RAM Address   */    0x8FF28000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    3
        /* Original RAM Address   */    0x8FF2C000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    4
        /* Original RAM Address   */    0x8FF30000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    5
        /* Original RAM Address   */    0x8FF34000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    6
        /* Original RAM Address   */    0x8FF38000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    7
        /* Original RAM Address   */    0x8FF3C000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    8
        /* Original RAM Address   */    0x8FF40000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    9
        /* Original RAM Address   */    0x8FF44000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    10
        /* Original RAM Address   */    0x8FF48000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    11
        /* Original RAM Address   */    0x8FF4C000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    12
        /* Original RAM Address   */    0x8FF50000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    13
        /* Original RAM Address   */    0x8FF54000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    14
        /* Original RAM Address   */    0x8FF58000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE

      /begin CALIBRATION_HANDLE
        /* EmuRAM page identifier */    15
        /* Original RAM Address   */    0x8FF5C000
        /* Page size              */    0x4000
      /end CALIBRATION_HANDLE
    /end CALIBRATION_METHOD


    SYSTEM_CONSTANT "ACCD_PANALIN_CUR_X" "25"
    SYSTEM_CONSTANT "EXTERNAL HEXFILE POST TREATMENT NAME" "hpt_hexmod17.dll"
    SYSTEM_CONSTANT "EXTERNAL HEXFILE POST TREATMENT PARAMETER" "BLK_START=0x80018000"
    SYSTEM_CONSTANT "ACCD_PPRESLIN_CUR_X" "25"
    SYSTEM_CONSTANT "ACCGRV_RES" "0.01"
    SYSTEM_CONSTANT "ACCPED_TRQENG_MAP_X" "16"
    SYSTEM_CONSTANT "ACCPED_TRQENG_MAP_Y" "16"
    SYSTEM_CONSTANT "ACCPED_TRQPRP_MAP_X" "16"
    SYSTEM_CONSTANT "ACCPED_TRQPRP_MAP_Y" "16"
    SYSTEM_CONSTANT "ACC_NORM_FAC" "2777777.77777778"
    SYSTEM_CONSTANT "ACC_RES" "0.001"
    SYSTEM_CONSTANT "ACC_ZERO" "0"
    SYSTEM_CONSTANT "ACTYP_ELEC" "3"
    SYSTEM_CONSTANT "ACTYP_MECHELEC" "4"
    SYSTEM_CONSTANT "ACTYP_MECH_FIX" "1"
    SYSTEM_CONSTANT "ACTYP_MECH_VAR" "2"
    SYSTEM_CONSTANT "ACT_ANGLE_RES" "0.05"
    SYSTEM_CONSTANT "AC_DEMAND_DISBL" "0"
    SYSTEM_CONSTANT "AC_DEMAND_ENBL" "1"
    SYSTEM_CONSTANT "ADC10MV_RSA_RES_ADAPT" "50"
    SYSTEM_CONSTANT "ADC1MV_RSA_RES_ADAPT" "5"
    SYSTEM_CONSTANT "ADC20MV_10MV_RSA_RES_ADAPT" "100"
    SYSTEM_CONSTANT "ADC20MV_RSA_RES_ADAPT" "20"
    SYSTEM_CONSTANT "ADC_RES" "1023"
    SYSTEM_CONSTANT "ADC_RESOLUTION_BITS" "12"
    SYSTEM_CONSTANT "ADDHTR_ACTRENA_SY" "1"
    SYSTEM_CONSTANT "ADDHTR_CONST" "360"
    SYSTEM_CONSTANT "AFSCD_DMAIRSUBSVAL_MAP_X" "16"
    SYSTEM_CONSTANT "AFSCD_DMAIRSUBSVAL_MAP_Y" "16"
    SYSTEM_CONSTANT "AFSCD_DMLIN_CUR_X" "32"
    SYSTEM_CONSTANT "AFSCD_PLSCOR_MAP_X" "16"
    SYSTEM_CONSTANT "AFSCD_PLSCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "AFSCD_QAIRMTHRSRCHIACTV_CUR_X" "25"
    SYSTEM_CONSTANT "AFSCD_TLIN_CUR_X" "25"
    SYSTEM_CONSTANT "AFS_DMTRANSF_CURX" "64"
    SYSTEM_CONSTANT "AFS_MAIRCONV" "66666"
    SYSTEM_CONSTANT "AFS_TYPHFMSENS_SY" "0"
    SYSTEM_CONSTANT "AG_CRS_REV_SY" "16383.999999996"
    SYSTEM_CONSTANT "AIRCTL_ADD" "0"
    SYSTEM_CONSTANT "AIRCTL_AIRTEMPCORBAS_MAP_X" "16"
    SYSTEM_CONSTANT "AIRCTL_AIRTEMPCORBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_APSCOR_CUR_X" "25"
    SYSTEM_CONSTANT "AIRCTL_FACCTSCOR_CUR_X" "10"
    SYSTEM_CONSTANT "AIRCTL_FACIATSCOR_CUR_X" "10"
    SYSTEM_CONSTANT "AIRCTL_FACIATSPAR_CUR_X" "25"
    SYSTEM_CONSTANT "AIRCTL_FACNQPAR_MAP_X" "16"
    SYSTEM_CONSTANT "AIRCTL_FACNQPAR_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_MDESBAS_MAP_X" "16"
    SYSTEM_CONSTANT "AIRCTL_MDESBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_MMAXDVT_MAP_X" "16"
    SYSTEM_CONSTANT "AIRCTL_MMAXDVT_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_MNQCTSCOR_MAP_X" "16"
    SYSTEM_CONSTANT "AIRCTL_MNQCTSCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_MUL" "1"
    SYSTEM_CONSTANT "AIRCTL_NQIATSCOR_MAP_X" "16"
    SYSTEM_CONSTANT "AIRCTL_NQIATSCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_QHI_CUR_X" "25"
    SYSTEM_CONSTANT "AIRCTL_QLO_CUR_X" "25"
    SYSTEM_CONSTANT "AIRCTL_REGR_MAP_X" "8"
    SYSTEM_CONSTANT "AIRCTL_REGR_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_RTVA_MAP_X" "8"
    SYSTEM_CONSTANT "AIRCTL_RTVA_MAP_Y" "16"
    SYSTEM_CONSTANT "AIRCTL_SWTAIRTEMPCOR_TYPE" "0"
    SYSTEM_CONSTANT "AIRCTL_SWTAIRTEMPCOR_VAL" "0"
    SYSTEM_CONSTANT "AIRCTL_SWTAPSCOR_TYPE" "0"
    SYSTEM_CONSTANT "AIRCTL_SWTAPSCOR_VAL" "0"
    SYSTEM_CONSTANT "AIRCTL_SWTGOV_TYPE" "2"
    SYSTEM_CONSTANT "AIRCTL_SWTGOV_VAL" "1"
    SYSTEM_CONSTANT "AIRCTL_SWTGVNR_TYPE" "2"
    SYSTEM_CONSTANT "AIRCTL_SWTGVNR_VAL" "1"
    SYSTEM_CONSTANT "AIRCTL_SWTIATSCOR_TYPE" "0"
    SYSTEM_CONSTANT "AIRCTL_SWTIATSCOR_VAL" "0"
    SYSTEM_CONSTANT "AIRCTL_SWTTRM_TYPE" "0"
    SYSTEM_CONSTANT "AIRCTL_SWTTRM_VAL" "0"
    SYSTEM_CONSTANT "AIRCTL_TICLDSTRT_CUR_X" "25"
    SYSTEM_CONSTANT "AIRFLOW_EGAF__RES_RSA" "0.1"
    SYSTEM_CONSTANT "AIRFLRAT_RES" "0.005"
    SYSTEM_CONSTANT "AIRFLRAT_RES_REV" "200"
    SYSTEM_CONSTANT "AIRMASSPERTIME_MAX" "1000"
    SYSTEM_CONSTANT "AIRMASSPERTIME_MIN" "0"
    SYSTEM_CONSTANT "AIRMASS_MAX" "5000"
    SYSTEM_CONSTANT "AIRMASS_MIN" "-5000"
    SYSTEM_CONSTANT "AIRMASS_ONE" "1"
    SYSTEM_CONSTANT "AIRMASS_ZERO" "0"
    SYSTEM_CONSTANT "AIRSYSSWT_RES" "6.103515625e-008"
    SYSTEM_CONSTANT "AIRSYSSWT_RES_S16" "6.103515625e-005"
    SYSTEM_CONSTANT "AIRSYS_AREAEFFONE" "1"
    SYSTEM_CONSTANT "AIRSYS_AREAEFFONE_SY" "1"
    SYSTEM_CONSTANT "AIRSYS_CTFLD_NUM" "3"
    SYSTEM_CONSTANT "AIRSYS_FACLTR2MTR3_SY" "1000"
    SYSTEM_CONSTANT "AIRSYS_FACPA2HPA_SY" "100"
    SYSTEM_CONSTANT "AIRSYS_FACPRC2RAT_SY" "100"
    SYSTEM_CONSTANT "AIRSYS_FACSEC2HR_SY" "3600"
    SYSTEM_CONSTANT "AIRSYS_FACTHRADAP" "36"
    SYSTEM_CONSTANT "AIRSYS_FACTHRADAP_SY" "36"
    SYSTEM_CONSTANT "AIRSYS_LIMRATMAX_FL" "99.99"
    SYSTEM_CONSTANT "AIRSYS_LIMZERO_FL" "0.001"
    SYSTEM_CONSTANT "AIRSYS_MINDEADTIME_SY" "1"
    SYSTEM_CONSTANT "AIRSYS_PRC100_FL" "100"
    SYSTEM_CONSTANT "AIRSYS_PRES_AIR_SY" "1000"
    SYSTEM_CONSTANT "AIRSYS_RMPTIME_MIN" "1e-007"
    SYSTEM_CONSTANT "AIRSYS_RMP_MAX" "1"
    SYSTEM_CONSTANT "AIRSYS_RMP_MAX_S16" "1"
    SYSTEM_CONSTANT "AIRSYS_RMP_MIN" "0"
    SYSTEM_CONSTANT "AIRSYS_SWT_FACT" "16384000"
    SYSTEM_CONSTANT "AIRSYS_SWT_FACT_S16" "16384"
    SYSTEM_CONSTANT "AIRSYS_SWT_NRM_EXP" "14"
    SYSTEM_CONSTANT "AIRSYS_TEMPTHRPST" "300"
    SYSTEM_CONSTANT "AIRSYS_TEMPTHRPST_SY" "300"
    SYSTEM_CONSTANT "AIR_KG_GM" "10"
    SYSTEM_CONSTANT "AIR_MASS_NORM" "66666"
    SYSTEM_CONSTANT "AIR_NUMTEMPSENSMON_SY" "5"
    SYSTEM_CONSTANT "ALTCRNT_LIM_RES" "0.25"
    SYSTEM_CONSTANT "ALTCRNT_OUT_RES" "0.125"
    SYSTEM_CONSTANT "ALTIO_BSS_PERI_ID_SY" "6"
    SYSTEM_CONSTANT "ALTLD_RES" "3.125"
    SYSTEM_CONSTANT "ALTVLTG_OFS" "10.6"
    SYSTEM_CONSTANT "ALTVLTG_RES_SY" "0.1"
    SYSTEM_CONSTANT "ALT_CHPTEMP_OFS" "-32"
    SYSTEM_CONSTANT "ALT_CHPTEMP_RES" "8"
    SYSTEM_CONSTANT "AMPC_NULL" "0"
    SYSTEM_CONSTANT "AMPC_RES" "0.1"
    SYSTEM_CONSTANT "AMPC_RES_FL" "0.1"
    SYSTEM_CONSTANT "AMPC_RES_REV" "10"
    SYSTEM_CONSTANT "AMPC_ZERO" "0"
    SYSTEM_CONSTANT "AMPERE_ADC_RES" "0.2"
    SYSTEM_CONSTANT "AMPERE_Q0P1_RES" "0.1"
    SYSTEM_CONSTANT "AMPERE_ZERO" "0"
    SYSTEM_CONSTANT "AMPTGPERSEC_RES" "0.05"
    SYSTEM_CONSTANT "AMPTGPERSEC_RES_FL" "0.05"
    SYSTEM_CONSTANT "AMPTGPERSEC_RES_REV" "20"
    SYSTEM_CONSTANT "AMPTSCND_RES" "0.1"
    SYSTEM_CONSTANT "AMPT_2_ZERO" "0"
    SYSTEM_CONSTANT "AMPT_NOXLDUNLD_RES" "0.0001"
    SYSTEM_CONSTANT "AMPT_NOXLDUNLD_RES_REV" "10000"
    SYSTEM_CONSTANT "AMPT_NOXRGN_MIN" "0"
    SYSTEM_CONSTANT "AMPT_NOXRGN_RES" "0.0005"
    SYSTEM_CONSTANT "AMPT_NOXRGN_RES_REV" "2000"
    SYSTEM_CONSTANT "AMPT_NOX_RES" "1e-005"
    SYSTEM_CONSTANT "AMPT_NOX_RES_REV" "100000"
    SYSTEM_CONSTANT "AMPT_NULL" "0"
    SYSTEM_CONSTANT "AMPT_RES" "0.1"
    SYSTEM_CONSTANT "AMPT_RES_2" "3.2e-005"
    SYSTEM_CONSTANT "AMPT_RES_2_REV" "31250"
    SYSTEM_CONSTANT "AMPT_RES_FL" "0.1"
    SYSTEM_CONSTANT "AMPT_RES_REV" "10"
    SYSTEM_CONSTANT "AMPT_SOX1_MIN" "0"
    SYSTEM_CONSTANT "AMPT_SOX1_RES" "0.003"
    SYSTEM_CONSTANT "AMPT_SOX1_RES_FL" "0.003"
    SYSTEM_CONSTANT "AMPT_ZERO" "0"
    SYSTEM_CONSTANT "AM_RES" "0.01"
    SYSTEM_CONSTANT "AM_RES_2" "0.1"
    SYSTEM_CONSTANT "AM_RES_FL" "0.01"
    SYSTEM_CONSTANT "ANGLE_CPP_RES" "46603.3777777664"
    SYSTEM_CONSTANT "ANGLE_DER1" "16"
    SYSTEM_CONSTANT "ANGLE_DER1_ZERO" "0"
    SYSTEM_CONSTANT "ANGLE_DER2" "8"
    SYSTEM_CONSTANT "ANGLE_DER2_ZERO" "0"
    SYSTEM_CONSTANT "ANGLE_HIGH_RES_RB" "4551.11111111"
    SYSTEM_CONSTANT "ANGLE_HIGH_RES_RSA" "5000"
    SYSTEM_CONSTANT "ANGLE_INDEX_CPP_RES" "1"
    SYSTEM_CONSTANT "ANGLE_RES" "45.5111111111"
    SYSTEM_CONSTANT "ANGLE_RES_1" "32"
    SYSTEM_CONSTANT "ANGLE_RES_FL" "45.5111111111"
    SYSTEM_CONSTANT "ANGLE_RES_INV_FL" "0.0219726562500054"
    SYSTEM_CONSTANT "ANGLE_RES_OFFS_RSA" "18000"
    SYSTEM_CONSTANT "ANGLE_RES_RSA" "50"
    SYSTEM_CONSTANT "ANGLE_STWHL_RES" "0.03125"
    SYSTEM_CONSTANT "ANGLE_STWHL_RES_REV" "32"
    SYSTEM_CONSTANT "ANGLE_ZERO" "0"
    SYSTEM_CONSTANT "AOHT_TAIRUPLI_CUR_X" "25"
    SYSTEM_CONSTANT "APPCD_DUSYNC_CUR_X" "2"
    SYSTEM_CONSTANT "APPCD_RLINAPP1_CUR_X" "2"
    SYSTEM_CONSTANT "APPCD_RLINAPP2_CUR_X" "2"
    SYSTEM_CONSTANT "APPCD_RLINAPP_CUR_X" "2"
    SYSTEM_CONSTANT "APPLY" "4"
    SYSTEM_CONSTANT "APSCD_PCOR_MAP_X" "16"
    SYSTEM_CONSTANT "APSCD_PCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "APSCD_PLIN_CUR_X" "25"
    SYSTEM_CONSTANT "AR2EFFGRAD_RES" "1e-005"
    SYSTEM_CONSTANT "AR2EFFGRAD_RES_REV" "100000"
    SYSTEM_CONSTANT "AREA_CM2_LOW_RES" "0.004"
    SYSTEM_CONSTANT "AREA_CM2_LOW_RES_FL" "0.004"
    SYSTEM_CONSTANT "AREA_CM2_MAX" "50"
    SYSTEM_CONSTANT "AREA_CM2_RES" "0.001"
    SYSTEM_CONSTANT "AREA_CM2_RES_FL" "0.001"
    SYSTEM_CONSTANT "AREA_CM2_RES_REV" "1000"
    SYSTEM_CONSTANT "AREA_CM2_ZERO" "0"
    SYSTEM_CONSTANT "AREA_CM2_ZERO_FL" "0"
    SYSTEM_CONSTANT "AREA_RES_FL" "0.0001220703125"
    SYSTEM_CONSTANT "ASDDC_FDT1PARAMMAP_KD_MAP_X" "16"
    SYSTEM_CONSTANT "ASDDC_FDT1PARAMMAP_KD_MAP_Y" "5"
    SYSTEM_CONSTANT "ASDDC_FDT1PARAMMAP_T1_MAP_X" "16"
    SYSTEM_CONSTANT "ASDDC_FDT1PARAMMAP_T1_MAP_Y" "5"
    SYSTEM_CONSTANT "ASDDC_GRIP_MAP_X" "16"
    SYSTEM_CONSTANT "ASDDC_GRIP_MAP_Y" "5"
    SYSTEM_CONSTANT "ASDRF_DTRQINRLTDLIM_CUR_X" "7"
    SYSTEM_CONSTANT "ASDRF_PARABLEPARAMCUR_COEFA_CUR_X" "16"
    SYSTEM_CONSTANT "ASDRF_PARABLEPARAMCUR_COEFB_CUR_X" "16"
    SYSTEM_CONSTANT "ASDRF_TRQLOSNEG_CUR_X" "16"
    SYSTEM_CONSTANT "ASDRF_TRQLOSPOS_CUR_X" "16"
    SYSTEM_CONSTANT "ASDRF_XDT1PARAMCUR_KD_CUR_X" "16"
    SYSTEM_CONSTANT "ASDRF_XDT1PARAMCUR_T1_CUR_X" "16"
    SYSTEM_CONSTANT "ASHMPTEG_RES" "0.0005"
    SYSTEM_CONSTANT "ASHMPT_RES" "0.01"
    SYSTEM_CONSTANT "ASHMSGP0Q1_RES" "0.1"
    SYSTEM_CONSTANT "ASHMSMGP0Q0016_RES" "0.0016"
    SYSTEM_CONSTANT "ASMOD_ACCURACY_FACT1" "1000"
    SYSTEM_CONSTANT "ASMOD_ACCURACY_FACT2" "10"
    SYSTEM_CONSTANT "ASMOD_AMPTO2MPT_NRM" "20000"
    SYSTEM_CONSTANT "ASMOD_AMPTRATFMO2MPT_NRM" "20"
    SYSTEM_CONSTANT "ASMOD_AREFFEGRLP_CUR_X" "12"
    SYSTEM_CONSTANT "ASMOD_AREFFEGRLP_MAX_FL" "50"
    SYSTEM_CONSTANT "ASMOD_AREFFEGRLP_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_AREFFEGR_CURX" "12"
    SYSTEM_CONSTANT "ASMOD_AREFFEGR_CUR_X" "12"
    SYSTEM_CONSTANT "ASMOD_AREFFEXHFLPLP_CUR_X" "10"
    SYSTEM_CONSTANT "ASMOD_AREFFTVA_CURX" "10"
    SYSTEM_CONSTANT "ASMOD_AREFFTVA_CUR_X" "10"
    SYSTEM_CONSTANT "ASMOD_AREFF_LONG_MAX_FL" "100"
    SYSTEM_CONSTANT "ASMOD_AREFF_LONG_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_AREFF_MAX" "32"
    SYSTEM_CONSTANT "ASMOD_AREFF_MAX_FL" "32"
    SYSTEM_CONSTANT "ASMOD_AREFF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_AREFF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_AREXCHEXTBRICK_CAX" "2"
    SYSTEM_CONSTANT "ASMOD_AREXCHEXTBRICK_MAX" "0.3"
    SYSTEM_CONSTANT "ASMOD_AREXCHEXTBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_AREXCHNSCBRICK_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_AREXCHNSCBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_AROXIC_MAX" "4"
    SYSTEM_CONSTANT "ASMOD_AROXIC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_CNDHTOFS_MAX" "0.01"
    SYSTEM_CONSTANT "ASMOD_CNDHTOFS_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_CNDHT_RES" "122070.3125"
    SYSTEM_CONSTANT "ASMOD_CPCATBRICK_CURX" "10"
    SYSTEM_CONSTANT "ASMOD_CPCATBRICK_MAX" "1.6"
    SYSTEM_CONSTANT "ASMOD_CPCATBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_CPEGBRICK_CURX" "10"
    SYSTEM_CONSTANT "ASMOD_CPEGBRICK_MAX" "1.2"
    SYSTEM_CONSTANT "ASMOD_CPEGBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_CPEGNSC_MAX" "65534"
    SYSTEM_CONSTANT "ASMOD_CPEGNSC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_CPGAS_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_CPGAS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_CPNSCBRICK_CURX" "11"
    SYSTEM_CONSTANT "ASMOD_CPNSCBRICK_CUR_X" "11"
    SYSTEM_CONSTANT "ASMOD_CPNSCBRICK_MAX" "1500"
    SYSTEM_CONSTANT "ASMOD_CPNSCBRICK_MIN" "500"
    SYSTEM_CONSTANT "ASMOD_CPOXIC_MAX" "3000"
    SYSTEM_CONSTANT "ASMOD_CPOXIC_MIN" "0.1"
    SYSTEM_CONSTANT "ASMOD_CPPFLT_MAX" "10000"
    SYSTEM_CONSTANT "ASMOD_CPPFLT_MIN" "200"
    SYSTEM_CONSTANT "ASMOD_CPPIPE_MAX" "3000"
    SYSTEM_CONSTANT "ASMOD_CPPIPE_MIN" "0.1"
    SYSTEM_CONSTANT "ASMOD_CT_PIPE" "2"
    SYSTEM_CONSTANT "ASMOD_CT_PIPESLW" "1"
    SYSTEM_CONSTANT "ASMOD_CT_PIPESLW_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_CT_PIPE_MAX" "4"
    SYSTEM_CONSTANT "ASMOD_DELAYFLD_SY" "10"
    SYSTEM_CONSTANT "ASMOD_DELAY_ARRSIZE" "16"
    SYSTEM_CONSTANT "ASMOD_DMAIRCONV" "360"
    SYSTEM_CONSTANT "ASMOD_DMAIRDESREF_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMAIRDESREF_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMAIRDESREF_MAX" "1400"
    SYSTEM_CONSTANT "ASMOD_DMAIRDESREF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMASHEG_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMASHEG_MAX" "16"
    SYSTEM_CONSTANT "ASMOD_DMASHEG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMCMPRUS_MAX_FL" "1400"
    SYSTEM_CONSTANT "ASMOD_DMCMPRUS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DMCOBASLM_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMCOBASLM_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMCOBASPHC_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMCOBASPHC_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMCOBASRM_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMCOBASRM_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMCO_MAX" "1638.35"
    SYSTEM_CONSTANT "ASMOD_DMCO_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMDESBAS_RES" "66666.6666666667"
    SYSTEM_CONSTANT "ASMOD_DMEFFLEANEXOMFL_MAX" "1500"
    SYSTEM_CONSTANT "ASMOD_DMEFFLEANEXOMFL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMEGCRVIN_MAX" "1500"
    SYSTEM_CONSTANT "ASMOD_DMEGCRVIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMEGFLD_MAX" "320"
    SYSTEM_CONSTANT "ASMOD_DMEGFLD_MIN" "-120"
    SYSTEM_CONSTANT "ASMOD_DMEGRDS_MAX_FL" "700"
    SYSTEM_CONSTANT "ASMOD_DMEGRDS_MIN_FL" "-700"
    SYSTEM_CONSTANT "ASMOD_DMEGRINTMNFDS_MAX_FL" "720"
    SYSTEM_CONSTANT "ASMOD_DMEGRINTMNFDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DMEGRINTMNF_MAX_FL" "180"
    SYSTEM_CONSTANT "ASMOD_DMEGRINTMNF_MIN_FL" "-180"
    SYSTEM_CONSTANT "ASMOD_DMEGRLPDS_MAX_FL" "700"
    SYSTEM_CONSTANT "ASMOD_DMEGRLPDS_MIN_FL" "-700"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFDSRED_MAX_FL" "1500"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFDSRED_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFDS_MAX" "1400"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFDS_MAX_FL" "1400"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFDS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFLPDS_MAX_FL" "1400"
    SYSTEM_CONSTANT "ASMOD_DMEXHMNFLPDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DMFUELBURNED_RES" "6896.55172413793"
    SYSTEM_CONSTANT "ASMOD_DMFUEL_RES" "66666.6666666667"
    SYSTEM_CONSTANT "ASMOD_DMINDVOL_MAX_FL" "360"
    SYSTEM_CONSTANT "ASMOD_DMINDVOL_MIN_FL" "-360"
    SYSTEM_CONSTANT "ASMOD_DMIND_RES" "100"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFDSREF_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFDSREF_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFDSREF_MAX" "1400"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFDSREF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFDS_MAX_FL" "1400"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFUS_MAX_FL" "1400"
    SYSTEM_CONSTANT "ASMOD_DMINTMNFUS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DMINTMNF_MAX_FL" "360"
    SYSTEM_CONSTANT "ASMOD_DMINTMNF_MIN_FL" "-360"
    SYSTEM_CONSTANT "ASMOD_DMMSAIRDVT_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_DMMSAIRDVT_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_DMNOXBASLM_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOXBASLM_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOXBASPHC_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOXBASPHC_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOXBASRM_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOXBASRM_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOXEGROFF_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOXEGROFF_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DMNOX_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_DMNOX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMNSCUS_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_DMNSCUS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMO2INTMNF_MAX_FL" "80"
    SYSTEM_CONSTANT "ASMOD_DMO2INTMNF_MIN_FL" "-80"
    SYSTEM_CONSTANT "ASMOD_DMO2_RES" "10000"
    SYSTEM_CONSTANT "ASMOD_DMOILCONSBAS_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMPFLTUS_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_DMPFLTUS_MIN" "-1000"
    SYSTEM_CONSTANT "ASMOD_DMSOTBASLM_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTBASLM_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTBASPHC_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTBASPHC_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTBASRM_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTBASRM_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTDYNRM_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTDYNRM_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTLAMCOR_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTLAMCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTRATEGRCORBAS_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOTRATEGRCORBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOT_MAX" "327.67"
    SYSTEM_CONSTANT "ASMOD_DMSOT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMSOXOIL_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_DMSOXOIL_MAX" "0.5"
    SYSTEM_CONSTANT "ASMOD_DMSOXOIL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DMSOXREDMSFLWEGCRVIN_MAX" "450"
    SYSTEM_CONSTANT "ASMOD_DMSOXREDMSFLWEGCRVIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DM_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_DM_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DRLAMRECMIN_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_DRLAMRECMIN_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_DT1KDLAMSOT_MAX" "50"
    SYSTEM_CONSTANT "ASMOD_DT1KDLAMSOT_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_DT1T1LAMSOT_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_DT1T1LAMSOT_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_DVOLEGPFLT_MAX" "3200"
    SYSTEM_CONSTANT "ASMOD_DVOLEGPFLT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DVOLEGPIPE_MAX" "3200"
    SYSTEM_CONSTANT "ASMOD_DVOLEGPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DVOLFLCONS_MAX" "40"
    SYSTEM_CONSTANT "ASMOD_DVOLFLCONS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DVOLPFLTEG_RES" "347.826086956522"
    SYSTEM_CONSTANT "ASMOD_DWENVOXICDFL_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_DWENVOXICDFL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MAPX" "6"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MAPY" "16"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MAP_X" "6"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MAX" "65534"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MAX_FL" "65534"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXODSOXNSCBRICK_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXOLEANNSCBRICK_MAX" "65534"
    SYSTEM_CONSTANT "ASMOD_DWEXOLEANNSCBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXOMINAVLSWTOFF_MAX" "32767"
    SYSTEM_CONSTANT "ASMOD_DWEXOMINAVLSWTOFF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXONSCBRICKIN_MAX" "5000"
    SYSTEM_CONSTANT "ASMOD_DWEXONSCBRICKIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXONSCBRICK_MAX" "65534"
    SYSTEM_CONSTANT "ASMOD_DWEXONSCBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MAPX" "6"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MAPY" "16"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MAP_X" "6"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MAX" "65534"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MAX_FL" "65534"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWEXORICHNSCBRICK_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODNOX_MAPX" "6"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODNOX_MAPY" "10"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODNOX_MAX" "40000"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODNOX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODSOX_MAPX" "6"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODSOX_MAPY" "10"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODSOX_MAX" "45000"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXODSOX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXOENGOUT_MAX" "45000"
    SYSTEM_CONSTANT "ASMOD_DWMAXEXOENGOUT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_EGYKILOPWR_NRM" "1"
    SYSTEM_CONSTANT "ASMOD_ENERGYPERMOL2TEMP" "10000000"
    SYSTEM_CONSTANT "ASMOD_ENGN_VOLEFF" "1000"
    SYSTEM_CONSTANT "ASMOD_ENG_FACTOR1" "200"
    SYSTEM_CONSTANT "ASMOD_ENG_FACTOR2" "36000"
    SYSTEM_CONSTANT "ASMOD_ENG_FACTOR3" "20000"
    SYSTEM_CONSTANT "ASMOD_ENG_FACTOR4" "100"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP1_MAX_FL" "1"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP1_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP2_MAX_FL" "700"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP2_MIN_FL" "-700"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP3_MAX_FL" "100"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP3_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP_MAP_X" "6"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP_MAP_Y" "3"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP_MAX_FL" "800"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLGLP_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLG_MAPX" "6"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLG_MAPY" "3"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLG_MAP_X" "6"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLG_MAP_Y" "3"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLG_MAX_FL" "1"
    SYSTEM_CONSTANT "ASMOD_ETAEGRCLG_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_ETATRBCH_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_ETATRBCH_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_ETATRBCH_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_ETATRBCH_MIN" "0.0001"
    SYSTEM_CONSTANT "ASMOD_ETATRBN_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_ETATRBN_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_ETATRBN_MAX_FL" "1"
    SYSTEM_CONSTANT "ASMOD_ETATRBN_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_EXHMASS_MAX" "500"
    SYSTEM_CONSTANT "ASMOD_EXHMASS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FAC1LAMDIFFNSCCOR_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FAC1LAMDIFFNSCCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACAMCOR_RES" "122.0703125"
    SYSTEM_CONSTANT "ASMOD_FACBRICKOXIC_MAX" "0.9"
    SYSTEM_CONSTANT "ASMOD_FACBRICKOXIC_MIN" "0.1"
    SYSTEM_CONSTANT "ASMOD_FACCALVALFL_MAX" "50000"
    SYSTEM_CONSTANT "ASMOD_FACCALVALFL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACCNDHTSLP_MAX" "8e-005"
    SYSTEM_CONSTANT "ASMOD_FACCNDHTSLP_MIN" "6e-005"
    SYSTEM_CONSTANT "ASMOD_FACCNVTEGNSCCOR_MAX" "2.55"
    SYSTEM_CONSTANT "ASMOD_FACCNVTEGNSCCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACCNVTEGNSC_MAX" "6000"
    SYSTEM_CONSTANT "ASMOD_FACCNVTEGNSC_MIN" "100"
    SYSTEM_CONSTANT "ASMOD_FACCOCLNTTEMPCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACCOCLNTTEMPCOR_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACCOCLNTTEMPCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACDDT_MAX" "8"
    SYSTEM_CONSTANT "ASMOD_FACDDT_MIN" "1"
    SYSTEM_CONSTANT "ASMOD_FACDNOXEXOHTBRICK_CAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACDNOXEXOHTBRICK_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACDNOXEXOHTBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACDSOXEXOHTBRICK_CAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACDSOXEXOHTBRICK_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACDSOXEXOHTBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEFFLEANEXOMFL_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_FACEFFLEANEXOMFL_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACEFFLEANEXOMFL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEFFLEANEXOTEMP_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_FACEFFLEANEXOTEMP_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACEFFLEANEXOTEMP_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTCORMAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTCORMAX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTCORMIN" "-2"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTCORMIN_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTPOP_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTPOP_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTPOP_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTPOP_MIN" "-10"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTWGH1_CUR_X" "16"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTWGH2_CUR_X" "16"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTWGH_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACEGRDVTWGH_MIN" "-1"
    SYSTEM_CONSTANT "ASMOD_FACEGTEMPMSFLWCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACEGTEMPMSFLWCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACEGTEMPMSFLWCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEGTEMPSOICOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACEGTEMPSOICOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACEGTEMPSOICOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEXOEFFMIN_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACEXOEFFMIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEXOEG_CURX" "11"
    SYSTEM_CONSTANT "ASMOD_FACEXOEG_CUR_X" "11"
    SYSTEM_CONSTANT "ASMOD_FACEXOEG_MAX" "0.1"
    SYSTEM_CONSTANT "ASMOD_FACEXOEG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEXOGN_MAX" "0.1"
    SYSTEM_CONSTANT "ASMOD_FACEXOGN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEXPOCALC_CURX" "11"
    SYSTEM_CONSTANT "ASMOD_FACEXPOCALC_CUR_X" "11"
    SYSTEM_CONSTANT "ASMOD_FACEXPOCALC_MAX" "0.003"
    SYSTEM_CONSTANT "ASMOD_FACEXPOCALC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACEXPOENRG_MAX" "-1"
    SYSTEM_CONSTANT "ASMOD_FACEXPOENRG_MIN" "-69"
    SYSTEM_CONSTANT "ASMOD_FACGEOEGPIPE_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_FACGEOEGPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACHCCNVOXIC_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_FACHCCNVOXIC_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACHCCNVOXIC_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACHCCNVOXIC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACHTTRANSNOLIN_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFDSTEMPCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFDSTEMPCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFTEMPMSFLWCOR_MAPX" "8"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFTEMPMSFLWCOR_MAPY" "8"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFTEMPMSFLWCOR_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFTEMPMSFLWCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFTEMPMSFLWCOR_MAX_FL" "1"
    SYSTEM_CONSTANT "ASMOD_FACINTMNFTEMPMSFLWCOR_MIN_FL" "-1"
    SYSTEM_CONSTANT "ASMOD_FACKINCONSTCOOXI_MAX" "100000"
    SYSTEM_CONSTANT "ASMOD_FACKINCONSTCOOXI_MIN" "10000"
    SYSTEM_CONSTANT "ASMOD_FACLAMDIFFNSCCOR_CURX" "4"
    SYSTEM_CONSTANT "ASMOD_FACLAMDIFFNSCCOR_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACLAMDIFFNSCCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACLAMRECREF_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACLAMRECREF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXOXIC_MAPX" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXOXIC_MAPY" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXOXIC_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXOXIC_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXOXIC_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXOXIC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXPFLT_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXPFLT_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXPFLT_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXPFLT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXTEMPEG_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXTEMPEG_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXTEMPEG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXTEMPENG_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXTEMPENG_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACLEANNOXTEMPENG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACMFLEGSPECHTCOR_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_FACMFLEGSPECHTCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACMFLEGSPECHTCOR_MAX" "30"
    SYSTEM_CONSTANT "ASMOD_FACMFLEGSPECHTCOR_MIN" "5"
    SYSTEM_CONSTANT "ASMOD_FACMFLNOXLFTCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACMFLNOXLFTCOR_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_FACMFLNOXLFTCOR_MIN" "-10"
    SYSTEM_CONSTANT "ASMOD_FACMSAIRDVTPOPCOR_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACMSAIRDVTPOPCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_FACMSAIRDVTPOPCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACMSAIRDVTPOPCOR_MIN" "-2"
    SYSTEM_CONSTANT "ASMOD_FACMSFLWTEMPCOR_MAX_FL" "2"
    SYSTEM_CONSTANT "ASMOD_FACMSFLWTEMPCOR_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_FACNOXCLNTTEMPCORBAS_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXCLNTTEMPCORBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXCLNTTEMPCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXCLNT_MAX" "3"
    SYSTEM_CONSTANT "ASMOD_FACNOXCLNT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACNOXENGCHCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXENG_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_FACNOXENG_MIN" "-10"
    SYSTEM_CONSTANT "ASMOD_FACNOXEPCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXEPCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACNOXEPCOR_MIN" "-3"
    SYSTEM_CONSTANT "ASMOD_FACNOXEPPOPCOR_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXEPPOPCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXEPPOPCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACNOXEPPOPCOR_MIN" "-3"
    SYSTEM_CONSTANT "ASMOD_FACNOXMSAIRDVT_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACNOXMSAIRDVT_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_FACNOXMSAIRDVT_MIN" "-5"
    SYSTEM_CONSTANT "ASMOD_FACOILCONSLFTCOR_CUR_X" "16"
    SYSTEM_CONSTANT "ASMOD_FACOILCONSLFTCOR_MAX" "3"
    SYSTEM_CONSTANT "ASMOD_FACOILCONSLFTCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACPOWEGPIPE_CUR_X" "11"
    SYSTEM_CONSTANT "ASMOD_FACPOWEGPIPE_MAX" "250"
    SYSTEM_CONSTANT "ASMOD_FACPOWEGPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACPRESEGRLP_MAX_FL" "0.3"
    SYSTEM_CONSTANT "ASMOD_FACPRESEGRLP_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_FACPRESLSEGRCLGLP_CUR_X" "3"
    SYSTEM_CONSTANT "ASMOD_FACPRESLSEGRCLG_CURX" "3"
    SYSTEM_CONSTANT "ASMOD_FACPRESLSEGRCLG_CUR_X" "3"
    SYSTEM_CONSTANT "ASMOD_FACPRESLS_MAX_FL" "0.3"
    SYSTEM_CONSTANT "ASMOD_FACPRESLS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_FACPRSTNSC_MAX" "0.9"
    SYSTEM_CONSTANT "ASMOD_FACPRSTNSC_MIN" "0.5"
    SYSTEM_CONSTANT "ASMOD_FACRECOR_CURX" "11"
    SYSTEM_CONSTANT "ASMOD_FACRECOR_CUR_X" "11"
    SYSTEM_CONSTANT "ASMOD_FACRECOR_MAX" "16383.5"
    SYSTEM_CONSTANT "ASMOD_FACRECOR_MIN" "100"
    SYSTEM_CONSTANT "ASMOD_FACRHOETAEGPIPE_MAP_X" "9"
    SYSTEM_CONSTANT "ASMOD_FACRHOETAEGPIPE_MAP_Y" "2"
    SYSTEM_CONSTANT "ASMOD_FACRHOETAEGPIPE_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_FACRHOETAEGPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACRSTOICH" "14.5"
    SYSTEM_CONSTANT "ASMOD_FACSOTLFTCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACSOTLFTCOR_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACSOTLFTCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACSOTRATEGRCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACSOTRATEGRCOR_MAX" "3"
    SYSTEM_CONSTANT "ASMOD_FACSOTRATEGRCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACSOXREDMSFLWEG_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACSOXREDMSFLWEG_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACSOXREDMSFLWEG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACSQR" "100"
    SYSTEM_CONSTANT "ASMOD_FACSQR_CUR_X" "10"
    SYSTEM_CONSTANT "ASMOD_FACT2PWR11_NRM" "32"
    SYSTEM_CONSTANT "ASMOD_FACTEMPCLG_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACTEMPCLG_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACTEMPCLG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACTEMPENVCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACTEMPENVCOR_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_FACTEMPENVCOR_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_FACTEMPENVPOPCOR_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACTEMPENVPOPCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_FACTEMPENVPOPCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACTEMPENVPOPCOR_MIN" "-3"
    SYSTEM_CONSTANT "ASMOD_FACTEMPINTMNFDSCOR_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_FACTEMPINTMNFDSCOR_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_FACTEMPINTMNFDSCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACTEMPINTMNFDSCOR_MIN" "-2"
    SYSTEM_CONSTANT "ASMOD_FACTHMCNDNSC_MAX" "0.09"
    SYSTEM_CONSTANT "ASMOD_FACTHMCNDNSC_MIN" "0.01"
    SYSTEM_CONSTANT "ASMOD_FACTIMECLG_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_FACTIMECLG_MAX" "255"
    SYSTEM_CONSTANT "ASMOD_FACTIMECLG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACTOR1" "0.472336"
    SYSTEM_CONSTANT "ASMOD_FACTOR2" "0.47172"
    SYSTEM_CONSTANT "ASMOD_FACTOR3" "0.52828"
    SYSTEM_CONSTANT "ASMOD_FACTRBN1_MAX_FL" "2000"
    SYSTEM_CONSTANT "ASMOD_FACTRBN1_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_FACTRBN2_MAX_FL" "200"
    SYSTEM_CONSTANT "ASMOD_FACTRBN2_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_FACTRBN3_MAX_FL" "300000"
    SYSTEM_CONSTANT "ASMOD_FACTRBN3_MIN_FL" "-300000"
    SYSTEM_CONSTANT "ASMOD_FACTRBN4_MAX_FL" "1000000"
    SYSTEM_CONSTANT "ASMOD_FACTRBN4_MIN_FL" "-1000000"
    SYSTEM_CONSTANT "ASMOD_FACVELDPNCOR_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_FACVELDPNCOR_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_FACVELDPNCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACVELTHMDPN_CURX" "16"
    SYSTEM_CONSTANT "ASMOD_FACVELTHMDPN_CUR_X" "16"
    SYSTEM_CONSTANT "ASMOD_FACVELTHMDPN_MAX" "655.34"
    SYSTEM_CONSTANT "ASMOD_FACVELTHMDPN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFF" "1000"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFBAS_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFBAS_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFBAS_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFBAS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFVSACOR_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFVSACOR_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFVSACOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFFVSACOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFF_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_FACVOLEFF_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_FACVSACORVOLEFF_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_FACVSACORVOLEFF_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_FACVSCDYNSLP_MAX" "0.0002"
    SYSTEM_CONSTANT "ASMOD_FACVSCDYNSLP_MIN" "3e-005"
    SYSTEM_CONSTANT "ASMOD_FACVSCKINSLP_MAX" "2e-007"
    SYSTEM_CONSTANT "ASMOD_FACVSCKINSLP_MIN" "8e-008"
    SYSTEM_CONSTANT "ASMOD_FAC_AIRMASSPERTIME" "3.6"
    SYSTEM_CONSTANT "ASMOD_FAC_AREA" "10000"
    SYSTEM_CONSTANT "ASMOD_FAC_DENS" "0.348432055749129"
    SYSTEM_CONSTANT "ASMOD_FAC_PRC" "100"
    SYSTEM_CONSTANT "ASMOD_FAC_PRC_FL" "100"
    SYSTEM_CONSTANT "ASMOD_FAC_PRES" "100"
    SYSTEM_CONSTANT "ASMOD_FAC_PSI" "36"
    SYSTEM_CONSTANT "ASMOD_FAC_VOLEFF" "1000"
    SYSTEM_CONSTANT "ASMOD_FlAIREXHGS_RES" "10"
    SYSTEM_CONSTANT "ASMOD_GAS_CONST1" "0.85"
    SYSTEM_CONSTANT "ASMOD_GAS_CONST2" "1.2177075"
    SYSTEM_CONSTANT "ASMOD_GAS_CONST_FL" "8.314"
    SYSTEM_CONSTANT "ASMOD_GAS_CONST_INT" "8314"
    SYSTEM_CONSTANT "ASMOD_HENG_CALC" "348"
    SYSTEM_CONSTANT "ASMOD_HENG_RES" "34.8"
    SYSTEM_CONSTANT "ASMOD_HTCAPTEMPEGYKILO_NRM" "10"
    SYSTEM_CONSTANT "ASMOD_HTCAPTEMPFINEEGYKILO_NRM" "1000000"
    SYSTEM_CONSTANT "ASMOD_HTCFREECNVTPIPE_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_HTCFREECNVTPIPE_MIN" "0.1"
    SYSTEM_CONSTANT "ASMOD_HTCOXIC_MAPX" "8"
    SYSTEM_CONSTANT "ASMOD_HTCOXIC_MAPY" "8"
    SYSTEM_CONSTANT "ASMOD_HTCOXIC_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_HTCOXIC_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_HTCOXIC_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_HTCOXIC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_HTFLW_RES" "2"
    SYSTEM_CONSTANT "ASMOD_HTFLW_RES_FL" "2"
    SYSTEM_CONSTANT "ASMOD_IMPT2AMPT" "10"
    SYSTEM_CONSTANT "ASMOD_INDVOL_MAX" "50"
    SYSTEM_CONSTANT "ASMOD_INDVOL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_INTEGLIMIT" "655340000"
    SYSTEM_CONSTANT "ASMOD_KGH2GS" "16384"
    SYSTEM_CONSTANT "ASMOD_KILO" "1000"
    SYSTEM_CONSTANT "ASMOD_KILOPWRHCMPTCAL_NRM" "1000"
    SYSTEM_CONSTANT "ASMOD_LAMBDAREC1" "3.35671375"
    SYSTEM_CONSTANT "ASMOD_LCHNNSC_MAX" "0.65534"
    SYSTEM_CONSTANT "ASMOD_LCHNNSC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_LDIAMPIPE_MAX" "0.1"
    SYSTEM_CONSTANT "ASMOD_LDIAMPIPE_MIN" "0.01"
    SYSTEM_CONSTANT "ASMOD_LLNGTHPIPE_MAX" "3"
    SYSTEM_CONSTANT "ASMOD_LLNGTHPIPE_MIN" "0.01"
    SYSTEM_CONSTANT "ASMOD_LMEXO_SY" "1"
    SYSTEM_CONSTANT "ASMOD_LNSCBRICK_MAX" "0.65534"
    SYSTEM_CONSTANT "ASMOD_LNSCBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_LSUMVEHLFTNOX_MAX" "500000"
    SYSTEM_CONSTANT "ASMOD_LSUMVEHLFTNOX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_LSUMVEHLFTSOT_MAX" "500000"
    SYSTEM_CONSTANT "ASMOD_LSUMVEHLFTSOT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_MAIRCONV" "66666"
    SYSTEM_CONSTANT "ASMOD_MAIRINTMNF_MAX_FL" "20"
    SYSTEM_CONSTANT "ASMOD_MAIRINTMNF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_MAIRPERCYLCOR_MAX" "700"
    SYSTEM_CONSTANT "ASMOD_MAIRPERCYLCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_MASS_NORM" "287.356321839081"
    SYSTEM_CONSTANT "ASMOD_MAXFUELMASS_NRM" "3.35675"
    SYSTEM_CONSTANT "ASMOD_MBRICK_CAX" "2"
    SYSTEM_CONSTANT "ASMOD_MBRICK_MAX" "2000"
    SYSTEM_CONSTANT "ASMOD_MBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_MEGRINTMNF_MAX_FL" "10"
    SYSTEM_CONSTANT "ASMOD_MEGRINTMNF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_MEXHMNFLP_MAX_FL" "150"
    SYSTEM_CONSTANT "ASMOD_MEXHMNFLP_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_MINDAIR" "445.44"
    SYSTEM_CONSTANT "ASMOD_MINDVOL_MAX_FL" "150"
    SYSTEM_CONSTANT "ASMOD_MINDVOL_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_MINMEXHMNFLP_FL" "0.5"
    SYSTEM_CONSTANT "ASMOD_MINMINDVOL_FL" "0.5"
    SYSTEM_CONSTANT "ASMOD_MINTMNFMIN_MAX_FL" "10"
    SYSTEM_CONSTANT "ASMOD_MINTMNF_MAX_FL" "20"
    SYSTEM_CONSTANT "ASMOD_MINTMNF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_MO2INDVOL_MAX_FL" "5"
    SYSTEM_CONSTANT "ASMOD_MO2INDVOL_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_MO2INTMNFMIN_MAX_FL" "3"
    SYSTEM_CONSTANT "ASMOD_MO2INTMNF_MAX_FL" "5"
    SYSTEM_CONSTANT "ASMOD_MO2INTMNF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_MPTCALPWR_NRM" "100"
    SYSTEM_CONSTANT "ASMOD_NDELAY_RES" "1875000"
    SYSTEM_CONSTANT "ASMOD_NENGIN_MAX" "4000"
    SYSTEM_CONSTANT "ASMOD_NENGIN_MIN" "800"
    SYSTEM_CONSTANT "ASMOD_NENG_MAX_FL" "6000"
    SYSTEM_CONSTANT "ASMOD_NENG_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_NMAXEXODNOX_MAX" "8000"
    SYSTEM_CONSTANT "ASMOD_NMAXEXODNOX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NMAXEXODSOX_MAX" "8000"
    SYSTEM_CONSTANT "ASMOD_NMAXEXODSOX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NRMSECHTCAPFINE_NRM" "100"
    SYSTEM_CONSTANT "ASMOD_NRMSECHTCAP_NRM" "100000"
    SYSTEM_CONSTANT "ASMOD_NRMSECKG2GMAMPT_NRM" "1000000"
    SYSTEM_CONSTANT "ASMOD_NRMSECPWREGY_NRM" "1000"
    SYSTEM_CONSTANT "ASMOD_NTHRESDWN_MAX" "900"
    SYSTEM_CONSTANT "ASMOD_NTHRESDWN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NTRBCHRED_MAPX" "16"
    SYSTEM_CONSTANT "ASMOD_NTRBCHRED_MAPY" "16"
    SYSTEM_CONSTANT "ASMOD_NTRBCHRED_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_NTRBCHRED_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_NTRBCH_MAX" "300000"
    SYSTEM_CONSTANT "ASMOD_NTRBCH_MAX_FL" "300000"
    SYSTEM_CONSTANT "ASMOD_NTRBCH_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NTRBCH_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_NTRBNRED_MAX_FL" "300000"
    SYSTEM_CONSTANT "ASMOD_NTRBNRED_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_NUMAIRTEMPCATMOD_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMAIRTEMPCATMOD_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMBNK_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMBNK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKMAX_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKMAX_MIN" "1"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKMAX_SY" "2"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKNSC1_SY" "0"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKNSC2_SY" "0"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKNSCTOT_SY" "0"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKSPECCRVIN_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_NUMBRICKSPECCRVIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMCATOUT_SY" "4"
    SYSTEM_CONSTANT "ASMOD_NUMCATREFBRICK_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMCATREFBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMCATSPECCRVIN_MAX" "0"
    SYSTEM_CONSTANT "ASMOD_NUMCATSPECCRVIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMCAT_SY" "1"
    SYSTEM_CONSTANT "ASMOD_NUMCLNTTEMP_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMCLNTTEMP_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMENGTEMPNOXCORPFLT_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_NUMENGTEMPNOXCORPFLT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMENGTEMPNOXCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMENGTEMPNOXCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMEOMCOEMI_SY" "3"
    SYSTEM_CONSTANT "ASMOD_NUMEOMNOXEMI_SY" "3"
    SYSTEM_CONSTANT "ASMOD_NUMEOMSOTEMI_SY" "3"
    SYSTEM_CONSTANT "ASMOD_NUMEXHMNFLP_MAX" "7"
    SYSTEM_CONSTANT "ASMOD_NUMEXHMNFLP_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMFLDTOT_SY" "0"
    SYSTEM_CONSTANT "ASMOD_NUMNSC_CA_X" "2"
    SYSTEM_CONSTANT "ASMOD_NUMNSC_SY" "0"
    SYSTEM_CONSTANT "ASMOD_NUMOPMODEMSK_SY" "1"
    SYSTEM_CONSTANT "ASMOD_NUMOXICAT_MAX" "0"
    SYSTEM_CONSTANT "ASMOD_NUMOXICAT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMPIPECATDS_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMPIPECATDS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMPIPECATUS_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMPIPECATUS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMPIPES_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMPIPES_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSELNSCBRICKDS_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_NUMSELNSCBRICKDS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSELNSCCATOUTSIM_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_NUMSELNSCCATOUTSIM_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSELNSCSENSOUT_MAX" "7"
    SYSTEM_CONSTANT "ASMOD_NUMSELNSCSENSOUT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPNSCDS_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPNSCDS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPOUTBRICK_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPOUTBRICK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPOUTSENS_MAX" "7"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPOUTSENS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPOUTSIM_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_NUMSELTEMPOUTSIM_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSOTEOMPFLTRGN_MAX" "4"
    SYSTEM_CONSTANT "ASMOD_NUMSOTEOMPFLTRGN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSOTLAMCOREGROFF_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMSOTLAMCOREGROFF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMSOTLAMCOR_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_NUMSOTLAMCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMTEMPOXICATDS_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_NUMTEMPOXICATDS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMTEMPOXICATSURF_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_NUMTEMPOXICATSURF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUMTEMPSENSBRICKUS_MAX" "7"
    SYSTEM_CONSTANT "ASMOD_NUMTEMPSENSBRICKUS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUPIPEENVSLW_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_NUPIPEENV_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_NUPIPEENV_MAX" "5309"
    SYSTEM_CONSTANT "ASMOD_NUPIPEENV_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_NUPIPESLW_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_NUPIPE_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_NUPIPE_MAX" "1130"
    SYSTEM_CONSTANT "ASMOD_NUPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_O2MPTKGGMHR2SEC_NRM" "180"
    SYSTEM_CONSTANT "ASMOD_O2MPTLOINJMPT_NRM" "20"
    SYSTEM_CONSTANT "ASMOD_O2_AMPT_NRM" "20000"
    SYSTEM_CONSTANT "ASMOD_ONE_R32" "1"
    SYSTEM_CONSTANT "ASMOD_PCMPRUS_MAX_FL" "1200"
    SYSTEM_CONSTANT "ASMOD_PCMPRUS_MIN_FL" "700"
    SYSTEM_CONSTANT "ASMOD_PCMPR_MAX_FL" "4000"
    SYSTEM_CONSTANT "ASMOD_PCMPR_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PDIFFPIPE_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_PDIFFPIPE_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_PDIFFPIPE_MAX" "400"
    SYSTEM_CONSTANT "ASMOD_PDIFFPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_PEGPRESPIPE_MAX" "3000"
    SYSTEM_CONSTANT "ASMOD_PEGPRESPIPE_MIN" "1000"
    SYSTEM_CONSTANT "ASMOD_PEGRDS_MAX_FL" "6000"
    SYSTEM_CONSTANT "ASMOD_PEGRDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PEGRLPDS_MAX_FL" "6000"
    SYSTEM_CONSTANT "ASMOD_PEGRLPDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PEXHMNFLP_MAX_FL" "4000"
    SYSTEM_CONSTANT "ASMOD_PEXHMNFLP_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PEXHMNF_MAX_FL" "6000"
    SYSTEM_CONSTANT "ASMOD_PEXHMNF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PHC" "3"
    SYSTEM_CONSTANT "ASMOD_PHIDIFFSOIREF_MAX" "20"
    SYSTEM_CONSTANT "ASMOD_PHIDIFFSOIREF_MIN" "-20"
    SYSTEM_CONSTANT "ASMOD_PHISOIREF_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_PHISOIREF_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_PHISOIREF_MAX" "40"
    SYSTEM_CONSTANT "ASMOD_PHISOIREF_MIN" "-20"
    SYSTEM_CONSTANT "ASMOD_PINDVOL_MAX" "4000"
    SYSTEM_CONSTANT "ASMOD_PINDVOL_MAX_FL" "4000"
    SYSTEM_CONSTANT "ASMOD_PINDVOL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_PINDVOL_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PINIT_MAX" "1100"
    SYSTEM_CONSTANT "ASMOD_PINIT_MIN" "900"
    SYSTEM_CONSTANT "ASMOD_PINTMNFFLT_MAX" "4000"
    SYSTEM_CONSTANT "ASMOD_PINTMNFFLT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_PINTMNFMIN_MAX_FL" "1000"
    SYSTEM_CONSTANT "ASMOD_PINTMNF_MAX_FL" "4000"
    SYSTEM_CONSTANT "ASMOD_PINTMNF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PLSEGRCLG_MAX_FL" "1000"
    SYSTEM_CONSTANT "ASMOD_PLSEGRCLG_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PRESEXHMNFPT1_MAX_FL" "1"
    SYSTEM_CONSTANT "ASMOD_PRESEXHMNFPT1_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PTRBNDSREF_MAX_FL" "6000"
    SYSTEM_CONSTANT "ASMOD_PTRBNDSREF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_PWRHIGHQ1_NRM" "10"
    SYSTEM_CONSTANT "ASMOD_PWRHTFLW_NRM" "20"
    SYSTEM_CONSTANT "ASMOD_QBRN_MAX" "150"
    SYSTEM_CONSTANT "ASMOD_QBRN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_QLMBD" "100"
    SYSTEM_CONSTANT "ASMOD_QMAXEXODNOX_MAX" "327.67"
    SYSTEM_CONSTANT "ASMOD_QMAXEXODNOX_MIN" "-327.68"
    SYSTEM_CONSTANT "ASMOD_QMAXEXODSOX_MAX" "327.67"
    SYSTEM_CONSTANT "ASMOD_QMAXEXODSOX_MIN" "-327.68"
    SYSTEM_CONSTANT "ASMOD_QPRESPIPE_MAX" "50"
    SYSTEM_CONSTANT "ASMOD_QSETUNBAL_MAX" "327.67"
    SYSTEM_CONSTANT "ASMOD_QSETUNBAL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_QSWTOUTOBSVRMAX_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_QSWTOUTOBSVRMIN_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_RARPIPE_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_RARPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RASHEG_RES" "500"
    SYSTEM_CONSTANT "ASMOD_RASHEXHGS_RES" "10000"
    SYSTEM_CONSTANT "ASMOD_RBPALIN_CURX" "6"
    SYSTEM_CONSTANT "ASMOD_RBPALIN_CUR_X" "6"
    SYSTEM_CONSTANT "ASMOD_RCOEXHGS_RES" "500000"
    SYSTEM_CONSTANT "ASMOD_RECBLIN_CUR_X" "6"
    SYSTEM_CONSTANT "ASMOD_RECBLPLIN_CUR_X" "6"
    SYSTEM_CONSTANT "ASMOD_REGRAIRDVTCORACTV_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_REGRAIRDVTCORACTV_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_REGRDVTWGHCRVIN_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_REGRDVTWGHCRVIN_MIN" "-0.5"
    SYSTEM_CONSTANT "ASMOD_REGRLAMCORMAX" "100"
    SYSTEM_CONSTANT "ASMOD_REGRLAMCORMAX_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_REGRLAMCORMIN" "0"
    SYSTEM_CONSTANT "ASMOD_REGRLAMCORMIN_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_REGRLAM_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_REGRLAM_MIN" "-5"
    SYSTEM_CONSTANT "ASMOD_REGRLIN_CURX" "6"
    SYSTEM_CONSTANT "ASMOD_REGRLIN_CUR_X" "6"
    SYSTEM_CONSTANT "ASMOD_REGRMAX_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_REGRMAX_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_REGRMIN_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_REGRMIN_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_REGRSET_MAP_X" "16"
    SYSTEM_CONSTANT "ASMOD_REGRSET_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_REGR_LIMMAX" "100"
    SYSTEM_CONSTANT "ASMOD_REGR_LIMMIN" "0"
    SYSTEM_CONSTANT "ASMOD_REGR_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_REGR_MAX_FL" "100"
    SYSTEM_CONSTANT "ASMOD_REGR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_REGR_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_REGR_ONE" "1"
    SYSTEM_CONSTANT "ASMOD_REPIPEENV_MAX" "3750000"
    SYSTEM_CONSTANT "ASMOD_REPIPEENV_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_REPIPE_MAX" "800000"
    SYSTEM_CONSTANT "ASMOD_REPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RFUELBURNED_RES" "100"
    SYSTEM_CONSTANT "ASMOD_RGN" "4"
    SYSTEM_CONSTANT "ASMOD_RHOFL" "1"
    SYSTEM_CONSTANT "ASMOD_RHONSC_MAX" "3200"
    SYSTEM_CONSTANT "ASMOD_RHONSC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RHYSTHRESBPA_CURX" "6"
    SYSTEM_CONSTANT "ASMOD_RLAMRECEXHMNFDD_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_RLAMRECEXHMNFDD_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RLAMRECINTMNFDS_MAX_FL" "2"
    SYSTEM_CONSTANT "ASMOD_RLAMRECINTMNFDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_RLAMRECREFBAS_MAP_X" "14"
    SYSTEM_CONSTANT "ASMOD_RLAMRECREFBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "ASMOD_RLAMRECREFBAS_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_RLAMRECREFBAS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RLAMRECREFMIN" "0"
    SYSTEM_CONSTANT "ASMOD_RLAMRECREFMIN_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_RLMBDREC" "1450"
    SYSTEM_CONSTANT "ASMOD_RM" "2"
    SYSTEM_CONSTANT "ASMOD_RMDNOXEXO_SY" "2"
    SYSTEM_CONSTANT "ASMOD_RMDSOXEXO_SY" "0"
    SYSTEM_CONSTANT "ASMOD_RMSFLWREF_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_RMSFLWREF_MIN" "-1"
    SYSTEM_CONSTANT "ASMOD_RNOXENGCHCORCRVIN_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_RNOXENGCHCORCRVIN_MIN" "-1"
    SYSTEM_CONSTANT "ASMOD_RNOXEXHGS_RES" "10000000"
    SYSTEM_CONSTANT "ASMOD_RO2EXHGS_RES" "10000"
    SYSTEM_CONSTANT "ASMOD_RO2_MAX" "0.2315"
    SYSTEM_CONSTANT "ASMOD_RO2_MAX_FL" "0.2315"
    SYSTEM_CONSTANT "ASMOD_RO2_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RO2_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_RPRESCMPR_MAX" "3"
    SYSTEM_CONSTANT "ASMOD_RPRESCMPR_MAX_FL" "3"
    SYSTEM_CONSTANT "ASMOD_RPRESCMPR_MIN" "0.5"
    SYSTEM_CONSTANT "ASMOD_RPRESCMPR_MIN_FL" "0.5"
    SYSTEM_CONSTANT "ASMOD_RPRESENGREF_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_RPRESENGREF_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_RPRESTRBN_MAX_FL" "5"
    SYSTEM_CONSTANT "ASMOD_RPRESTRBN_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_RRELPOS_MAX_FL" "100"
    SYSTEM_CONSTANT "ASMOD_RRELPOS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_RSOTEXHGS_RES" "10000"
    SYSTEM_CONSTANT "ASMOD_RSOTLAMCORCRVIN_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_RSOTLAMCORCRVIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RSOTRATEGRCORCRVIN_MAX" "0.8"
    SYSTEM_CONSTANT "ASMOD_RSOTRATEGRCORCRVIN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RSOXEXHGS_RES" "100000"
    SYSTEM_CONSTANT "ASMOD_RSOXFL_MAX" "0.000118"
    SYSTEM_CONSTANT "ASMOD_RSOXFL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RTEMPADBT_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_RTEMPADBT_MAX" "1.4"
    SYSTEM_CONSTANT "ASMOD_RTEMPADBT_MIN" "1"
    SYSTEM_CONSTANT "ASMOD_RTEMPCLNT_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_RTEMPCLNT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RTEMPDIFFTRBNADBT_CURX" "8"
    SYSTEM_CONSTANT "ASMOD_RTEMPDIFFTRBNADBT_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_RTEMPDIFFTRBNADBT_MAX_FL" "1"
    SYSTEM_CONSTANT "ASMOD_RTEMPDIFFTRBNADBT_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_RTIME_MAX" "8"
    SYSTEM_CONSTANT "ASMOD_RTIME_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RTVALIN_CUR_X" "6"
    SYSTEM_CONSTANT "ASMOD_RVOLCOLEAN_MAX" "0.06554"
    SYSTEM_CONSTANT "ASMOD_RVOLCOLEAN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RVOLO2LEAN_MAX" "65.534"
    SYSTEM_CONSTANT "ASMOD_RVOLO2LEAN_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_RVSALIN_CUR_X" "6"
    SYSTEM_CONSTANT "ASMOD_R_STOICH" "1450"
    SYSTEM_CONSTANT "ASMOD_SEC2HUNDREDHRS_RES" "36000000"
    SYSTEM_CONSTANT "ASMOD_SECTO100HRS_RES" "360000"
    SYSTEM_CONSTANT "ASMOD_SOXFL_RES" "29492025.7767217"
    SYSTEM_CONSTANT "ASMOD_SPECHEAT_FACT" "250"
    SYSTEM_CONSTANT "ASMOD_SPECHT_CAPFINEMS_NRM" "1"
    SYSTEM_CONSTANT "ASMOD_SPECHT_CAPFINE_NRM" "1"
    SYSTEM_CONSTANT "ASMOD_SPECHT_CAPMS_NRM" "1000"
    SYSTEM_CONSTANT "ASMOD_SPECHT_CAP_NRM" "1000"
    SYSTEM_CONSTANT "ASMOD_SPECHT_HR2SECCAPFINE_NRM" "36"
    SYSTEM_CONSTANT "ASMOD_STAIRCTLBITMSK_MAX" "4294967295"
    SYSTEM_CONSTANT "ASMOD_STAIRCTLBITMSK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_STMSK_UINT32_MAX" "4294967295"
    SYSTEM_CONSTANT "ASMOD_STMSK_UINT32_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_STOPMODEMSK_CAX" "1"
    SYSTEM_CONSTANT "ASMOD_STOPMODEMSK_MAX" "4294967295"
    SYSTEM_CONSTANT "ASMOD_STOPMODEMSK_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTCALCQNTINJCMB_MAX" "3"
    SYSTEM_CONSTANT "ASMOD_SWTCALCQNTINJCMB_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTENGSPDPT1_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTENGSPDPT1_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTEXOBRICKCALCOFF_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTEXOBRICKCALCOFF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTFACHCCNVOXIC_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTFACHCCNVOXIC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTFLMSFLWOXIC_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_SWTFLMSFLWOXIC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTLAMDIFFNSCCORON_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTLAMDIFFNSCCORON_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTMFLINTMNFDSFLT_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTMFLINTMNFDSFLT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTNOXMSFLWRM_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTNOXMSFLWRM_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTOFFINDVOL_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTOFFINDVOL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTPFLTTEMPMODOFF_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTPFLTTEMPMODOFF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTPRESMIDPFLT_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_SWTPRESMIDPFLT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTRATNOXTEMPCAT_CAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTSELMAXEXOCAT_CAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTSELMAXEXOCAT_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_SWTSELMAXEXOCAT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTSELNUMBRICKUS_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_SWTSELNUMBRICKUS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTSELTEMPBRICKUS_CAX" "2"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPCATMODOFF_CAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPCATMODOFF_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPCATMODOFF_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPCATOUT_CAX" "4"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPCATOUT_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPCATOUT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPEXHMNFCORON_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPEXHMNFCORON_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPNSCFLD_CAX" "0"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPNSCFLD_MAX" "2"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPNSCFLD_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPTRBNCORON_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_SWTTEMPTRBNCORON_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TBRICKDSDFL_CAX" "2"
    SYSTEM_CONSTANT "ASMOD_TBRICKDSDFL_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TBRICKDSDFL_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TCACDS_MAX" "400"
    SYSTEM_CONSTANT "ASMOD_TCACDS_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_TCATBRICK_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TCATBRICK_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TCLNT_MAX" "150"
    SYSTEM_CONSTANT "ASMOD_TCLNT_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_TCMPRUSREF_MAX_FL" "200"
    SYSTEM_CONSTANT "ASMOD_TCMPRUSREF_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TCMPRUS_MAX_FL" "150"
    SYSTEM_CONSTANT "ASMOD_TCMPRUS_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TDIFFEGRCLG_MAX_FL" "800"
    SYSTEM_CONSTANT "ASMOD_TDIFFEGRCLG_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_TDIFFEGRLP_MAX_FL" "576"
    SYSTEM_CONSTANT "ASMOD_TDIFFEGRLP_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_TDIFFENGBAS_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_TDIFFENGBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_TDIFFENGBAS_MAX" "600"
    SYSTEM_CONSTANT "ASMOD_TDIFFENGBAS_MIN" "-600"
    SYSTEM_CONSTANT "ASMOD_TDIFFENGREF_MAX" "120"
    SYSTEM_CONSTANT "ASMOD_TDIFFENGREF_MIN" "-80"
    SYSTEM_CONSTANT "ASMOD_TEFFLEANEXOTEMP_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TEFFLEANEXOTEMP_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TEGBRICK_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TEGBRICK_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TEGENGTEMPCOR_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_TEGENGTEMPCOR_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_TEGENGTEMPCOR_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TEGNSCSRC_MAX" "1500"
    SYSTEM_CONSTANT "ASMOD_TEGNSCSRC_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TEGPRESPIPE_MAX" "800"
    SYSTEM_CONSTANT "ASMOD_TEGPRESPIPE_MIN" "-40"
    SYSTEM_CONSTANT "ASMOD_TEGRDSMIN_MAX" "300"
    SYSTEM_CONSTANT "ASMOD_TEGRDSMIN_MAX_FL" "300"
    SYSTEM_CONSTANT "ASMOD_TEGRDS_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TEGRDS_MAX_FL" "1000"
    SYSTEM_CONSTANT "ASMOD_TEGRDS_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_TEGRDS_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TEGRLPDS1_MAX_FL" "1000"
    SYSTEM_CONSTANT "ASMOD_TEGRLPDS1_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TEGRLPDS_MAX_FL" "300"
    SYSTEM_CONSTANT "ASMOD_TEGRLPDS_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TEMP1" "1000"
    SYSTEM_CONSTANT "ASMOD_TEMPCELS_FINE2NRM" "100"
    SYSTEM_CONSTANT "ASMOD_TEMPINTMNFDSPT1_MAX_FL" "0.5"
    SYSTEM_CONSTANT "ASMOD_TEMPINTMNFDSPT1_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_TEMPKS" "12.8"
    SYSTEM_CONSTANT "ASMOD_TEMPNULL_NORM" "-819.42"
    SYSTEM_CONSTANT "ASMOD_TEMPOXICI_KI_MAX" "4"
    SYSTEM_CONSTANT "ASMOD_TEMPOXICI_KI_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTDT1_KD_MAX" "50"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTDT1_KD_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTDT1_TI_MAX" "15"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTDT1_TI_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTI_KINEG_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTI_KINEG_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTI_KIPOS_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTI_KIPOS_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTI_KI_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_TEMPPFLTI_KI_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TEMPPIPEI_KI_MAX" "4"
    SYSTEM_CONSTANT "ASMOD_TEMPPIPEI_KI_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TENGREF_MAX" "150"
    SYSTEM_CONSTANT "ASMOD_TENGREF_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_TEXHMNFDSREF_MAX_FL" "1000"
    SYSTEM_CONSTANT "ASMOD_TEXHMNFDSREF_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TEXHMNFDS_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TEXHMNFDS_MAX_FL" "1000"
    SYSTEM_CONSTANT "ASMOD_TEXHMNFDS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TEXHMNFDS_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_TFLD_MAX" "3000"
    SYSTEM_CONSTANT "ASMOD_TFLD_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TICALCINITEMPON_MAX" "120"
    SYSTEM_CONSTANT "ASMOD_TICALCINITEMPON_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TICLGOFS_MAX" "21474836.47"
    SYSTEM_CONSTANT "ASMOD_TICLGOFS_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TIDT1_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_TIDT1_MIN" "0.05"
    SYSTEM_CONSTANT "ASMOD_TIENGON_MAX" "8000"
    SYSTEM_CONSTANT "ASMOD_TIENGON_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TIENGSPDPT1DWN_MAX" "0.5"
    SYSTEM_CONSTANT "ASMOD_TIENGSPDPT1DWN_MIN" "5e-006"
    SYSTEM_CONSTANT "ASMOD_TIENGSPDPT1UP_MAX" "0.5"
    SYSTEM_CONSTANT "ASMOD_TIENGSPDPT1UP_MIN" "5e-006"
    SYSTEM_CONSTANT "ASMOD_TIEXHGSDELPFLT_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_TIEXHGSDELPFLT_MAX" "15"
    SYSTEM_CONSTANT "ASMOD_TIEXHGSDELPFLT_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TIHALVALCAT_MAX" "21474836.47"
    SYSTEM_CONSTANT "ASMOD_TIHALVALCAT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TIHAVALCLNT_MAX" "21474836.47"
    SYSTEM_CONSTANT "ASMOD_TIHAVALCLNT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TIHAVALNSC_MAX" "40000000"
    SYSTEM_CONSTANT "ASMOD_TIHAVALNSC_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TIHAVALPIPE_MAX" "21474836.47"
    SYSTEM_CONSTANT "ASMOD_TIHAVALPIPE_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TIHTTRANSDT1_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_TIHTTRANSDT1_MAX" "15"
    SYSTEM_CONSTANT "ASMOD_TIHTTRANSDT1_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TILAMRECSTATPT1_MAX" "10"
    SYSTEM_CONSTANT "ASMOD_TILAMRECSTATPT1_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TILAMSENSDDT_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_TILAMSENSDDT_MAX" "0.32"
    SYSTEM_CONSTANT "ASMOD_TILAMSENSDDT_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TILAMSENSPT1_CUR_X" "8"
    SYSTEM_CONSTANT "ASMOD_TILAMSENSPT1_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_TILAMSENSPT1_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TIMEDELAY_S_MIN" "5e-006"
    SYSTEM_CONSTANT "ASMOD_TINDAIRREF_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_TINDAIRREF_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_TINDMNFDSDIFF_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_TINDMNFDSDIFF_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TINIT_MAX" "90"
    SYSTEM_CONSTANT "ASMOD_TINIT_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TINI_MAX" "90"
    SYSTEM_CONSTANT "ASMOD_TINI_MIN" "-40"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSEGRREF_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSEGRREF_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSEGRREF_MAX" "400"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSEGRREF_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSREF_MAP_X" "10"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSREF_MAP_Y" "10"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSREF_MAX" "100"
    SYSTEM_CONSTANT "ASMOD_TINTMNFDSREF_MIN" "-50"
    SYSTEM_CONSTANT "ASMOD_TINTMNF_MAX_FL" "400"
    SYSTEM_CONSTANT "ASMOD_TINTMNF_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TIPFLTPT1_MAX" "15"
    SYSTEM_CONSTANT "ASMOD_TIPFLTPT1_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TIPRESINTMNFPT1_CUR_X" "4"
    SYSTEM_CONSTANT "ASMOD_TIPRESINTMNFPT1_MAX_FL" "0.5"
    SYSTEM_CONSTANT "ASMOD_TIPRESINTMNFPT1_MIN_FL" "0.001"
    SYSTEM_CONSTANT "ASMOD_TIPT1_MAX" "5"
    SYSTEM_CONSTANT "ASMOD_TIPT1_MIN" "0.05"
    SYSTEM_CONSTANT "ASMOD_TIRELPOSPT1_MAX" "1"
    SYSTEM_CONSTANT "ASMOD_TIRELPOSPT1_MIN" "0.01"
    SYSTEM_CONSTANT "ASMOD_TIRELPOS_MAX" "0.5"
    SYSTEM_CONSTANT "ASMOD_TIRELPOS_MIN" "5e-006"
    SYSTEM_CONSTANT "ASMOD_TISTPDELVAL_CURX" "10"
    SYSTEM_CONSTANT "ASMOD_TISTPDELVAL_CUR_X" "10"
    SYSTEM_CONSTANT "ASMOD_TISTPDELVAL_MAX" "655"
    SYSTEM_CONSTANT "ASMOD_TISTPDELVAL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TISWTSOTRMDEL_MAX" "120"
    SYSTEM_CONSTANT "ASMOD_TISWTSOTRMDEL_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TITEMPEGRDSFWDPT1_MAX" "0.5"
    SYSTEM_CONSTANT "ASMOD_TITEMPEGRDSPT1_MAX" "0.5"
    SYSTEM_CONSTANT "ASMOD_TITRBNPT1_MAX" "4000"
    SYSTEM_CONSTANT "ASMOD_TITRBNPT1_MIN" "0.001"
    SYSTEM_CONSTANT "ASMOD_TLEANNOXTEMPEG_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TLEANNOXTEMPEG_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TLEANNOXTEMPENG_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TLEANNOXTEMPENG_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TMIXPNTEG_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TMIXPNTEG_MAX_FL" "1000"
    SYSTEM_CONSTANT "ASMOD_TMIXPNTEG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TMIXPNTEG_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_TNSCEXOINCR_MAP_X" "8"
    SYSTEM_CONSTANT "ASMOD_TNSCEXOINCR_MAP_Y" "8"
    SYSTEM_CONSTANT "ASMOD_TNSCSPCHTBRICK_MAX" "1500"
    SYSTEM_CONSTANT "ASMOD_TNSCSPCHTBRICK_MIN" "-100"
    SYSTEM_CONSTANT "ASMOD_TOXICDFL_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TOXICDFL_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TOXICUS_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TOXICUS_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TPARNSC_AXISX" "10"
    SYSTEM_CONSTANT "ASMOD_TPARNSC_AXIS_X" "10"
    SYSTEM_CONSTANT "ASMOD_TPFLTDFL_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TPFLTDFL_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TPFLTDIFFCORR_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TPFLTDIFFCORR_MIN" "500"
    SYSTEM_CONSTANT "ASMOD_TPFLTUS_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TPFLTUS_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TPIPEDFL_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TPIPEDFL_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TRQINRSET_MAX" "35"
    SYSTEM_CONSTANT "ASMOD_TRQINRSET_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_TSTRTDFL_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TSTRTDFL_MIN" "-40"
    SYSTEM_CONSTANT "ASMOD_TTRBNDDRAWDFL_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TTRBNDDRAWDFL_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TTRBNDS_MAX_FL" "500"
    SYSTEM_CONSTANT "ASMOD_TTRBNDS_MIN_FL" "-50"
    SYSTEM_CONSTANT "ASMOD_TWALLPIPEDFL_MAX" "1000"
    SYSTEM_CONSTANT "ASMOD_TWALLPIPEDFL_MIN" "-30"
    SYSTEM_CONSTANT "ASMOD_TWO_R32" "2"
    SYSTEM_CONSTANT "ASMOD_VEGNSCBRICK_MAX" "400"
    SYSTEM_CONSTANT "ASMOD_VEGNSCBRICK_MIN" "5"
    SYSTEM_CONSTANT "ASMOD_VEGNSC_CONST" "1000"
    SYSTEM_CONSTANT "ASMOD_VEHV_MAX" "200"
    SYSTEM_CONSTANT "ASMOD_VEHV_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_VOLENG_MAX" "20"
    SYSTEM_CONSTANT "ASMOD_VOLENG_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_VOLEXHMNFLP_MAX_FL" "50"
    SYSTEM_CONSTANT "ASMOD_VOLEXHMNFLP_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_VOLINDVOL_MAX_FL" "50"
    SYSTEM_CONSTANT "ASMOD_VOLINDVOL_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_VOLINTMNF_MAX_FL" "5"
    SYSTEM_CONSTANT "ASMOD_VOLINTMNF_MIN_FL" "0"
    SYSTEM_CONSTANT "ASMOD_VOLNSCBRICK_MAX" "0.01"
    SYSTEM_CONSTANT "ASMOD_VOLNSCBRICK_MIN" "0.0001"
    SYSTEM_CONSTANT "ASMOD_VOL_NORM" "666.666666666667"
    SYSTEM_CONSTANT "ASMOD_VRECOR_MAX" "183"
    SYSTEM_CONSTANT "ASMOD_VRECOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_VSCDYNOFS_MAX" "0.02"
    SYSTEM_CONSTANT "ASMOD_VSCDYNOFS_MIN" "-0.03"
    SYSTEM_CONSTANT "ASMOD_VSCDYN_RES" "12207.03125"
    SYSTEM_CONSTANT "ASMOD_VSCKINOFS_MAX" "-7e-006"
    SYSTEM_CONSTANT "ASMOD_VSCKINOFS_MIN" "-6e-005"
    SYSTEM_CONSTANT "ASMOD_VSCKIN_RES" "1000"
    SYSTEM_CONSTANT "ASMOD_VVELDPNCOR_MAX" "327.67"
    SYSTEM_CONSTANT "ASMOD_VVELDPNCOR_MIN" "0"
    SYSTEM_CONSTANT "ASMOD_WOXICO_CURX" "11"
    SYSTEM_CONSTANT "ASMOD_WOXICO_CUR_X" "11"
    SYSTEM_CONSTANT "ASMOD_WOXICO_MAX" "300000"
    SYSTEM_CONSTANT "ASMOD_WOXICO_MIN" "200000"
    SYSTEM_CONSTANT "ASMOD_WREACACTV_MAX" "65534"
    SYSTEM_CONSTANT "ASMOD_WREACACTV_MIN" "0"
    SYSTEM_CONSTANT "ASTINTVENG_NO" "0"
    SYSTEM_CONSTANT "ASTINTVENG_SY" "0"
    SYSTEM_CONSTANT "AVPT_RES" "0.1"
    SYSTEM_CONSTANT "AVPT_RES_FL" "0.1"
    SYSTEM_CONSTANT "AVPT_RES_REV" "10"
    SYSTEM_CONSTANT "Avs_NumAdjVal_SY" "11"
    SYSTEM_CONSTANT "BANK1" "0"
    SYSTEM_CONSTANT "BANK1_SY" "0"
    SYSTEM_CONSTANT "BANK2" "1"
    SYSTEM_CONSTANT "BANK2_SY" "1"
    SYSTEM_CONSTANT "BAR01_RSA_RES" "0.1"
    SYSTEM_CONSTANT "BAR01_RSA_RES_REV" "10"
    SYSTEM_CONSTANT "BAR_02_RSA_RES" "0.2"
    SYSTEM_CONSTANT "BATTCD_ULIN_CUR_X" "25"
    SYSTEM_CONSTANT "BATTU_ZERO_VOLT" "0"
    SYSTEM_CONSTANT "BOOT_FSH_SY" "0"
    SYSTEM_CONSTANT "BPACD_DCYCCONV_CUR_X" "25"
    SYSTEM_CONSTANT "BPSCD_PLIN_CUR_X" "25"
    SYSTEM_CONSTANT "CALORIFIC_VALUE" "42.5"
    SYSTEM_CONSTANT "CALORY_RES" "1"
    SYSTEM_CONSTANT "CALORY_RES_REV" "1"
    SYSTEM_CONSTANT "CALVAL_Q0P01_RES" "0.01"
    SYSTEM_CONSTANT "CALVAL_Q0P01_RES_REV" "100"
    SYSTEM_CONSTANT "CAMLIFT_RES_REV" "256"
    SYSTEM_CONSTANT "CAMPAR_A_RES_REV" "1024"
    SYSTEM_CONSTANT "CAMSLP_RES_REV" "1024"
    SYSTEM_CONSTANT "CAP_PA_MAX" "8"
    SYSTEM_CONSTANT "CAP_PA_MIN" "0"
    SYSTEM_CONSTANT "CAP_PA_RES" "0.001"
    SYSTEM_CONSTANT "CAP_PA_ZERO" "0"
    SYSTEM_CONSTANT "CASCD_FACPLAUSHIGH_CUR_X" "12"
    SYSTEM_CONSTANT "CASCD_FACPLAUSLOW_CUR_X" "12"
    SYSTEM_CONSTANT "CASTYP_SY" "0"
    SYSTEM_CONSTANT "CAS_ADAP_SY" "1"
    SYSTEM_CONSTANT "CAS_FAC_ADAP_SY" "1000"
    SYSTEM_CONSTANT "CAS_FAC_PLAUS_SY" "1000"
    SYSTEM_CONSTANT "CAS_MAX" "3"
    SYSTEM_CONSTANT "CAS_MOUNTCHK_SY" "0"
    SYSTEM_CONSTANT "CERADD_TNKLVLSENS_SY" "1"
    SYSTEM_CONSTANT "CHG2W_PA_FAC" "1000"
    SYSTEM_CONSTANT "CHG_PA_MAX" "3000"
    SYSTEM_CONSTANT "CHG_PA_MIN" "-3000"
    SYSTEM_CONSTANT "CHG_PA_RES" "1"
    SYSTEM_CONSTANT "CHG_PA_ZERO" "0"
    SYSTEM_CONSTANT "CHKPNTWORD_NUM" "2"
    SYSTEM_CONSTANT "CLG_TIMAXDYNTST_CUR_X" "10"
    SYSTEM_CONSTANT "CMBCHB_CONST" "1000"
    SYSTEM_CONSTANT "CMBCHB_DISABLED" "0"
    SYSTEM_CONSTANT "CMBCHB_ENABLED" "3"
    SYSTEM_CONSTANT "CMBCHB_NOT_PRESSED" "2"
    SYSTEM_CONSTANT "CMBCHB_PRESSED" "1"
    SYSTEM_CONSTANT "CMBMON_OFS_FLOAT_RES" "0.001"
    SYSTEM_CONSTANT "CMBNOI_FLTLNGTH_FACT" "3"
    SYSTEM_CONSTANT "CMBNOI_NRM_EXP" "10"
    SYSTEM_CONSTANT "CMBNOI_NRM_FACT" "16"
    SYSTEM_CONSTANT "CMBNOI_RES" "0.0009765625"
    SYSTEM_CONSTANT "CMBNOI_RES_REV" "1024"
    SYSTEM_CONSTANT "CMBTYP_DS" "0"
    SYSTEM_CONSTANT "CMBTYP_GS" "1"
    SYSTEM_CONSTANT "CMBTYP_SY" "0"
    SYSTEM_CONSTANT "CnvAngleByNToInjTime" "18310.5468750045"
    SYSTEM_CONSTANT "CNVTCOEFFCATAIR_RES" "0.02"
    SYSTEM_CONSTANT "CNVTCOEFFCATAIR_RES_FL" "0.02"
    SYSTEM_CONSTANT "CNVTCOEFFCATAIR_RES_REV" "50"
    SYSTEM_CONSTANT "CNV_QNT2ANGLE" "219.726562500054"
    SYSTEM_CONSTANT "COEFFA_MAX" "159.9951171875"
    SYSTEM_CONSTANT "COEFFA_MIN" "0"
    SYSTEM_CONSTANT "COEFFA_RES" "0.0048828125"
    SYSTEM_CONSTANT "COENG_STSHOFFIMMO" "7"
    SYSTEM_CONSTANT "COENG_TISOFTSHOFF_CURX" "9"
    SYSTEM_CONSTANT "COEOMSWT_RES" "6.103515625e-008"
    SYSTEM_CONSTANT "COEOMSWT_RES_S16" "6.103515625e-005"
    SYSTEM_CONSTANT "COEOM_AFSQNTNUMMAP_SY" "1"
    SYSTEM_CONSTANT "COEOM_AFSTRQNUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_AIRCTLQNTNUMMAP_SY" "1"
    SYSTEM_CONSTANT "COEOM_AIRCTLTRQNUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_EGRCLGQNTNUMMAP_SY" "2"
    SYSTEM_CONSTANT "COEOM_EGRCLGTRQNUMMAP_SY" "2"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMSWTDES_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMSWTMAX_SY" "12"
    SYSTEM_CONSTANT "COEOM_INJCRVMI1NUMSWTSET_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMSWTDES_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMSWTMAX_SY" "12"
    SYSTEM_CONSTANT "COEOM_INJCRVPII1NUMSWTSET_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMSWTDES_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMSWTMAX_SY" "12"
    SYSTEM_CONSTANT "COEOM_INJCRVPII2NUMSWTSET_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII3NUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII3NUMSWTDES_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPII3NUMSWTMAX_SY" "12"
    SYSTEM_CONSTANT "COEOM_INJCRVPII3NUMSWTSET_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPIIRLSNUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI13NUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMSWTDES_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMSWTMAX_SY" "12"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI1NUMSWTSET_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMSWTDES_SY" "3"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMSWTMAX_SY" "12"
    SYSTEM_CONSTANT "COEOM_INJCRVPOI2NUMSWTSET_SY" "3"
    SYSTEM_CONSTANT "COEOM_MAX_OPMODE_BP" "15"
    SYSTEM_CONSTANT "COEOM_NUMRGNMAX_SY" "7"
    SYSTEM_CONSTANT "COEOM_NUM_MAX_OPMODE" "16"
    SYSTEM_CONSTANT "COEOM_NUM_MAX_STAGE" "11"
    SYSTEM_CONSTANT "COEOM_NUM_OPMODE_REQ" "8"
    SYSTEM_CONSTANT "COEOM_PCRQNTNUMMAP_SY" "1"
    SYSTEM_CONSTANT "COEOM_PCRTRQNUMMAP_SY" "0"
    SYSTEM_CONSTANT "COEOM_POSMCDESEGTNUMMAP_SY" "4"
    SYSTEM_CONSTANT "COEOM_POSMCDESNUMEGT_SY" "4"
    SYSTEM_CONSTANT "COEOM_POSMCDESNUMOPMODE_SY" "6"
    SYSTEM_CONSTANT "COEOM_PSCNUMOPMODE_SY" "8"
    SYSTEM_CONSTANT "COEOM_RAILNUMMAP_SY" "3"
    SYSTEM_CONSTANT "COEOM_RAILNUMSWTDES_SY" "3"
    SYSTEM_CONSTANT "COEOM_RMP_MAX" "1"
    SYSTEM_CONSTANT "COEOM_RMP_MAX_S16" "1"
    SYSTEM_CONSTANT "COEOM_RMP_MIN" "0"
    SYSTEM_CONSTANT "COEOM_RMP_MIN_S16" "0"
    SYSTEM_CONSTANT "COEOM_SWT_FACT" "16384000"
    SYSTEM_CONSTANT "COEOM_SWT_FACT_S16" "16384"
    SYSTEM_CONSTANT "COEOM_SWT_NRM_EXP" "14"
    SYSTEM_CONSTANT "COEOM_TRANS_ARRAY_SIZE" "9"
    SYSTEM_CONSTANT "COEOM_TYP_SY" "1"
    SYSTEM_CONSTANT "COEOM_VSWCTLQNTNUMMAP_SY" "1"
    SYSTEM_CONSTANT "COEOM_VSWCTLTRQNUMMAP_SY" "0"
    SYSTEM_CONSTANT "COETM_CLGDEM_DISBL" "0"
    SYSTEM_CONSTANT "COETM_CLGDEM_ENBL" "1"
    SYSTEM_CONSTANT "COMPACCPED_OFF" "0"
    SYSTEM_CONSTANT "COMPACCPED_ON" "1"
    SYSTEM_CONSTANT "COMPACCPED_SY" "0"
    SYSTEM_CONSTANT "COMPT_RES" "0.05"
    SYSTEM_CONSTANT "CONV_BAR_HPA_RES" "20"
    SYSTEM_CONSTANT "CONV_HR2SEC" "36"
    SYSTEM_CONSTANT "CONV_KD_16_TO_KD_32" "2.00006103701895"
    SYSTEM_CONSTANT "CONV_KG2L" "785.964912280702"
    SYSTEM_CONSTANT "CONV_MGS2KGS" "1000000"
    SYSTEM_CONSTANT "CONV_T1_16_TO_1_T1_32" "28146638.6776064"
    SYSTEM_CONSTANT "COTEMP_RCLGDES_CURX" "5"
    SYSTEM_CONSTANT "COTEMP_RCLGDES_CUR_X" "5"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASENTRQ_MAPX" "2"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASENTRQ_MAPY" "2"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASENTRQ_MAP_X" "10"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASENTRQ_MAP_Y" "10"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASETEMPVEL_MAPX" "2"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASETEMPVEL_MAPY" "2"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASETEMPVEL_MAP_X" "6"
    SYSTEM_CONSTANT "COTEMP_TENGDESBASETEMPVEL_MAP_Y" "8"
    SYSTEM_CONSTANT "COTS_THERMDEM_DISBL" "0"
    SYSTEM_CONSTANT "COTS_THERMDEM_ENBL" "1"
    SYSTEM_CONSTANT "COVEH_TRQLIM_CUR_X" "25"
    SYSTEM_CONSTANT "COVOM_CTLABRT" "3"
    SYSTEM_CONSTANT "COVOM_CTLACTV" "1"
    SYSTEM_CONSTANT "COVOM_CTLCNGMND" "4"
    SYSTEM_CONSTANT "COVOM_CTLFIN" "2"
    SYSTEM_CONSTANT "COVOM_CTLRDY" "0"
    SYSTEM_CONSTANT "COVOM_CTLSFTST" "5"
    SYSTEM_CONSTANT "COVOM_SHTOFF" "239"
    SYSTEM_CONSTANT "COVOM_TRATRGELMDRV" "3"
    SYSTEM_CONSTANT "COVOM_TRATRGELMRDN" "4"
    SYSTEM_CONSTANT "COVOM_TRATRGENGIDL" "1"
    SYSTEM_CONSTANT "COVOM_TRATRGENGRDN" "5"
    SYSTEM_CONSTANT "COVOM_TRATRGERR" "7"
    SYSTEM_CONSTANT "COVOM_TRATRGHYBDRV" "2"
    SYSTEM_CONSTANT "COVOM_TRATRGINI" "0"
    SYSTEM_CONSTANT "CPPFEAT_FACT" "1608.49543863808"
    SYSTEM_CONSTANT "CPP_ANGLE1_POSTTDC" "-150"
    SYSTEM_CONSTANT "CPP_ANGLE2_POSTTDC" "-5"
    SYSTEM_CONSTANT "CPP_ANGLE_MAX" "-179"
    SYSTEM_CONSTANT "CPP_ANGLE_MIN" "180"
    SYSTEM_CONSTANT "CPP_ANGLE_ZERO" "0"
    SYSTEM_CONSTANT "CPP_FACT" "1024"
    SYSTEM_CONSTANT "CPP_FACT1" "16"
    SYSTEM_CONSTANT "CPP_FACT1_EXP" "4"
    SYSTEM_CONSTANT "CPP_FACT_EXP" "10"
    SYSTEM_CONSTANT "CPP_FAC_VOL_CYL_RES" "3.0517578125e-005"
    SYSTEM_CONSTANT "CPP_FAC_VOL_CYL_RES_REV" "32768"
    SYSTEM_CONSTANT "CPP_HTRLSRATE_ANGLE_OFS" "175"
    SYSTEM_CONSTANT "CPP_HTRLS_ANGLE_OFS" "174"
    SYSTEM_CONSTANT "CPP_HT_RLS_OFS" "-6"
    SYSTEM_CONSTANT "CPP_HT_RLS_RATE_FLT_OFS" "-5"
    SYSTEM_CONSTANT "CPP_HT_RLS_RATE_FLT_ORD_MAX" "4"
    SYSTEM_CONSTANT "CPP_HT_RLS_RATE_OFS" "-1"
    SYSTEM_CONSTANT "CPP_MAX_FLT_ORD" "32"
    SYSTEM_CONSTANT "CPP_NUMCYLMAX_SY" "6"
    SYSTEM_CONSTANT "CPP_NUMMAXMEASTST_SY" "0"
    SYSTEM_CONSTANT "CPP_OFS_FACT_RES" "0.00390625"
    SYSTEM_CONSTANT "CPP_OFS_FACT_RES_REV" "256"
    SYSTEM_CONSTANT "CPP_PRESCALC_CUR_SIZE" "33"
    SYSTEM_CONSTANT "CPP_PRESCALC_EXP" "5"
    SYSTEM_CONSTANT "CPP_PRESCALC_EXP1" "7"
    SYSTEM_CONSTANT "CPP_SWTEGRVLVPOS_SY" "0"
    SYSTEM_CONSTANT "CPP_SWTINVSTDIA_SY" "0"
    SYSTEM_CONSTANT "CPP_SWTPINTK_SY" "0"
    SYSTEM_CONSTANT "CPP_SWTTHRVLVPOS_SY" "0"
    SYSTEM_CONSTANT "CPP_SWT_DSPLFUNC_SY" "1"
    SYSTEM_CONSTANT "CRCTL_DVACCG3_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVACCG4_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVACCG5_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVACCG6_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVDECLG3_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVDECLG4_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVDECLG5_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVDECLG6_CUR_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG3_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG3_MAP_Y" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG4_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG4_MAP_Y" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG5_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG5_MAP_Y" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG6_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESABVG6_MAP_Y" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG3_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG3_MAP_Y" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG4_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG4_MAP_Y" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG5_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG5_MAP_Y" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG6_MAP_X" "5"
    SYSTEM_CONSTANT "CRCTL_DVRESBLWG6_MAP_Y" "5"
    SYSTEM_CONSTANT "CRSCD_FACGAPPLAUSHIGH_CUR_X" "10"
    SYSTEM_CONSTANT "CRSCD_FACGAPPLAUSLOW_CUR_X" "10"
    SYSTEM_CONSTANT "CRSCD_FACINCPLAUSHIGH_CUR_X" "10"
    SYSTEM_CONSTANT "CRSCD_FACINCPLAUSLOW_CUR_X" "10"
    SYSTEM_CONSTANT "CRSCD_PHIINCCOR_CUR_X" "12"
    SYSTEM_CONSTANT "CRSSENSTYP_SY" "0"
    SYSTEM_CONSTANT "CRS_TO_CAS" "2"
    SYSTEM_CONSTANT "CSC_SY" "0"
    SYSTEM_CONSTANT "CTL_NEG" "3"
    SYSTEM_CONSTANT "CTL_POS" "2"
    SYSTEM_CONSTANT "CTL_ZFC" "6"
    SYSTEM_CONSTANT "CTSCD_TLIN_CUR_X" "25"
    SYSTEM_CONSTANT "CURR_A_RES" "0.01"
    SYSTEM_CONSTANT "CURR_PA_MAX" "30000"
    SYSTEM_CONSTANT "CURR_PA_MIN" "-30000"
    SYSTEM_CONSTANT "CURR_PA_ZERO" "0"
    SYSTEM_CONSTANT "CURR_RES" "1"
    SYSTEM_CONSTANT "CURR_RMP_RES_SY" "6553.6"
    SYSTEM_CONSTANT "CYLFLTPRM_REC_NRM_EXP" "15"
    SYSTEM_CONSTANT "CYLFLTPRM_REC_RES" "32767"
    SYSTEM_CONSTANT "CYLHTRLSRATE_NRM_EXP" "6"
    SYSTEM_CONSTANT "CYLHTRLSRATE_RES" "0.015625"
    SYSTEM_CONSTANT "CYLHTRLSRATE_RES_REV" "64"
    SYSTEM_CONSTANT "CYLHTRLS_NRM_EXP" "2"
    SYSTEM_CONSTANT "CYLHTRLS_RES" "0.25"
    SYSTEM_CONSTANT "CYLHTRLS_RES_REV" "4"
    SYSTEM_CONSTANT "CYLINDER_VOLUME_RES" "1e-006"
    SYSTEM_CONSTANT "CYLK1_RES" "0.0078125"
    SYSTEM_CONSTANT "CYLK1_RES_REV" "128"
    SYSTEM_CONSTANT "CYLK2_REC_NRM_EXP" "14"
    SYSTEM_CONSTANT "CYLK2_REC_RES" "16384"
    SYSTEM_CONSTANT "CYLPRESVOLT_RES" "0.805860805860806"
    SYSTEM_CONSTANT "CYLPRES_HTRLSRATE_CONV" "256"
    SYSTEM_CONSTANT "CYLPRES_K2_HTRLSRATE_CONV" "4194304"
    SYSTEM_CONSTANT "CYLPRES_NRM_EXP" "7"
    SYSTEM_CONSTANT "CYLPRES_RES" "0.0078125"
    SYSTEM_CONSTANT "CYLPRES_RES_REV" "128"
    SYSTEM_CONSTANT "CYL_FAC_NORM" "33333"
    SYSTEM_CONSTANT "CYL_MAX" "6"
    SYSTEM_CONSTANT "DCSOVRDSDFFTLPRT_SY" "1"
    SYSTEM_CONSTANT "DCSOVRDSENGPRT_SY" "0"
    SYSTEM_CONSTANT "DCSOVRDSTRAPRT_SY" "1"
    SYSTEM_CONSTANT "DCSOVRDSTSCDEC_SY" "1"
    SYSTEM_CONSTANT "DCS_OVRDS_DFFTLPRT" "1"
    SYSTEM_CONSTANT "DCS_OVRDS_ENGPRT" "1"
    SYSTEM_CONSTANT "DCS_OVRDS_TRAPRT" "1"
    SYSTEM_CONSTANT "DCS_OVRDS_TSCDEC" "1"
    SYSTEM_CONSTANT "DDVOL_RES" "10"
    SYSTEM_CONSTANT "DELAY" "5"
    SYSTEM_CONSTANT "DELTA_PRES_FAC" "250000"
    SYSTEM_CONSTANT "DENSFINE_RES" "0.002"
    SYSTEM_CONSTANT "DENSFINE_RES_FL" "0.002"
    SYSTEM_CONSTANT "DENSFINE_RES_REV" "500"
    SYSTEM_CONSTANT "DENSFINE_TEMP2PRES" "5000000"
    SYSTEM_CONSTANT "DENS_RES" "0.1"
    SYSTEM_CONSTANT "DENS_RES_FL" "0.1"
    SYSTEM_CONSTANT "DEVLIB_4WINDIACMPNENA_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_4WINDIA_TYP_CTLLN" "0"
    SYSTEM_CONSTANT "DEVLIB_4WINDIA_TYP_DIGIN" "1"
    SYSTEM_CONSTANT "DEVLIB_4WINDIA_TYP_EXT" "2"
    SYSTEM_CONSTANT "DEVLIB_4WINDIA_TYP_NONE" "3"
    SYSTEM_CONSTANT "DEVLIB_ACTRPRTCMPNENA_SY" "1"
    SYSTEM_CONSTANT "DEVLIB_DBG_SY" "1"
    SYSTEM_CONSTANT "DEVLIB_DIACTLLINECMPNENA_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_HBRGENA_SY" "1"
    SYSTEM_CONSTANT "DEVLIB_PHYSRNGCHK_SY" "0"
    SYSTEM_CONSTANT "DEVLIB_PSOFFOPNLD_SY" "0"
    SYSTEM_CONSTANT "DEWDET_FACCLDSTRTLSU_CUR_X" "4"
    SYSTEM_CONSTANT "DEWDET_HEATFLOW_INTER1_RES" "3600"
    SYSTEM_CONSTANT "DEWDET_HEATFLOW_INTER2_RES" "10000"
    SYSTEM_CONSTANT "DEWDET_INTEGRLS" "0"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT0_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT0_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT0_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT0_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT10_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT10_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT10_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT10_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT11_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT11_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT11_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT11_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT1_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT1_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT1_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT1_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT2_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT2_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT2_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT2_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT3_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT3_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT3_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT3_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT4_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT4_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT4_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT4_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT5_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT5_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT5_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT5_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT6_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT6_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT6_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT6_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT7_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT7_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT7_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT7_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT8_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT8_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT8_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT8_MAP_Y" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT9_MAPX" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT9_MAPY" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT9_MAP_X" "10"
    SYSTEM_CONSTANT "DEWDET_WTHRESLSUAXISPNT9_MAP_Y" "10"
    SYSTEM_CONSTANT "DE_ATSINTVMOD_NOSHOFFBYP" "0"
    SYSTEM_CONSTANT "DE_ATSINTVMOD_SHOFFBYP" "1"
    SYSTEM_CONSTANT "DFES_COMMILDEB_SY" "0"
    SYSTEM_CONSTANT "DFES_EXTDFLT_SY" "0"
    SYSTEM_CONSTANT "DFES_SIMCOND_SY" "1"
    SYSTEM_CONSTANT "DFFTLPRTOVRDSTSCINC_SY" "1"
    SYSTEM_CONSTANT "DFFTLPRT_OVRDS_DCS" "0"
    SYSTEM_CONSTANT "DFFTLPRT_OVRDS_TSCINC" "1"
    SYSTEM_CONSTANT "DIAGAPPLINF_DCALNO" "2"
    SYSTEM_CONSTANT "DIAGAPPLINF_DDIC" "1"
    SYSTEM_CONSTANT "DIAGAPPLINF_DEDNO" "2"
    SYSTEM_CONSTANT "DIAGAPPLINF_DHWNO" "5"
    SYSTEM_CONSTANT "DIAGAPPLINF_DMRP" "5"
    SYSTEM_CONSTANT "DIAGAPPLINF_DOTHSYS" "4"
    SYSTEM_CONSTANT "DIAGAPPLINF_DSUPPITG" "3"
    SYSTEM_CONSTANT "DIAGAPPLINF_DSWNO" "2"
    SYSTEM_CONSTANT "DIAGCOM_BOOTPART_SY" "0"
    SYSTEM_CONSTANT "DIAGCOM_RDPI_SY" "0"
    SYSTEM_CONSTANT "DIAGCOM_RESPONEVT_SY" "0"
    SYSTEM_CONSTANT "DIAGCOM_RINGBUF_SY" "0"
    SYSTEM_CONSTANT "DIFCOEFQ0P0001_INVRESO" "10000"
    SYSTEM_CONSTANT "DIFCOEFQ0P0001_RESO" "0.0001"
    SYSTEM_CONSTANT "DIFCOEF_INVRESO" "1"
    SYSTEM_CONSTANT "DIFCOEF_RESO" "1"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ADCIADC0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_AFSPLOFFSDRFT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_AFSSRC_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_AFSTPER_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_APP1SIGPATH_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_APP2SIGPATH_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ASMODPIPESLW_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ASMODPIPE_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ASMODPRESCALC_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ASMODSTRT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ASMODSWTOFFENG_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ASMODTRBN_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_CIC751DEV1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGNRML2STRT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHCLSEGR_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHCLSTHR_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHCYLOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHETZR_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHFLQNT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHINJVLVOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHLPSYSOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHRPMIN_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGPTHTRQZR_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COENGSOFTSHOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COORDALS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COORDFBC_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COORDTAA_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_COORDZFC_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_CY100DEV1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_DEVLIBACTRPRT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_DEWDETHTGDEL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_DEWDETSTSRVTSTDEM_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ECBVLVFRZVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ECBVLVREPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ECBVLVSS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EGRVLVFRZVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EGRVLVJAMVLV_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EGRVLVREPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EGRVLVSSPMON_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMBCR_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMCASADAPCASI1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMCASDIAG_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMCASOFSDIAGCASI1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMCASOFSERRCASI1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMCASSEGCOR_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMCRSDIAGVEH_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMCRSDIAG_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_EPMOPMODE_INJLOCK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ETCLBCORACTV_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FBC_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FLSYSDENS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FLSYSTNKLOEEP_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FLSYSTNKLOINFO_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FMALAMO2VALID_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FMASWTOFF1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FMASWTOFF3_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FUELTCTS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FUELTFLSYS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FUELTFRZVALB1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FUELTFRZVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FUELTPHYSRNG_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_FUELTREPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_GLB_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_GLWCTL1_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_GLWCTL2_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_GLWCTL3_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_GLWPLGCOD_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_GLWPLGGCUTDIA_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INHIBITALWAYS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INHIBITNEVER_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJUNSTRTPLSBLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVBNK0SHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVCYL0SHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVCYL1SHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVCYL2SHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVCYL3SHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVCYL4SHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVCYL5SHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVPREP_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVPRESMINRUN_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVPRESMINSTRT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_INJVLVPRESMIN_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVACTRTEMPRPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVADJNVCENA_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVDIACYLOKTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVDIATST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVPLAUSCOMPRTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVPLAUSRUNUPTSTACTV_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVPLAUSRUNUPTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_IVPSPLYDCDCOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUADAP0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUCLBSCHED_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUCMPCHK0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUCTL0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUDEWRLS0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUDYNCHK0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUHTCOUP0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUHTRPS0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUIPOPNLDTST0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUISOLCHK0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSULOBATT0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSULSU0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUMON0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUO20_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUO2CLB0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUO2SRC0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUPLAUSCHK0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUPRESCOMP0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUPRESCOMPADAP0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSURI0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSURICLB0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUSHCIR0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_LSUUNVGOPNLDTST0_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_MEUNACTRTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_MEUNFRZI_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_MEUNROT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_MEUNSETPTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_PCVACTRTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_PCVFRZI_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_PCVNOSTRT_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_PCVPWRSTGTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_PCVSETPTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_QWCCTSDEF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_QWCFTSDEF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_QWCOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILCPCTLMEUNMODE_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILCPCTLPCVMODE_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILCTLMODE_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILHPTSTACTV_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILHPTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN0BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN0RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN1BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN1RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN22RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN2BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN2RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN3BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN3RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN4BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUN4RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUNCLSDSHUTOFF_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUNCTLMODE_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILMEUNCTLUPLIM_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV0BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV0RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV1BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV1RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV2BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV2RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV3BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV3RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV4BLK_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCV4RLS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCVCTLMODE_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPCVCTLUPLIM_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPSS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILPSUBSVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILSETPOINTLIM_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILSETPOINTRED_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILSETPOINTTST_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_RAILTNKLO_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_SSTEGRCLRDS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_STAVSCOESLSU_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TAA_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TECUFRZVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TECURPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TEGRCLRDSFRZVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TEGRCLRDSRPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_THRVLVFRZVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_THRVLVOPNLD_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_THRVLVRPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_THRVLVSSPMON_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TRBCHFRZVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TRBCHPMP_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TRBCHRPLVAL_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_TRBCHSS_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ZFCCLBACTV_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ZFCCLDCMBCHAM_SIZE" "4"
    SYSTEM_CONSTANT "DINH_DSQ_FID_ZFCPCLCLBACTV_SIZE" "4"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ADCIADC0_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_AFSPLOFFSDRFT_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_AFSSRC_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_AFSTPER_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_APP1SIGPATH_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_APP2SIGPATH_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ASMODPIPESLW_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ASMODPIPE_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ASMODPRESCALC_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ASMODSTRT_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ASMODSWTOFFENG_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ASMODTRBN_SIZE" "7"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_CIC751DEV1_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGNRML2STRT_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHCLSEGR_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHCLSTHR_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHCYLOFF_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHETZR_SIZE" "21"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHFLQNT_SIZE" "21"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHINJVLVOFF_SIZE" "21"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHLPSYSOFF_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHRPMIN_SIZE" "21"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGPTHTRQZR_SIZE" "21"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COENGSOFTSHOFF_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COORDALS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COORDFBC_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COORDTAA_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_COORDZFC_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_CY100DEV1_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_DEVLIBACTRPRT_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_DEWDETHTGDEL_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_DEWDETSTSRVTSTDEM_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ECBVLVFRZVAL_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ECBVLVREPLVAL_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ECBVLVSS_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EGRVLVFRZVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EGRVLVJAMVLV_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EGRVLVREPLVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EGRVLVSSPMON_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMBCR_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMCASADAPCASI1_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMCASDIAG_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMCASOFSDIAGCASI1_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMCASOFSERRCASI1_SIZE" "7"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMCASSEGCOR_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMCRSDIAGVEH_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMCRSDIAG_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_EPMOPMODE_INJLOCK_SIZE" "7"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ETCLBCORACTV_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FBC_SIZE" "27"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FLSYSDENS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FLSYSTNKLOEEP_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FLSYSTNKLOINFO_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FMALAMO2VALID_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FMASWTOFF1_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FMASWTOFF3_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FUELTCTS_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FUELTFLSYS_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FUELTFRZVALB1_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FUELTFRZVAL_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FUELTPHYSRNG_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_FUELTREPLVAL_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_GLB_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_GLWCTL1_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_GLWCTL2_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_GLWCTL3_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_GLWPLGCOD_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_GLWPLGGCUTDIA_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INHIBITALWAYS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INHIBITNEVER_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJUNSTRTPLSBLK_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVBNK0SHUTOFF_SIZE" "12"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVCYL0SHUTOFF_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVCYL1SHUTOFF_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVCYL2SHUTOFF_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVCYL3SHUTOFF_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVCYL4SHUTOFF_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVCYL5SHUTOFF_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVPREP_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVPRESMINRUN_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVPRESMINSTRT_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_INJVLVPRESMIN_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVACTRTEMPRPLVAL_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVADJNVCENA_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVDIACYLOKTST_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVDIATST_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVPLAUSCOMPRTST_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVPLAUSRUNUPTSTACTV_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVPLAUSRUNUPTST_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_IVPSPLYDCDCOFF_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUADAP0_SIZE" "23"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUCLBSCHED_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUCMPCHK0_SIZE" "22"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUCTL0_SIZE" "12"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUDEWRLS0_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUDYNCHK0_SIZE" "20"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUHTCOUP0_SIZE" "21"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUHTRPS0_SIZE" "7"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUIPOPNLDTST0_SIZE" "23"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUISOLCHK0_SIZE" "20"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSULOBATT0_SIZE" "7"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSULSU0_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUMON0_SIZE" "22"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUO20_SIZE" "18"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUO2CLB0_SIZE" "12"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUO2SRC0_SIZE" "16"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUPLAUSCHK0_SIZE" "25"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUPRESCOMP0_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUPRESCOMPADAP0_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSURI0_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSURICLB0_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUSHCIR0_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_LSUUNVGOPNLDTST0_SIZE" "18"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_MEUNACTRTST_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_MEUNFRZI_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_MEUNROT_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_MEUNSETPTST_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_PCVACTRTST_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_PCVFRZI_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_PCVNOSTRT_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_PCVPWRSTGTST_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_PCVSETPTST_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_QWCCTSDEF_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_QWCFTSDEF_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_QWCOFF_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILCPCTLMEUNMODE_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILCPCTLPCVMODE_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILCTLMODE_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILHPTSTACTV_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILHPTST_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN0BLK_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN0RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN1BLK_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN1RLS_SIZE" "12"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN22RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN2BLK_SIZE" "7"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN2RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN3BLK_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN3RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN4BLK_SIZE" "7"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUN4RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUNCLSDSHUTOFF_SIZE" "14"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUNCTLMODE_SIZE" "13"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILMEUNCTLUPLIM_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV0BLK_SIZE" "14"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV0RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV1BLK_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV1RLS_SIZE" "15"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV2BLK_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV2RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV3BLK_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV3RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV4BLK_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCV4RLS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCVCTLMODE_SIZE" "11"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPCVCTLUPLIM_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPSS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILPSUBSVAL_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILSETPOINTLIM_SIZE" "9"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILSETPOINTRED_SIZE" "8"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILSETPOINTTST_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_RAILTNKLO_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_SSTEGRCLRDS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_STAVSCOESLSU_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TAA_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TECUFRZVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TECURPLVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TEGRCLRDSFRZVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TEGRCLRDSRPLVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_THRVLVFRZVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_THRVLVOPNLD_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_THRVLVRPLVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_THRVLVSSPMON_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TRBCHFRZVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TRBCHPMP_SIZE" "10"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TRBCHRPLVAL_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_TRBCHSS_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ZFCCLBACTV_SIZE" "43"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ZFCCLDCMBCHAM_SIZE" "6"
    SYSTEM_CONSTANT "DINH_SBXCF_FID_ZFCPCLCLBACTV_SIZE" "6"
    SYSTEM_CONSTANT "DIV_INJTIME_US" "2"
    SYSTEM_CONSTANT "DMFL_BRN_RESLO" "13793.1034482759"
    SYSTEM_CONSTANT "DMO2_RESLO" "20000"
    SYSTEM_CONSTANT "DM_AMPTSOX_RES_FL" "0.004"
    SYSTEM_CONSTANT "DM_NOX2SOOT" "15"
    SYSTEM_CONSTANT "DM_NOX_100" "100"
    SYSTEM_CONSTANT "DM_NOX_RES" "0.15"
    SYSTEM_CONSTANT "DM_NOX_RES_100" "15"
    SYSTEM_CONSTANT "DM_NOX_RES_REV" "6.66666666666667"
    SYSTEM_CONSTANT "DM_OILASH_RES" "0.01"
    SYSTEM_CONSTANT "DM_OILASH_RES_REV" "100"
    SYSTEM_CONSTANT "DM_SOOT_MAX" "327"
    SYSTEM_CONSTANT "DM_SOOT_MIN" "0"
    SYSTEM_CONSTANT "DM_SOOT_RES" "0.01"
    SYSTEM_CONSTANT "DM_SOOT_RES_REV" "100"
    SYSTEM_CONSTANT "DM_SOX2_RES_FL" "0.004"
    SYSTEM_CONSTANT "DPDIFFTMP_RES" "100"
    SYSTEM_CONSTANT "DPDIFF_RES" "0.1"
    SYSTEM_CONSTANT "DPRC_100" "100"
    SYSTEM_CONSTANT "DPRC_M_100" "-100"
    SYSTEM_CONSTANT "DPRC_RES_REV" "81.92"
    SYSTEM_CONSTANT "DPRES_RES" "1"
    SYSTEM_CONSTANT "DPRES_RES_REV" "1"
    SYSTEM_CONSTANT "DRLAMREC_RES" "0.01"
    SYSTEM_CONSTANT "DRLMBD_ZERO" "0"
    SYSTEM_CONSTANT "DRV_T15RST_SY" "1"
    SYSTEM_CONSTANT "DSMAUX_TCSORT_SY" "0"
    SYSTEM_CONSTANT "DSM_NUMDFCMAX_SY" "304"
    SYSTEM_CONSTANT "DT1INITI_ZERO_SY" "0"
    SYSTEM_CONSTANT "DT1INITO_ZERO_SY" "0"
    SYSTEM_CONSTANT "DTRQ2RMPTRQ_CNV" "65.536"
    SYSTEM_CONSTANT "DTRQ_MAX" "2000"
    SYSTEM_CONSTANT "DTRQ_MIN" "-2000"
    SYSTEM_CONSTANT "DTRQ_RES" "0.1"
    SYSTEM_CONSTANT "DTRQ_RES_REV" "10"
    SYSTEM_CONSTANT "DTRQ_ZERO" "0"
    SYSTEM_CONSTANT "DTR_LEGIFC_SY" "0"
    SYSTEM_CONSTANT "DTYCYC_SLP_10" "10"
    SYSTEM_CONSTANT "DTYCYC_SLP_MIN" "0"
    SYSTEM_CONSTANT "DTY_CYC_10" "10"
    SYSTEM_CONSTANT "DTY_CYC_100" "100"
    SYSTEM_CONSTANT "DTY_CYC_120" "120"
    SYSTEM_CONSTANT "DTY_CYC_150" "150"
    SYSTEM_CONSTANT "DTY_CYC_20" "20"
    SYSTEM_CONSTANT "DTY_CYC_30" "30"
    SYSTEM_CONSTANT "DTY_CYC_5" "5"
    SYSTEM_CONSTANT "DTY_CYC_50" "50"
    SYSTEM_CONSTANT "DTY_CYC_FAC" "1.95503421309873"
    SYSTEM_CONSTANT "DTY_CYC_MAX" "100"
    SYSTEM_CONSTANT "DTY_CYC_MIN" "0"
    SYSTEM_CONSTANT "DTY_CYC_RES" "0.01"
    SYSTEM_CONSTANT "DTY_CYC_RES_REV" "100"
    SYSTEM_CONSTANT "DT_KELV_RES" "0.1"
    SYSTEM_CONSTANT "DT_KELV_RES_REV" "10"
    SYSTEM_CONSTANT "DVOL_MAX" "3000"
    SYSTEM_CONSTANT "DVOL_MIN" "0"
    SYSTEM_CONSTANT "DVOL_RES" "0.1"
    SYSTEM_CONSTANT "DVOL_RES_FL" "0.1"
    SYSTEM_CONSTANT "DVOL_RES_INV" "10"
    SYSTEM_CONSTANT "DX_WAIT" "2"
    SYSTEM_CONSTANT "DYN_TST_TIME_FACT" "256"
    SYSTEM_CONSTANT "D_FLCONS_RES" "0.01"
    SYSTEM_CONSTANT "EATSCD_TLIN_CUR_X" "25"
    SYSTEM_CONSTANT "ECBVLV_ATSINTVMOD_SY" "0"
    SYSTEM_CONSTANT "ECLTYP_IMPCLTH" "1"
    SYSTEM_CONSTANT "ECLTYP_NOCLTH" "0"
    SYSTEM_CONSTANT "ECLTYP_PROPCLTH" "2"
    SYSTEM_CONSTANT "ECUOFF_TMR_SY" "0"
    SYSTEM_CONSTANT "ECU_GENR_SY" "3"
    SYSTEM_CONSTANT "ECU_TRICORE_SY" "1"
    SYSTEM_CONSTANT "EECR_BLDPRC_SY" "1"
    SYSTEM_CONSTANT "EFFCNY_RES" "0.001"
    SYSTEM_CONSTANT "EFFCNY_RES_REV" "1000"
    SYSTEM_CONSTANT "EFF_GRAD_RES" "0.0001"
    SYSTEM_CONSTANT "EFF_GRAD_RES_REV" "10000"
    SYSTEM_CONSTANT "EGRCD_DCYCEGR_MAP_X" "16"
    SYSTEM_CONSTANT "EGRCD_DCYCEGR_MAP_Y" "16"
    SYSTEM_CONSTANT "EGRCLG_CLGOFF_CUR_X" "25"
    SYSTEM_CONSTANT "EGRCLG_CLGON_CUR_X" "25"
    SYSTEM_CONSTANT "EGRCLG_QCLGOFF_CUR_X" "25"
    SYSTEM_CONSTANT "EGRCLG_QCLGON_CUR_X" "25"
    SYSTEM_CONSTANT "EGRVLVHP" "0"
    SYSTEM_CONSTANT "EGRVLVHPLPCOMBO" "1"
    SYSTEM_CONSTANT "EGRVLVLP_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "EGRVLVLP_TYPTWINFLW_SY" "0"
    SYSTEM_CONSTANT "EGRVLVTYPE" "0"
    SYSTEM_CONSTANT "EGRVLV_AVSSEL_SY" "0"
    SYSTEM_CONSTANT "EGRVLV_HP" "0"
    SYSTEM_CONSTANT "EGRVLV_HPLP" "1"
    SYSTEM_CONSTANT "EGRVLV_POSCLSED" "99.2"
    SYSTEM_CONSTANT "EGRVLV_TYPAVL_SY" "1"
    SYSTEM_CONSTANT "EGRVLV_TYPTWINFLW_SY" "0"
    SYSTEM_CONSTANT "EGRVLV_TYP_SY" "0"
    SYSTEM_CONSTANT "EGTCOND_ACTV_BP" "0"
    SYSTEM_CONSTANT "EGTCOND_MHCLDMAXCAT_CUR_X" "7"
    SYSTEM_CONSTANT "EGTCOND_MO2LDMAXCAT_CUR_X" "7"
    SYSTEM_CONSTANT "EGTCOND_NUMTEMPHLDOPMODEMSK_SY" "2"
    SYSTEM_CONSTANT "EGTFACT_RES" "0.001"
    SYSTEM_CONSTANT "EGTSWT_FACT" "16384000"
    SYSTEM_CONSTANT "EGTSWT_FACT_S16" "16384"
    SYSTEM_CONSTANT "EGTSWT_NRM_EXP" "14"
    SYSTEM_CONSTANT "EGTSWT_RES" "6.103515625e-008"
    SYSTEM_CONSTANT "EGTSWT_RES_S16" "6.103515625e-005"
    SYSTEM_CONSTANT "EGT_FACT" "0"
    SYSTEM_CONSTANT "EGT_FACTMAX" "1"
    SYSTEM_CONSTANT "EGT_LIMMAX" "1"
    SYSTEM_CONSTANT "EGT_LIMMIN" "-1"
    SYSTEM_CONSTANT "EGT_NUMRGNSTG" "2"
    SYSTEM_CONSTANT "EGT_STATE" "1"
    SYSTEM_CONSTANT "EGT_SWTRGN_VAL" "0"
    SYSTEM_CONSTANT "EGT_SWT_DISABLED" "0"
    SYSTEM_CONSTANT "EGT_SWT_ENABLED" "1"
    SYSTEM_CONSTANT "EGT_ZERO" "0"
    SYSTEM_CONSTANT "EISDEM_NSETPOINTINIT_CUR_X" "25"
    SYSTEM_CONSTANT "EISDEM_TIPT1_CUR_X" "25"
    SYSTEM_CONSTANT "EISDEM_TRQINITI_CUR_X" "25"
    SYSTEM_CONSTANT "EISGOV_TIPT1TRQFLT_CUR_X" "25"
    SYSTEM_CONSTANT "EMDMP_NUM_PS" "2"
    SYSTEM_CONSTANT "ENERGYPERMOLHIGH_RES" "2"
    SYSTEM_CONSTANT "ENERGYPERMOLLOW_RES" "10"
    SYSTEM_CONSTANT "ENERGYPERMOLLOW_RES_FL" "10"
    SYSTEM_CONSTANT "ENERGY_J_HI_RES" "1"
    SYSTEM_CONSTANT "ENERGY_Q0P0001_RES" "0.0001"
    SYSTEM_CONSTANT "ENERGY_Q0P0001_RES_REV" "10000"
    SYSTEM_CONSTANT "ENERGY_RES" "1"
    SYSTEM_CONSTANT "ENGDA_CTFLD_NUM" "3"
    SYSTEM_CONSTANT "ENGDA_ENGOFFRSTVAL" "1"
    SYSTEM_CONSTANT "ENGDA_TFLD_TCLNT_POS" "0"
    SYSTEM_CONSTANT "ENGDA_TFLD_TENG_POS" "2"
    SYSTEM_CONSTANT "ENGDA_TFLD_TOIL_POS" "1"
    SYSTEM_CONSTANT "ENGDA_TIENGONOBD_SY" "1"
    SYSTEM_CONSTANT "ENGDEM_RMP_ACTV_BP" "1"
    SYSTEM_CONSTANT "ENGDEM_TRQLIMERR_CUR_X" "25"
    SYSTEM_CONSTANT "ENGM_NUMCYL_10" "10"
    SYSTEM_CONSTANT "ENGM_NUMCYL_3" "3"
    SYSTEM_CONSTANT "ENGM_NUMCYL_4" "4"
    SYSTEM_CONSTANT "ENGM_NUMCYL_5" "5"
    SYSTEM_CONSTANT "ENGM_NUMCYL_6" "6"
    SYSTEM_CONSTANT "ENGM_NUMCYL_8" "8"
    SYSTEM_CONSTANT "ENGM_SWTNUMCYL_TYPE" "0"
    SYSTEM_CONSTANT "ENGM_SWTNUMCYL_VAL" "6"
    SYSTEM_CONSTANT "ENGPRT_FACOVHTPRVCT_CUR_X" "25"
    SYSTEM_CONSTANT "ENGPRT_FACOVHTPRVFT_CUR_X" "25"
    SYSTEM_CONSTANT "ENGPRT_FACOVHTPRVOT_CUR_X" "25"
    SYSTEM_CONSTANT "ENGPRT_OVRDS_DCS" "0"
    SYSTEM_CONSTANT "ENGPRT_QLIM_CUR_X" "25"
    SYSTEM_CONSTANT "ENGPRT_QOVHTPRVNRNG_MAP_X" "16"
    SYSTEM_CONSTANT "ENGPRT_QOVHTPRVNRNG_MAP_Y" "16"
    SYSTEM_CONSTANT "ENGPRT_QOVHTPRVVRNG_MAP_X" "16"
    SYSTEM_CONSTANT "ENGPRT_QOVHTPRVVRNG_MAP_Y" "16"
    SYSTEM_CONSTANT "ENGPRT_TRQLIM_CUR_X" "25"
    SYSTEM_CONSTANT "ENGPRT_TRQNLIMSPR_CUR_X" "25"
    SYSTEM_CONSTANT "ENGPRT_TRQNLIM_CUR_X" "25"
    SYSTEM_CONSTANT "ENGRESTRT_SY" "0"
    SYSTEM_CONSTANT "ENGSPDLIMSTRT_SY" "0"
    SYSTEM_CONSTANT "ENGTRQPTD_RTRQNOFS_MAPX" "8"
    SYSTEM_CONSTANT "ENGTRQPTD_RTRQNOFS_MAPY" "8"
    SYSTEM_CONSTANT "ENGTRQPTD_RTRQTOFS_MAPX" "8"
    SYSTEM_CONSTANT "ENGTRQPTD_RTRQTOFS_MAPY" "8"
    SYSTEM_CONSTANT "ENGTRQPTD_TRQMAX_MAPX" "6"
    SYSTEM_CONSTANT "ENGTRQPTD_TRQMAX_MAPY" "6"
    SYSTEM_CONSTANT "ENGTRQPTD_TRQSPDGPTD_MAPX" "6"
    SYSTEM_CONSTANT "ENGTRQPTD_TRQSPDGPTD_MAPY" "6"
    SYSTEM_CONSTANT "ENG_NMAX_DS" "6000"
    SYSTEM_CONSTANT "ENG_NMAX_GS" "10000"
    SYSTEM_CONSTANT "ENG_NMIN_DS" "40"
    SYSTEM_CONSTANT "ENG_NMIN_GS" "20"
    SYSTEM_CONSTANT "ENG_N_HIRES" "0.03125"
    SYSTEM_CONSTANT "ENG_N_HIRES_EXP" "5"
    SYSTEM_CONSTANT "ENG_N_IDL_RES" "10"
    SYSTEM_CONSTANT "ENG_N_L_RES" "40"
    SYSTEM_CONSTANT "ENG_N_MAX" "10000"
    SYSTEM_CONSTANT "ENG_N_MIN" "20"
    SYSTEM_CONSTANT "ENG_N_RES" "0.5"
    SYSTEM_CONSTANT "ENG_N_RES1" "0.5"
    SYSTEM_CONSTANT "ENG_N_RES_FL" "0.5"
    SYSTEM_CONSTANT "ENG_N_RES_REV" "2"
    SYSTEM_CONSTANT "ENG_N_ZERO" "0"
    SYSTEM_CONSTANT "ENRGPERMASS_RES" "0.1"
    SYSTEM_CONSTANT "ENRGPRMOLQ0P001_INVRESO" "1000"
    SYSTEM_CONSTANT "ENRGPRMOLQ0P001_RESO" "0.001"
    SYSTEM_CONSTANT "ENRGPRMOLQ100P0_INVRESO" "0"
    SYSTEM_CONSTANT "ENRGPRMOLQ100P0_RESO" "100"
    SYSTEM_CONSTANT "EPMBCA_FACSEGTIMEACC_CURX" "3"
    SYSTEM_CONSTANT "EPMBCA_FAC_TSTINJ_SY" "1000"
    SYSTEM_CONSTANT "EPMBCR_DTINCSTRT_CURX" "5"
    SYSTEM_CONSTANT "EPMBCR_FACWEIGHTPAS_DSTX" "4"
    SYSTEM_CONSTANT "EPMBCR_FACWEIGHT_DSTX" "4"
    SYSTEM_CONSTANT "EPMBCR_NENG_DSTX" "5"
    SYSTEM_CONSTANT "EPMBCR_USEBOTHEDGES" "2"
    SYSTEM_CONSTANT "EPMBCR_USEFALLINGEDGES" "0"
    SYSTEM_CONSTANT "EPMBCR_USERISINGEDGES" "1"
    SYSTEM_CONSTANT "EPMCAS_DETECTBOTHEDGES" "2"
    SYSTEM_CONSTANT "EPMCAS_DETECTFALLINGEDGES" "0"
    SYSTEM_CONSTANT "EPMCAS_DETECTRISINGEDGES" "1"
    SYSTEM_CONSTANT "EPMCAS_FACPLAUS_DSTX" "3"
    SYSTEM_CONSTANT "EPMCAS_I1_SY" "0"
    SYSTEM_CONSTANT "EPMCAS_MOUNTCHK" "0"
    SYSTEM_CONSTANT "EPMCAS_NUMSEG" "10"
    SYSTEM_CONSTANT "EPMCAS_NUMSEGLEN" "10"
    SYSTEM_CONSTANT "EPMCAS_PHINCOR_CURX" "6"
    SYSTEM_CONSTANT "EPMCAS_PHITEMPCOR05_DSTX" "3"
    SYSTEM_CONSTANT "EPMCAS_SEGCOR_SY" "0"
    SYSTEM_CONSTANT "EPMCRS_DIAG_VEH_V_MAX" "25"
    SYSTEM_CONSTANT "EPMCRS_DIAG_VEH_V_MIN" "1"
    SYSTEM_CONSTANT "EPMCRS_NUMTHRESH" "4"
    SYSTEM_CONSTANT "EPMCRS_NUMVAL" "4"
    SYSTEM_CONSTANT "EPMHCRS_INCDVTBUF_MAX_SY" "0"
    SYSTEM_CONSTANT "EPMHCRS_NUMINC" "60"
    SYSTEM_CONSTANT "EPMHCRS_PHIINCR" "6"
    SYSTEM_CONSTANT "EPMHCRS_SWTALTPIN_SY" "0"
    SYSTEM_CONSTANT "EPMHCRS_SWTCODEDGAP_SY" "0"
    SYSTEM_CONSTANT "EPMHCRS_SWTDGI_SY" "0"
    SYSTEM_CONSTANT "EPMHCRS_SWTGAP12_SY" "0"
    SYSTEM_CONSTANT "EPMHCRS_SWTIAP_SY" "1"
    SYSTEM_CONSTANT "EPMHCRS_SWTIAS_SY" "1"
    SYSTEM_CONSTANT "EPMHCRS_SWTINCDVTMEAS_SY" "0"
    SYSTEM_CONSTANT "EPMRRS_SY" "0"
    SYSTEM_CONSTANT "EPMRRS_TITEMP_CURX" "3"
    SYSTEM_CONSTANT "EPMSYN_PHIINCCOR_CURX" "4"
    SYSTEM_CONSTANT "EPM_NENG10MSMAX" "2550"
    SYSTEM_CONSTANT "EPM_NUMCRSREVWCY_SY" "2"
    SYSTEM_CONSTANT "EPM_NUMCYLMAX" "6"
    SYSTEM_CONSTANT "EPM_N_HIRES" "0.03125"
    SYSTEM_CONSTANT "EPM_N_HIRES_EXP" "5"
    SYSTEM_CONSTANT "EPM_N_IDL_RES" "10"
    SYSTEM_CONSTANT "EPM_N_L_RES" "40"
    SYSTEM_CONSTANT "EPM_N_MAX" "10000"
    SYSTEM_CONSTANT "EPM_N_MIN" "20"
    SYSTEM_CONSTANT "EPM_N_RES" "0.5"
    SYSTEM_CONSTANT "EPM_N_RES_FL" "0.5"
    SYSTEM_CONSTANT "EPM_N_RES_INV" "2"
    SYSTEM_CONSTANT "EPM_N_RES_REV" "2"
    SYSTEM_CONSTANT "EPM_N_TO_CAS" "750"
    SYSTEM_CONSTANT "EPM_N_ZERO" "0"
    SYSTEM_CONSTANT "EPM_PHICRSREV_SY" "360"
    SYSTEM_CONSTANT "EPM_PHIMAX" "720"
    SYSTEM_CONSTANT "EPM_PHIMAX_SY" "32767"
    SYSTEM_CONSTANT "EPM_SYNCSLV_SY" "0"
    SYSTEM_CONSTANT "EPM_TI_SHORTINT" "2500"
    SYSTEM_CONSTANT "EQUALINIT" "255"
    SYSTEM_CONSTANT "EQUALINITBP" "238"
    SYSTEM_CONSTANT "ERRVAL_S16" "32767"
    SYSTEM_CONSTANT "ERRVAL_S32" "2147483647"
    SYSTEM_CONSTANT "ERRVAL_S8" "127"
    SYSTEM_CONSTANT "ERRVAL_U16" "65535"
    SYSTEM_CONSTANT "ERRVAL_U32" "4294967295"
    SYSTEM_CONSTANT "ERRVAL_U8" "255"
    SYSTEM_CONSTANT "ESC_DT_NESTING_DEPTH" "10"
    SYSTEM_CONSTANT "ESC_NUMTHRESH" "3"
    SYSTEM_CONSTANT "ESC_STACKSIZE" "10"
    SYSTEM_CONSTANT "ESC_STSCHDSX_SIZE" "16"
    SYSTEM_CONSTANT "ETA0001_RSA_RES" "0.001"
    SYSTEM_CONSTANT "ETA0001_RSA_RES_REV" "1000"
    SYSTEM_CONSTANT "ETA1_EXP" "7"
    SYSTEM_CONSTANT "ETA1_RES" "0.0078125"
    SYSTEM_CONSTANT "ETA1_RES_REV" "128"
    SYSTEM_CONSTANT "ETA2_EXP" "7"
    SYSTEM_CONSTANT "ETA2_RES" "0.0078125"
    SYSTEM_CONSTANT "ETA2_RES_REV" "128"
    SYSTEM_CONSTANT "ETA_CORR_FACT_ONE" "1"
    SYSTEM_CONSTANT "ETA_COR_FACT_ONE" "1"
    SYSTEM_CONSTANT "ETA_EXP" "7"
    SYSTEM_CONSTANT "ETA_RES" "0.0078125"
    SYSTEM_CONSTANT "ETA_RES_FL" "0.001"
    SYSTEM_CONSTANT "ETA_RES_REV" "128"
    SYSTEM_CONSTANT "ETA_THM_ENG_ONE" "1"
    SYSTEM_CONSTANT "ETCLB_COR_OFF" "0"
    SYSTEM_CONSTANT "ETCLB_COR_ON" "1"
    SYSTEM_CONSTANT "ETCLB_NUMRAILPCLBPNT_SY" "3"
    SYSTEM_CONSTANT "ETCLB_NUM_RAILP_CLB_PNT" "2"
    SYSTEM_CONSTANT "ETCLB_SWTCORACTV_TYPE" "2"
    SYSTEM_CONSTANT "ETCLB_SWTCORACTV_VAL" "1"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR0_CURX" "12"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR1_CURX" "12"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR2_CURX" "12"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR3_CURX" "12"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR4_CURX" "12"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR5_CURX" "12"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR6_CURX" "12"
    SYSTEM_CONSTANT "ETCLB_TIBSTPRESCORR_CUR_X" "12"
    SYSTEM_CONSTANT "ETCTLGOV_P0Q001_LIMMAX" "1"
    SYSTEM_CONSTANT "ETCTLGOV_P0Q001_LIMMIN" "-1"
    SYSTEM_CONSTANT "ETCTLGOV_P0Q001_RES" "0.001"
    SYSTEM_CONSTANT "ETCTLGOV_P0Q001_RES_INV" "1000"
    SYSTEM_CONSTANT "ETCTLGOV_P0Q001_ZERO" "0"
    SYSTEM_CONSTANT "ETCTL_ACTV_BP" "0"
    SYSTEM_CONSTANT "ETCTL_AMPT0" "0"
    SYSTEM_CONSTANT "ETCTL_AMPT1400" "1400"
    SYSTEM_CONSTANT "ETCTL_DTOOUTRDES_CUR_X" "8"
    SYSTEM_CONSTANT "ETCTL_FACPAROXICATHTLOS_CUR_X" "10"
    SYSTEM_CONSTANT "ETCTL_FACPARTUBEHTLOS_CUR_X" "10"
    SYSTEM_CONSTANT "ETCTL_FACTQ0P001_TEN" "10"
    SYSTEM_CONSTANT "ETCTL_FACTQ0P001_ZERO" "0"
    SYSTEM_CONSTANT "ETCTL_NUMOPMODEMSK_SY" "2"
    SYSTEM_CONSTANT "ETCTL_RO2ONE" "1"
    SYSTEM_CONSTANT "ETCTL_RO2ZERO" "0"
    SYSTEM_CONSTANT "ETCTL_SLOPENEG" "0"
    SYSTEM_CONSTANT "ETCTL_STMSKINR_CA_X" "2"
    SYSTEM_CONSTANT "ETCTL_STMSKOUTR_CA_X" "2"
    SYSTEM_CONSTANT "ETCTL_TEMPCELS0" "0"
    SYSTEM_CONSTANT "ETCTL_TEMPCELS1500" "1500"
    SYSTEM_CONSTANT "ETCTL_TIMES0" "0"
    SYSTEM_CONSTANT "ETCTL_TIMES30" "30"
    SYSTEM_CONSTANT "ETS_DPF_SY" "2"
    SYSTEM_CONSTANT "ETS_HOM_SY" "2"
    SYSTEM_CONSTANT "ETS_INJMI" "3"
    SYSTEM_CONSTANT "ETS_INJNUM_SY" "6"
    SYSTEM_CONSTANT "ETS_INJPII1" "2"
    SYSTEM_CONSTANT "ETS_INJPII2" "1"
    SYSTEM_CONSTANT "ETS_INJPII3" "0"
    SYSTEM_CONSTANT "ETS_INJPOI1" "4"
    SYSTEM_CONSTANT "ETS_INJPOI2" "5"
    SYSTEM_CONSTANT "ETS_LEAN_0" "10"
    SYSTEM_CONSTANT "ETS_LEAN_1" "11"
    SYSTEM_CONSTANT "ETS_LEAN_2" "12"
    SYSTEM_CONSTANT "ETS_LEAN_SY" "1"
    SYSTEM_CONSTANT "ETS_NSC_0" "50"
    SYSTEM_CONSTANT "ETS_NSC_1" "51"
    SYSTEM_CONSTANT "ETS_NSC_2" "52"
    SYSTEM_CONSTANT "ETS_NSC_SY" "1"
    SYSTEM_CONSTANT "ETS_NUMINPMSK_SY" "7"
    SYSTEM_CONSTANT "ETS_PFLT1_0" "20"
    SYSTEM_CONSTANT "ETS_PFLT1_1" "21"
    SYSTEM_CONSTANT "ETS_PFLT1_2" "22"
    SYSTEM_CONSTANT "ETS_PFLT1_SY" "1"
    SYSTEM_CONSTANT "ETS_PFLT2_0" "30"
    SYSTEM_CONSTANT "ETS_PFLT2_1" "31"
    SYSTEM_CONSTANT "ETS_PFLT2_2" "32"
    SYSTEM_CONSTANT "ETS_PFLT2_SY" "1"
    SYSTEM_CONSTANT "ETS_PHC_0" "40"
    SYSTEM_CONSTANT "ETS_PHC_1" "41"
    SYSTEM_CONSTANT "ETS_PHC_2" "42"
    SYSTEM_CONSTANT "ETS_PHC_SY" "2"
    SYSTEM_CONSTANT "ETS_SOX_0" "60"
    SYSTEM_CONSTANT "ETS_SOX_1" "61"
    SYSTEM_CONSTANT "ETS_SOX_2" "62"
    SYSTEM_CONSTANT "ETS_SOX_SY" "1"
    SYSTEM_CONSTANT "EXHFLPLP_TYPAVL_SY" "1"
    SYSTEM_CONSTANT "EXHFLPLP_TYPTWINFLW_SY" "0"
    SYSTEM_CONSTANT "EXHPRES_CT_SENSORS" "8"
    SYSTEM_CONSTANT "EXHTEMP_CT_SENSORS" "8"
    SYSTEM_CONSTANT "EXHTMON_CT_SENSORS" "3"
    SYSTEM_CONSTANT "EXH_NUMTEMPSENSMON_SY" "6"
    SYSTEM_CONSTANT "FACEGRCOR_EXP" "7"
    SYSTEM_CONSTANT "FACQ0P0001_INVRESO" "10000"
    SYSTEM_CONSTANT "FACQ0P0001_RESO" "0.0001"
    SYSTEM_CONSTANT "FACREACTVELQ100P0_INVRESO" "0"
    SYSTEM_CONSTANT "FACREACTVELQ100P0_RESO" "100"
    SYSTEM_CONSTANT "FACREACTVEL_INVRESO" "1"
    SYSTEM_CONSTANT "FACREACTVEL_RESO" "1"
    SYSTEM_CONSTANT "FACT0002_RES" "0.0002"
    SYSTEM_CONSTANT "FACT0002_RES_REV" "5000"
    SYSTEM_CONSTANT "FACT10000_RES" "0.0001"
    SYSTEM_CONSTANT "FACT10000_RES_REV" "10000"
    SYSTEM_CONSTANT "FACT1000_RES" "0.001"
    SYSTEM_CONSTANT "FACT1000_RES_REV" "1000"
    SYSTEM_CONSTANT "FACT100_ONE" "1"
    SYSTEM_CONSTANT "FACT100_RES" "0.01"
    SYSTEM_CONSTANT "FACT100_RES_REV" "100"
    SYSTEM_CONSTANT "FACT10_EXP" "10"
    SYSTEM_CONSTANT "FACT10_RES" "1e-010"
    SYSTEM_CONSTANT "FACT16_EXP" "16"
    SYSTEM_CONSTANT "FACT16_RES_REV" "65536"
    SYSTEM_CONSTANT "FACT1_EXP" "7"
    SYSTEM_CONSTANT "FACT1_INV" "-0.0078125"
    SYSTEM_CONSTANT "FACT1_ONE" "1"
    SYSTEM_CONSTANT "FACT1_ONE_RES" "0.1"
    SYSTEM_CONSTANT "FACT1_ONE_RES_REV" "10"
    SYSTEM_CONSTANT "FACT1_RES" "0.0078125"
    SYSTEM_CONSTANT "FACT1_RES_FL" "0.0078125"
    SYSTEM_CONSTANT "FACT1_RES_REV" "128"
    SYSTEM_CONSTANT "FACT1_ZERO" "0"
    SYSTEM_CONSTANT "FACT256_RES" "0.00390625"
    SYSTEM_CONSTANT "FACT256_RES_REV" "256"
    SYSTEM_CONSTANT "FACT26_EXP" "26"
    SYSTEM_CONSTANT "FACT26_RES" "1.49011611938477e-008"
    SYSTEM_CONSTANT "FACT26_RES_REV" "67108864"
    SYSTEM_CONSTANT "FACT3_RES" "0.01"
    SYSTEM_CONSTANT "FACT3_RES_FL" "0.01"
    SYSTEM_CONSTANT "FACT4_MAX" "1500"
    SYSTEM_CONSTANT "FACT4_MIN" "0"
    SYSTEM_CONSTANT "FACT4_ONE" "1"
    SYSTEM_CONSTANT "FACT4_RES" "0.05"
    SYSTEM_CONSTANT "FACT4_RES_REV" "20"
    SYSTEM_CONSTANT "FACT5_RES" "0.5"
    SYSTEM_CONSTANT "FACT5_RES_FL" "0.5"
    SYSTEM_CONSTANT "FACT6_RES" "0.002"
    SYSTEM_CONSTANT "FACT6_RES_FL" "0.002"
    SYSTEM_CONSTANT "FACT6_RES_REV" "500"
    SYSTEM_CONSTANT "FACT7_RES" "1e-007"
    SYSTEM_CONSTANT "FACT7_RES_REV" "10000000"
    SYSTEM_CONSTANT "FACT8_EXP" "8"
    SYSTEM_CONSTANT "FACT8_RES" "1e-008"
    SYSTEM_CONSTANT "FACT8_RES_REV" "100000000"
    SYSTEM_CONSTANT "FACT9_RES" "0.0002"
    SYSTEM_CONSTANT "FACT9_RES_FL" "0.0002"
    SYSTEM_CONSTANT "FACTFINE_MIN" "0"
    SYSTEM_CONSTANT "FACTFINE_RES" "1e-006"
    SYSTEM_CONSTANT "FACTFINE_RES_FL" "1e-006"
    SYSTEM_CONSTANT "FACTGOVILMBDRESREV_SY" "64"
    SYSTEM_CONSTANT "FACTGOVIT3RESREV_SY" "512"
    SYSTEM_CONSTANT "FACTGOVPLMBDRESREV_SY" "128"
    SYSTEM_CONSTANT "FACTGOVPT3RESREV_SY" "256"
    SYSTEM_CONSTANT "FACTLOW1_RES" "0.04"
    SYSTEM_CONSTANT "FACTLOW1_RES_REV" "25"
    SYSTEM_CONSTANT "FACTPIINT_SY" "2147"
    SYSTEM_CONSTANT "FACTPIPROP_SY" "32768"
    SYSTEM_CONSTANT "FACTR_RES" "10"
    SYSTEM_CONSTANT "FACTR_RES_FL" "10"
    SYSTEM_CONSTANT "FACTSOX1_RES_REV" "1000000"
    SYSTEM_CONSTANT "FACT_2PWR11_EXP" "11"
    SYSTEM_CONSTANT "FACT_2PWR11_RES" "0.00048828125"
    SYSTEM_CONSTANT "FACT_2PWR11_RES_REV" "2048"
    SYSTEM_CONSTANT "FACT_AR2EFFGRAD_RES" "0.01"
    SYSTEM_CONSTANT "FACT_AR2EFFGRAD_RES_REV" "100"
    SYSTEM_CONSTANT "FACT_BIP_RES" "4096"
    SYSTEM_CONSTANT "FACT_CSCVNOP_RES" "4096"
    SYSTEM_CONSTANT "FACT_EGT_RES" "0.001"
    SYSTEM_CONSTANT "FACT_EGT_RES_REV" "1000"
    SYSTEM_CONSTANT "FACT_ETCTL_ONE" "1"
    SYSTEM_CONSTANT "FACT_LAMBDAREC1" "100"
    SYSTEM_CONSTANT "FACT_LAMBDAREC2" "1000000"
    SYSTEM_CONSTANT "FACT_MASSOILASH_TO_VOLOILASH" "10"
    SYSTEM_CONSTANT "FACT_NRM_EXP" "13"
    SYSTEM_CONSTANT "FACT_NRM_EXP_LOW" "10"
    SYSTEM_CONSTANT "FACT_NSCAGETOT_RES" "3"
    SYSTEM_CONSTANT "FACT_NSCAGE_RES" "0.001"
    SYSTEM_CONSTANT "FACT_NSCEFF_RES" "0.0001"
    SYSTEM_CONSTANT "FACT_NSCEFF_RES_REV" "10000"
    SYSTEM_CONSTANT "FACT_NSC_MAX" "1"
    SYSTEM_CONSTANT "FACT_NSC_MIN" "0"
    SYSTEM_CONSTANT "FACT_NSC_RES" "0.001"
    SYSTEM_CONSTANT "FACT_NSC_RES_REV" "1000"
    SYSTEM_CONSTANT "FACT_OILMFLMGPSQ0P1_2_MSMG_REV" "10"
    SYSTEM_CONSTANT "FACT_OILMSMG_2_Q0P1" "10"
    SYSTEM_CONSTANT "FACT_OIL_VOLSNGLDIFF" "32000"
    SYSTEM_CONSTANT "FACT_ONE" "1"
    SYSTEM_CONSTANT "FACT_POI2POI1_MAX" "1"
    SYSTEM_CONSTANT "FACT_POI2POI1_MIN" "0"
    SYSTEM_CONSTANT "FACT_PRC2EFFGRAD_RES" "0.0001"
    SYSTEM_CONSTANT "FACT_PRC2EFFGRAD_RES_REV" "10000"
    SYSTEM_CONSTANT "FACT_Q0P001_RES" "0.001"
    SYSTEM_CONSTANT "FACT_Q0P001_RES_REV" "1000"
    SYSTEM_CONSTANT "FACT_RES" "0.0001220703125"
    SYSTEM_CONSTANT "FACT_RES_FL" "0.0001220703125"
    SYSTEM_CONSTANT "FACT_RES_LOW" "0.0009765625"
    SYSTEM_CONSTANT "FACT_RES_REV" "8192"
    SYSTEM_CONSTANT "FACT_RES_REV_LOW" "1024"
    SYSTEM_CONSTANT "FACT_RES_RLX" "10"
    SYSTEM_CONSTANT "FACT_SOX1_RES" "1e-006"
    SYSTEM_CONSTANT "FACT_TEMP" "-2731.4"
    SYSTEM_CONSTANT "FACT_TEMP1" "-27314"
    SYSTEM_CONSTANT "FACT_TWO_SY" "2"
    SYSTEM_CONSTANT "FACT_VOLNSC_RES" "1e-006"
    SYSTEM_CONSTANT "FACT_VOLNSC_RES_FL" "1e-006"
    SYSTEM_CONSTANT "FACT_ZERO" "0"
    SYSTEM_CONSTANT "FAC_10000_RSA" "10000"
    SYSTEM_CONSTANT "FAC_1000_RSA" "1000"
    SYSTEM_CONSTANT "FAC_AG_CRS_HI_RESO" "128"
    SYSTEM_CONSTANT "FAC_DERIVATIVE" "500000"
    SYSTEM_CONSTANT "FAC_MASSINJ_TO_QNTINJ" "10000"
    SYSTEM_CONSTANT "FAC_PLAUS" "16"
    SYSTEM_CONSTANT "FAC_PRECTL_CTLINJ" "240000"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_0" "1000"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_1" "1500"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_2" "2500"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_3" "5000"
    SYSTEM_CONSTANT "FAC_QNTADJ_TO_QNTINJ_RES" "100"
    SYSTEM_CONSTANT "FAC_T_INC_PER_DUR_HI_RESO" "256"
    SYSTEM_CONSTANT "FAC_U8_BAR_PA_RSA" "10"
    SYSTEM_CONSTANT "FAC_U8_RES_RSA" "255"
    SYSTEM_CONSTANT "FAC_USEC_TO_RPM" "60000000"
    SYSTEM_CONSTANT "FANCTL_DCYCCALC_CUR_X" "25"
    SYSTEM_CONSTANT "FANCTL_SPD_DISBL" "0"
    SYSTEM_CONSTANT "FANCTL_SPD_ENBL" "1"
    SYSTEM_CONSTANT "FANS_ADDCLGDEM_DISBL" "0"
    SYSTEM_CONSTANT "FANS_ADDCLGDEM_ENBL" "1"
    SYSTEM_CONSTANT "FANS_SWTAUTODETIO_DISBL" "0"
    SYSTEM_CONSTANT "FANS_SWTAUTODETIO_ENBL" "1"
    SYSTEM_CONSTANT "FAN_ATSINTVMOD_SY" "0"
    SYSTEM_CONSTANT "FAN_NUM_D" "2"
    SYSTEM_CONSTANT "FAN_NUM_P" "0"
    SYSTEM_CONSTANT "FBC_BPfacINV_RES" "546.116666666667"
    SYSTEM_CONSTANT "FBC_BPfac_MAX" "30"
    SYSTEM_CONSTANT "FBC_BPfac_MIN" "-30"
    SYSTEM_CONSTANT "FBC_BPfac_RES" "0.00183111056855983"
    SYSTEM_CONSTANT "FBC_CTPHCOMP_MAX" "4"
    SYSTEM_CONSTANT "FBC_CTPHCOMP_MIN" "0"
    SYSTEM_CONSTANT "FBC_CTSEGOFFSET" "3"
    SYSTEM_CONSTANT "FBC_CTTDCOFFSET" "1"
    SYSTEM_CONSTANT "FBC_DBPFAC1DEN1" "1.6879"
    SYSTEM_CONSTANT "FBC_DBPFAC1DEN2" "0.949"
    SYSTEM_CONSTANT "FBC_DBPFAC2DEN1" "0.9747"
    SYSTEM_CONSTANT "FBC_DBPFAC2DEN2" "0.949"
    SYSTEM_CONSTANT "FBC_DBPFAC3DEN1" "0.000425"
    SYSTEM_CONSTANT "FBC_DBPFAC3DEN2" "0.949"
    SYSTEM_CONSTANT "FBC_DBPFAC4DEN1" "0"
    SYSTEM_CONSTANT "FBC_DBPFAC4DEN2" "0"
    SYSTEM_CONSTANT "FBC_DBPFAC5DEN1" "0"
    SYSTEM_CONSTANT "FBC_DBPFAC5DEN2" "0"
    SYSTEM_CONSTANT "FBC_DSYN" "1"
    SYSTEM_CONSTANT "FBC_DXS_FL" "4194304"
    SYSTEM_CONSTANT "FBC_EQUALINIT_BY_FBCPRECTL_BP" "1"
    SYSTEM_CONSTANT "FBC_EQUALINIT_BY_FBCWHEELLRN_BP" "0"
    SYSTEM_CONSTANT "FBC_EQUALINIT_BY_TAA_BP" "2"
    SYSTEM_CONSTANT "FBC_FIOMAX_SY" "8"
    SYSTEM_CONSTANT "FBC_FSURGE_CURX" "10"
    SYSTEM_CONSTANT "FBC_NPRECTL_AXISX" "5"
    SYSTEM_CONSTANT "FBC_NUMAASEGMAX_SY" "4"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA0" "0.0681483474"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA1" "0.131652498"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA2" "0.186184748"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA3" "0.228028815"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA4" "0.186184748"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA5" "0.131652498"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA6" "0.0681483474"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA7" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AA8" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL03_AAORD" "6"
    SYSTEM_CONSTANT "FBC_NUMCYL03_NUMAASEG" "4"
    SYSTEM_CONSTANT "FBC_NUMCYL03_TSM0" "3.5"
    SYSTEM_CONSTANT "FBC_NUMCYL03_TSM1" "-2.5"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA0" "0.0155861364"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA1" "0.0571060835"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA2" "0.125906618"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA3" "0.191080679"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA4" "0.220640963"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA5" "0.191080679"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA6" "0.125906618"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA7" "0.0571060835"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AA8" "0.0155861364"
    SYSTEM_CONSTANT "FBC_NUMCYL04_AAORD" "8"
    SYSTEM_CONSTANT "FBC_NUMCYL04_NUMAASEG" "3"
    SYSTEM_CONSTANT "FBC_NUMCYL04_TSM0" "4.5"
    SYSTEM_CONSTANT "FBC_NUMCYL04_TSM1" "-3.5"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA0" "0.0143161042"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA1" "0.0541633501"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA2" "0.125118189"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA3" "0.193597643"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA4" "0.225609425"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA5" "0.193597643"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA6" "0.125118189"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA7" "0.0541633501"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AA8" "0.0143161042"
    SYSTEM_CONSTANT "FBC_NUMCYL05_AAORD" "8"
    SYSTEM_CONSTANT "FBC_NUMCYL05_NUMAASEG" "3"
    SYSTEM_CONSTANT "FBC_NUMCYL05_TSM0" "5.5"
    SYSTEM_CONSTANT "FBC_NUMCYL05_TSM1" "-4.5"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA0" "0.0744924388"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA1" "0.249256558"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA2" "0.352502005"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA3" "0.249256558"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA4" "0.0744924388"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA5" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA6" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA7" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AA8" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL06_AAORD" "4"
    SYSTEM_CONSTANT "FBC_NUMCYL06_NUMAASEG" "2"
    SYSTEM_CONSTANT "FBC_NUMCYL06_TSM0" "6.5"
    SYSTEM_CONSTANT "FBC_NUMCYL06_TSM1" "-5.5"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA0" "0.0155861364"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA1" "0.0571060835"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA2" "0.125906618"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA3" "0.191080679"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA4" "0.220640963"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA5" "0.191080679"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA6" "0.125906618"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA7" "0.0571060835"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AA8" "0.0155861364"
    SYSTEM_CONSTANT "FBC_NUMCYL08_AAORD" "8"
    SYSTEM_CONSTANT "FBC_NUMCYL08_NUMAASEG" "3"
    SYSTEM_CONSTANT "FBC_NUMCYL08_TSM0" "8.5"
    SYSTEM_CONSTANT "FBC_NUMCYL08_TSM1" "-7.5"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA0" "0.0750601575"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA1" "0.248923997"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA2" "0.352031692"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA3" "0.248923997"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA4" "0.0750601575"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA5" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA6" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA7" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AA8" "0"
    SYSTEM_CONSTANT "FBC_NUMCYL10_AAORD" "4"
    SYSTEM_CONSTANT "FBC_NUMCYL10_NUMAASEG" "2"
    SYSTEM_CONSTANT "FBC_NUMCYL10_TSM0" "10.5"
    SYSTEM_CONSTANT "FBC_NUMCYL10_TSM1" "-9.5"
    SYSTEM_CONSTANT "FBC_NUMESPPLRNREG_SY" "2"
    SYSTEM_CONSTANT "FBC_NUMSEG" "2"
    SYSTEM_CONSTANT "FBC_QGVRNTHRESMAX_CURX" "4"
    SYSTEM_CONSTANT "FBC_QLIM_CURX" "4"
    SYSTEM_CONSTANT "FBC_QLIM_CUR_X" "4"
    SYSTEM_CONSTANT "FBC_QPRECTL_AXISX" "6"
    SYSTEM_CONSTANT "FBC_TPRECTL_AXISX" "2"
    SYSTEM_CONSTANT "FINALTRQREV1" "3125"
    SYSTEM_CONSTANT "FLASH_CONFIG_SY" "0"
    SYSTEM_CONSTANT "FLCONS1_RES" "0.01"
    SYSTEM_CONSTANT "FLCONS1_RES_INV" "100"
    SYSTEM_CONSTANT "FLCONS2_RES" "1"
    SYSTEM_CONSTANT "FLCONS2_RES_1" "0.001"
    SYSTEM_CONSTANT "FLCONS2_RES_HIGH" "0.05"
    SYSTEM_CONSTANT "FLCONS2_RES_HIGH_REV" "20"
    SYSTEM_CONSTANT "FLCONS3_MIN" "0"
    SYSTEM_CONSTANT "FLCONS3_RES" "2.77777777777778e-006"
    SYSTEM_CONSTANT "FLCONS3_RES_REV" "360000"
    SYSTEM_CONSTANT "FLCONS_LPS_RES" "0.0001"
    SYSTEM_CONSTANT "FLCONS_L_RES" "0.001"
    SYSTEM_CONSTANT "FLCONS_RES_100MS" "2.77777777777778e-007"
    SYSTEM_CONSTANT "FLCONS_RES_REV_100MS" "3600000"
    SYSTEM_CONSTANT "FLCONS_SDET_MIN" "0.01"
    SYSTEM_CONSTANT "FLDETREFUEL_HALF_L" "0.5"
    SYSTEM_CONSTANT "FLMNG_FULLLDRGLIKI_CUR_X" "7"
    SYSTEM_CONSTANT "FLMNG_FULLLDRGLPKP_CUR_X" "7"
    SYSTEM_CONSTANT "FLMNG_R_STOICH" "14.5"
    SYSTEM_CONSTANT "FLMNG_R_STOICH_CONF" "14.5"
    SYSTEM_CONSTANT "FLMNG_SMK_NORM" "689.655172413793"
    SYSTEM_CONSTANT "FLMNG_TIFULLLDRGLDEL_CUR_X" "10"
    SYSTEM_CONSTANT "FLSYS_FTS_EXISTS" "1"
    SYSTEM_CONSTANT "FLSYS_FTS_NONE" "0"
    SYSTEM_CONSTANT "FLSYS_RHOFL_CURX" "2"
    SYSTEM_CONSTANT "FLSYS_SWTTEMPSENSCFG_TYPE" "2"
    SYSTEM_CONSTANT "FLSYS_SWTTEMPSENSCFG_VAL" "0"
    SYSTEM_CONSTANT "FLVOL_RES" "0.05"
    SYSTEM_CONSTANT "FL_2_RES" "10"
    SYSTEM_CONSTANT "FL_Half_L_MAX" "300"
    SYSTEM_CONSTANT "FL_Half_L_MIN" "0"
    SYSTEM_CONSTANT "FL_L_MAX" "320"
    SYSTEM_CONSTANT "FL_L_MIN" "0"
    SYSTEM_CONSTANT "FL_L_RES" "0.01"
    SYSTEM_CONSTANT "FL_L_RES_INV" "100"
    SYSTEM_CONSTANT "FL_RES" "0.5"
    SYSTEM_CONSTANT "FL_RES_INV" "2"
    SYSTEM_CONSTANT "FL_VOL_MAX" "65.5"
    SYSTEM_CONSTANT "FL_VOL_MIN" "0"
    SYSTEM_CONSTANT "FL_VOL_RES" "0.001"
    SYSTEM_CONSTANT "FL_VOL_RES_INV" "1000"
    SYSTEM_CONSTANT "FMA_DT1_RES" "4294.967296"
    SYSTEM_CONSTANT "FMA_ENA_SY" "1"
    SYSTEM_CONSTANT "FMA_N_2_PSI" "33554.432"
    SYSTEM_CONSTANT "FMA_QADAPINI_X_AXIS" "8"
    SYSTEM_CONSTANT "FMA_QADAPINI_Y_AXIS" "8"
    SYSTEM_CONSTANT "FMA_Q_2_PSI" "67108.864"
    SYSTEM_CONSTANT "FMA_SWTQNTAIRCTLCOR_SY" "0"
    SYSTEM_CONSTANT "FMO_ENA_SY" "0"
    SYSTEM_CONSTANT "FMO_NUMNGRID_SY" "8"
    SYSTEM_CONSTANT "FMO_NUMQGRID_SY" "8"
    SYSTEM_CONSTANT "FMO_SWTEMICTL_SY" "1"
    SYSTEM_CONSTANT "FMO_SWTPGOVDVT_SY" "0"
    SYSTEM_CONSTANT "FMO_SWTSCALE_SY" "0"
    SYSTEM_CONSTANT "FORCE_OFS_RSA" "10000"
    SYSTEM_CONSTANT "FORCE_RES_RSA" "2"
    SYSTEM_CONSTANT "FRQCYLPRES_RES" "1"
    SYSTEM_CONSTANT "FRQCYLPRES_RES_REV" "1"
    SYSTEM_CONSTANT "FRQTDC_RES" "0.02"
    SYSTEM_CONSTANT "FRQTDC_RES_REV" "50"
    SYSTEM_CONSTANT "FRTP_VAR_SY" "0"
    SYSTEM_CONSTANT "FTSCD_TLIN_CUR_X" "25"
    SYSTEM_CONSTANT "FUELP_DYNPLAUSENBL_SY" "0"
    SYSTEM_CONSTANT "FUELP_INAVRGENBL_SY" "0"
    SYSTEM_CONSTANT "FUELP_OUTFLTENBL_SY" "1"
    SYSTEM_CONSTANT "FUELT_FTS_NONE" "0"
    SYSTEM_CONSTANT "FUELT_PHYSRNGCHK_SY" "0"
    SYSTEM_CONSTANT "FUELT_TEMP_CTS" "1"
    SYSTEM_CONSTANT "FUELT_TEMP_DFL" "2"
    SYSTEM_CONSTANT "FUELT_TEMP_FTS" "0"
    SYSTEM_CONSTANT "GAIN_RSA" "100"
    SYSTEM_CONSTANT "GCVOLT_RES" "1023"
    SYSTEM_CONSTANT "GCVOLT_VOLT_BATT_REV" "409.2"
    SYSTEM_CONSTANT "GDI_SY" "0"
    SYSTEM_CONSTANT "GEAR0" "0"
    SYSTEM_CONSTANT "GEAR1" "1"
    SYSTEM_CONSTANT "GEAR2" "2"
    SYSTEM_CONSTANT "GEAR3" "3"
    SYSTEM_CONSTANT "GEAR4" "4"
    SYSTEM_CONSTANT "GEAR5" "5"
    SYSTEM_CONSTANT "GEAR6" "6"
    SYSTEM_CONSTANT "GEAR7" "7"
    SYSTEM_CONSTANT "GEARBX_NUMGEAR_MAX" "6"
    SYSTEM_CONSTANT "GEARBX_NUMGEAR_MIN" "-1"
    SYSTEM_CONSTANT "GEARBX_TRQMAXGEAR1_CUR_X" "15"
    SYSTEM_CONSTANT "GEARBX_TRQMAXGEAR2_CUR_X" "15"
    SYSTEM_CONSTANT "GEARBX_TRQMAXGEAR3_CUR_X" "15"
    SYSTEM_CONSTANT "GEARBX_TRQMAXGEAR4_CUR_X" "15"
    SYSTEM_CONSTANT "GEARBX_TRQMAXGEAR5_CUR_X" "15"
    SYSTEM_CONSTANT "GEARBX_TRQMAXGEAR6_CUR_X" "15"
    SYSTEM_CONSTANT "GEARBX_TRQMAXGEARR_CUR_X" "15"
    SYSTEM_CONSTANT "GEARBX_TYPE_MT" "0"
    SYSTEM_CONSTANT "GEAR_OFS_RSA" "1"
    SYSTEM_CONSTANT "GLWCTL_BATTCORR" "2"
    SYSTEM_CONSTANT "GLWCTL_BATTCORR_MSG" "3"
    SYSTEM_CONSTANT "GLWCTL_DWENRGSLP_CUR_X" "6"
    SYSTEM_CONSTANT "GLWCTL_FACT_TIME" "10"
    SYSTEM_CONSTANT "GLWCTL_GSK3" "1"
    SYSTEM_CONSTANT "GLWCTL_PREGLWDURCALC_AIRPRESS" "1"
    SYSTEM_CONSTANT "GLWCTL_PREGLWDURCALC_UBATT" "0"
    SYSTEM_CONSTANT "GLWCTL_QPOST_CUR_X" "25"
    SYSTEM_CONSTANT "GLWCTL_QPST_CUR_X" "8"
    SYSTEM_CONSTANT "GLWCTL_STINTR1_MAP_X" "16"
    SYSTEM_CONSTANT "GLWCTL_STINTR1_MAP_Y" "16"
    SYSTEM_CONSTANT "GLWCTL_STINTR2_MAP_X" "16"
    SYSTEM_CONSTANT "GLWCTL_STINTR2_MAP_Y" "16"
    SYSTEM_CONSTANT "GLWCTL_STRLYCTL_MAP_X" "16"
    SYSTEM_CONSTANT "GLWCTL_STRLYCTL_MAP_Y" "16"
    SYSTEM_CONSTANT "GLWCTL_SWTPREGLWDURCALC_TYPE" "2"
    SYSTEM_CONSTANT "GLWCTL_SWTPREGLWDURCALC_VAL" "0"
    SYSTEM_CONSTANT "GLWCTL_TIHIPREGLWPRECTL_CUR_X" "5"
    SYSTEM_CONSTANT "GLWCTL_TIME_MS_RES" "10"
    SYSTEM_CONSTANT "GLWCTL_TIOUT1_CUR_X" "6"
    SYSTEM_CONSTANT "GLWCTL_TIPOST_MAP_X" "16"
    SYSTEM_CONSTANT "GLWCTL_TIPOST_MAP_Y" "16"
    SYSTEM_CONSTANT "GLWCTL_TIPRE1_MAPX" "4"
    SYSTEM_CONSTANT "GLWCTL_TIPRE1_MAPY" "6"
    SYSTEM_CONSTANT "GLWCTL_TIPRE1_MAP_X" "16"
    SYSTEM_CONSTANT "GLWCTL_TIPRE1_MAP_Y" "16"
    SYSTEM_CONSTANT "GLWCTL_TIPRE2_MAPX" "4"
    SYSTEM_CONSTANT "GLWCTL_TIPRE2_MAPY" "6"
    SYSTEM_CONSTANT "GLWCTL_TIPRE2_MAP_X" "16"
    SYSTEM_CONSTANT "GLWCTL_TIPRE2_MAP_Y" "16"
    SYSTEM_CONSTANT "GLWCTL_TIPREGLWPSH_CUR_X" "8"
    SYSTEM_CONSTANT "GLWCTL_TIPREGLW_CUR_X" "4"
    SYSTEM_CONSTANT "GLWCTL_TIPST_MAP_X" "8"
    SYSTEM_CONSTANT "GLWCTL_TIPST_MAP_Y" "6"
    SYSTEM_CONSTANT "GLWCTL_TIRDY_CUR_X" "6"
    SYSTEM_CONSTANT "GLWCTL_TITHRESFL1_CUR_X" "6"
    SYSTEM_CONSTANT "GLWCTL_UGLWPLGHIPREGLWPRECTL_CUR_X" "8"
    SYSTEM_CONSTANT "GLWCTL_UGLWPLGHIPREGLW_CUR_X" "8"
    SYSTEM_CONSTANT "GLWCTL_UGLWPLGRAW" "11000"
    SYSTEM_CONSTANT "GLWCTL_UOUTITM_MAP_X" "6"
    SYSTEM_CONSTANT "GLWCTL_UOUTITM_MAP_Y" "6"
    SYSTEM_CONSTANT "GLWCTL_UOUT_CUR_X" "6"
    SYSTEM_CONSTANT "GLWCTL_UOUT_MAP_X" "11"
    SYSTEM_CONSTANT "GLWCTL_UOUT_MAP_Y" "9"
    SYSTEM_CONSTANT "GLWCTL_UPRESPSTCOR_MAP_X" "4"
    SYSTEM_CONSTANT "GLWCTL_UPRESPSTCOR_MAP_Y" "6"
    SYSTEM_CONSTANT "GLWCTL_UPSTCOR_MAP_X" "6"
    SYSTEM_CONSTANT "GLWCTL_UPSTCOR_MAP_Y" "6"
    SYSTEM_CONSTANT "GLWCTL_UTINDPSTCOR_MAP_X" "6"
    SYSTEM_CONSTANT "GLWCTL_UTINDPSTCOR_MAP_Y" "6"
    SYSTEM_CONSTANT "GLWCTL_UVOLTBATTGLWPLGRAW" "11000"
    SYSTEM_CONSTANT "GLWCTL_WENRGPRE_CUR_X" "10"
    SYSTEM_CONSTANT "GLWLMP_ATSINTVMOD_SY" "1"
    SYSTEM_CONSTANT "GLWPLG_ATSINTVMOD_SY" "1"
    SYSTEM_CONSTANT "GLWPLG_NUM_PLGS" "6"
    SYSTEM_CONSTANT "GLWPLG_TCTL_SY" "0"
    SYSTEM_CONSTANT "GRPDLYTIME_RES" "0.1"
    SYSTEM_CONSTANT "GRPDLYTIME_RES_REV" "10"
    SYSTEM_CONSTANT "GRPDLY_FACT_FL" "13.65333333333"
    SYSTEM_CONSTANT "GSHDEM_TRQMAX_MAP_X" "16"
    SYSTEM_CONSTANT "GSHDEM_TRQMAX_MAP_Y" "16"
    SYSTEM_CONSTANT "GSSYS_TYPAIRCTL_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPAIRFLW_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPAIRSYS_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEAIRFLW_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEEXHFLW_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEGRCLGLP_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEGRCLG_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEGRLP_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEGR_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPENG_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEPHC_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEXHMNFLP_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPEXHMNF_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPINDVOL_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPINTMNFLP_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPINTMNF_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPNSC_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPOXIC_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPPCR_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPPFLT_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPTRBCHR_SY" "1"
    SYSTEM_CONSTANT "GSSYS_TYPVSWCTL_SY" "1"
    SYSTEM_CONSTANT "GVRN" "1"
    SYSTEM_CONSTANT "G_08_RSA_RES" "0.8"
    SYSTEM_CONSTANT "G_1_6_RSA_RES" "1.6"
    SYSTEM_CONSTANT "G_MIN_RSA_RES" "100"
    SYSTEM_CONSTANT "HCMPT_Q0P0000004_RES" "4e-007"
    SYSTEM_CONSTANT "HCMPT_Q0P0000004_RES_REV" "2500000"
    SYSTEM_CONSTANT "HCMPT_Q0P0000004_ZERO" "0"
    SYSTEM_CONSTANT "HCMPT_Q0P4_RES" "0.4"
    SYSTEM_CONSTANT "HCMPT_Q0P4_RES_REV" "2.5"
    SYSTEM_CONSTANT "HCMPT_Q0P8_RES" "0.8"
    SYSTEM_CONSTANT "HCMPT_RES" "0.1"
    SYSTEM_CONSTANT "HCMPT_RES_REV" "10"
    SYSTEM_CONSTANT "HCMPT_ZERO" "0"
    SYSTEM_CONSTANT "HCUN_FACPRESCOR_CUR_X" "6"
    SYSTEM_CONSTANT "HCUN_FACTEMPCOR_CUR_X" "10"
    SYSTEM_CONSTANT "HCUN_LPSPLY_CUR_X" "10"
    SYSTEM_CONSTANT "HCUN_RHIHCFLWDDV_CUR_X" "10"
    SYSTEM_CONSTANT "HCUN_RLOHCFLWDDV_CUR_X" "10"
    SYSTEM_CONSTANT "HCUN_TIBATTCOR_CUR_X" "7"
    SYSTEM_CONSTANT "HC_MASSPERTIME_RES_RSA" "1000000"
    SYSTEM_CONSTANT "HEATCAPA_FINE_RES" "0.0001"
    SYSTEM_CONSTANT "HEATCAPA_FINE_RES_REV" "10000"
    SYSTEM_CONSTANT "HEAT_CAPACITY_RES" "0.1"
    SYSTEM_CONSTANT "HEAT_CAPACITY_RES_REV" "10"
    SYSTEM_CONSTANT "HESRV_AIRSYSCALCLOCB1" "0"
    SYSTEM_CONSTANT "HESRV_AIRSYSCALCLOCB2" "0"
    SYSTEM_CONSTANT "HESRV_COSWTAVG" "0"
    SYSTEM_CONSTANT "HESRV_COSWTAVG_SY" "0"
    SYSTEM_CONSTANT "HESRV_COSWTMAX" "2"
    SYSTEM_CONSTANT "HESRV_COSWTMAX_SY" "2"
    SYSTEM_CONSTANT "HESRV_COSWTMIN" "1"
    SYSTEM_CONSTANT "HESRV_COSWTMIN_SY" "1"
    SYSTEM_CONSTANT "HESRV_COSWTSUM" "3"
    SYSTEM_CONSTANT "HESRV_COSWTSUM_SY" "3"
    SYSTEM_CONSTANT "HESRV_EGSYSCALCLOCB1" "0"
    SYSTEM_CONSTANT "HESRV_EGSYSCALCLOCB2" "0"
    SYSTEM_CONSTANT "HESRV_ENASCNDFLW_SY" "1"
    SYSTEM_CONSTANT "HESRV_HETYP_SY" "255"
    SYSTEM_CONSTANT "HESRV_LOCAL" "255"
    SYSTEM_CONSTANT "HESRV_MASTER" "0"
    SYSTEM_CONSTANT "HESRV_MASTERSLAVE" "1"
    SYSTEM_CONSTANT "HESRV_ONEBOX" "255"
    SYSTEM_CONSTANT "HESRV_SLAVE" "1"
    SYSTEM_CONSTANT "HESRV_SNGLFLW" "1"
    SYSTEM_CONSTANT "HESRV_TWFLW" "2"
    SYSTEM_CONSTANT "HEVTYP_PARL" "4"
    SYSTEM_CONSTANT "HEVTYP_PWRSPLT" "3"
    SYSTEM_CONSTANT "HEVTYP_SER" "1"
    SYSTEM_CONSTANT "HEVTYP_SERPARL" "2"
    SYSTEM_CONSTANT "HIGH_PREGLOW_NORM" "250"
    SYSTEM_CONSTANT "HIRES_INJTIME_US" "3"
    SYSTEM_CONSTANT "HLSDEM_NSETPHI_MAP_X" "8"
    SYSTEM_CONSTANT "HLSDEM_NSETPHI_MAP_Y" "8"
    SYSTEM_CONSTANT "HLSDEM_NSETPLOINI_CUR_X" "25"
    SYSTEM_CONSTANT "HLSDEM_TRQREQSTRT_CUR_X" "25"
    SYSTEM_CONSTANT "HTRLSTHRES_NRM_EXP" "14"
    SYSTEM_CONSTANT "HTRLSTHRES_RES_REV" "16384"
    SYSTEM_CONSTANT "IAIRHT_NUM_SY" "2"
    SYSTEM_CONSTANT "IATSCD_TLIN_CUR_X" "25"
    SYSTEM_CONSTANT "IDEAL_GAS_CONSTANT" "287.5"
    SYSTEM_CONSTANT "IDEAL_GAS_CONSTANT_FL" "287"
    SYSTEM_CONSTANT "IDEAL_GAS_CONSTANT_INT" "2875"
    SYSTEM_CONSTANT "IDEAL_GAS_VOL" "22.4"
    SYSTEM_CONSTANT "IMPT_RES" "0.01"
    SYSTEM_CONSTANT "IMPT_RES_REV" "100"
    SYSTEM_CONSTANT "INACTIV" "4"
    SYSTEM_CONSTANT "INIT" "1"
    SYSTEM_CONSTANT "INIT_ZERO" "0"
    SYSTEM_CONSTANT "INJCRV_ANGLE" "0"
    SYSTEM_CONSTANT "INJCRV_DBLCOR_SY" "1"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AGRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM0_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM1_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM2_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM3_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM4_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM5_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM6_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1AIRDVTCOREOM7_CURX" "4"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR1EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1APSSOECOR2EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR1EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ATSSOECOR2EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR1EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1ETSSOECOR2EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACMI1FTSRAILCOR_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMI1PFLTPHICOR_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACMIAPSPHICOR_CUR_X" "8"
    SYSTEM_CONSTANT "INJCRV_FACMIAPSPHICOR_X_AXIS" "4"
    SYSTEM_CONSTANT "INJCRV_FACMIATSPHICOR_CUR_X" "8"
    SYSTEM_CONSTANT "INJCRV_FACMIATSPHICOR_X_AXIS" "12"
    SYSTEM_CONSTANT "INJCRV_FACMIETSPHICOR_CUR_X" "8"
    SYSTEM_CONSTANT "INJCRV_FACMIETSPHICOR_X_AXIS" "12"
    SYSTEM_CONSTANT "INJCRV_FACMIFTSRAILCOR_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACMIPFLTPHICOR_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOR2EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOR2EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1APSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOR2EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOR2EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ATSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOR2EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOR2EOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1ETSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTMIN_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1QNTRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII1SOERMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2APSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ATSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2ETSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTMIN_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2QNTRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2RMPVAL_GCUR_X" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII2SOERMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3AGRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3APSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ATSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3ETSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTMIN_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM0_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPII3QNTRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1AGRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1APSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ATSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1ETSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI1QNTRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2APSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ATSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFEOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFEOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFEOMX_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFEOMX_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFLPCEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2EFFSLPEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSQCOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM4_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM5_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM6_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2ETSSOECOREOM7_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2NOEFFEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTMIN_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2QNTRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM0_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOI2SOERMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_FACPOPPOI2ETSCOR_CURX" "6"
    SYSTEM_CONSTANT "INJCRV_NUMINJRTMLIM_CURX" "8"
    SYSTEM_CONSTANT "INJCRV_NUMPOI1SPLTMAX_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_NUMPOI1SPLTMAX_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_NUMPOI1SPLT_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_NUMPOI1SPLT_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_NUMSTGPOI2EFFLPC_SY" "4"
    SYSTEM_CONSTANT "INJCRV_NUMSTGPOI2EFFSLP_SY" "6"
    SYSTEM_CONSTANT "INJCRV_PHIDYNOFS_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM0_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM0_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM1_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM1_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM2_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM2_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM3_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM3_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM4_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM4_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM5_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM5_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM6_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM6_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM7_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIREXSEOM7_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM0_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM0_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM1_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM1_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM2_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM2_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM3_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM3_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM4_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM4_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM5_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM5_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM6_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM6_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM7_MAPX" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1AIRLACKEOM7_MAPY" "4"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR1EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1APSCOR2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR1EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ATSCOR2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS1EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS3EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS4EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS5EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1BAS5EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1DESCSCMAX_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1DESCSCMAX_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1DESCSCMIN_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1DESCSCMIN_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1DESCSC_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR1EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1ETSCOR2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1FTSRAILCOR_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1FTSRAILCOR_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1MAXEOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1MAXEOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1MAXEOMX_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1MAXEOMX_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1MAX_X_AXIS" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1MAX_Y_AXIS" "10"
    SYSTEM_CONSTANT "INJCRV_PHIMI1PFLTCOR_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMI1PFLTCOR_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMIAPSCOR_MAP_X" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMIAPSCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "INJCRV_PHIMIAPSCOR_X_AXIS" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMIAPSCOR_Y_AXIS" "8"
    SYSTEM_CONSTANT "INJCRV_PHIMIATSCOR_MAP_X" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMIATSCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "INJCRV_PHIMIATSCOR_X_AXIS" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMIATSCOR_Y_AXIS" "8"
    SYSTEM_CONSTANT "INJCRV_PHIMIETSCOR_MAP_X" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMIETSCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "INJCRV_PHIMIETSCOR_X_AXIS" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMIETSCOR_Y_AXIS" "8"
    SYSTEM_CONSTANT "INJCRV_PHIMIFTSRAILCOR_MAPX" "12"
    SYSTEM_CONSTANT "INJCRV_PHIMIFTSRAILCOR_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIMIPFLTCOR_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIMIPFLTCOR_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM1_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM1_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM2_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM2_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM3_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM3_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM4_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM4_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM5_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM5_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM6_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM6_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM7_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS1EOM7_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM1_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM1_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM2_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM2_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM3_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM3_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM4_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM4_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM5_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM5_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM6_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM6_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM7_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS2EOM7_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS3EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1BAS3EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII1ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM1_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM1_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM2_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM2_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM3_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM3_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM4_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM4_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM5_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM5_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM6_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM6_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM7_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2BASEOM7_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII2ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM0_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM0_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM1_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM1_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM2_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM2_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM3_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM3_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM4_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM4_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM5_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM5_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM6_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM6_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM7_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS1EOM7_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS2EOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3BAS2EOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM0_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETS_MAP_X" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPII3ETS_MAP_Y" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1BASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1MAX_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPOI1MAX_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2BASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2MAXEOMX_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2MAXEOMX_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2MINOILDIL_CURX" "6"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2REPLNRM_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_PHIPOI2REPLNRM_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_PII1SOECLBMODEEOM0_SY" "1"
    SYSTEM_CONSTANT "INJCRV_PII1SOECLBMODEEOMX_SY" "1"
    SYSTEM_CONSTANT "INJCRV_PII2SEPCOR_SY" "1"
    SYSTEM_CONSTANT "INJCRV_PII2SOECLBMODEEOM0_SY" "1"
    SYSTEM_CONSTANT "INJCRV_PII2SOECLBMODEEOMX_SY" "1"
    SYSTEM_CONSTANT "INJCRV_PIIDBLCORMAP_OFF" "0"
    SYSTEM_CONSTANT "INJCRV_PIIDBLCORMAP_ON" "1"
    SYSTEM_CONSTANT "INJCRV_PIONOFF_OFF" "255"
    SYSTEM_CONSTANT "INJCRV_PIONOFF_ON" "0"
    SYSTEM_CONSTANT "INJCRV_POI2SOECLBMODEEOM0_SY" "1"
    SYSTEM_CONSTANT "INJCRV_POI2SOECLBMODEEOMX_SY" "1"
    SYSTEM_CONSTANT "INJCRV_POPPIIAIRCOR_CUR_X" "8"
    SYSTEM_CONSTANT "INJCRV_POPPOI1BAS_MAPX" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI1BAS_MAPY" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI1EOM_MAPX" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI1EOM_MAPY" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI2BAS_MAPX" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI2BAS_MAPY" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI2EOM_MAPX" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI2EOM_MAPY" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI2ETSCOR_MAPX" "6"
    SYSTEM_CONSTANT "INJCRV_POPPOI2ETSCOR_MAPY" "6"
    SYSTEM_CONSTANT "INJCRV_QACT" "1"
    SYSTEM_CONSTANT "INJCRV_QMI1CSCMAX_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QMI1CSCMAX_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QMI1CSCMIN_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QMI1CSCMIN_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QMI1CSC_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_QMI1LPCMAX_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QMI1LPCMAX_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QMI1NRMMAX_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QMI1NRMMAX_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QMIN1_CURX" "25"
    SYSTEM_CONSTANT "INJCRV_QMIN2_CURX" "25"
    SYSTEM_CONSTANT "INJCRV_QMIN3_CURX" "25"
    SYSTEM_CONSTANT "INJCRV_QMIN4_CURX" "25"
    SYSTEM_CONSTANT "INJCRV_QMIN5_CURX" "25"
    SYSTEM_CONSTANT "INJCRV_QMIN_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_QMIN_MAP_X" "16"
    SYSTEM_CONSTANT "INJCRV_QMIN_MAP_Y" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS1EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1BAS2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1MAX1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1MAX1_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_QPII1MAX2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII1MAX2_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2BASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII2MAX_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_QPII2MAX_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM0_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM0_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS1EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3BAS2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM0_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3MAX_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPII3MAX_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1BASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI1MAX_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI1MAX_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM0_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2BASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2EFFLPCEOM0_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_QPOI2EFFLPCEOM1_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_QPOI2EFFLPCEOM2_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_QPOI2EFFLPCEOM3_CURX" "12"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_QPOI2LPCMAX_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI2LPCMAX_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI2MIN_CUR_X" "6"
    SYSTEM_CONSTANT "INJCRV_QPOI2NRMMAX_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI2NRMMAX_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_QPOI2SMKCOR_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_QRAW" "0"
    SYSTEM_CONSTANT "INJCRV_RMI1DESCSC_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_RMI1QNTCSC_CURX" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STPIIRLSOPRNG5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_STRLSOPRNGTHRESEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_SWTPIIDBLCORMAP_TYPE" "2"
    SYSTEM_CONSTANT "INJCRV_SWTPIIDBLCORMAP_VAL" "0"
    SYSTEM_CONSTANT "INJCRV_SWTPIONOFF_TYPE" "0"
    SYSTEM_CONSTANT "INJCRV_SWTPIONOFF_VAL" "0"
    SYSTEM_CONSTANT "INJCRV_SWTTIPSE_TYPE" "2"
    SYSTEM_CONSTANT "INJCRV_SWTTIPSE_VAL" "0"
    SYSTEM_CONSTANT "INJCRV_TIME" "1"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM0_MAPX" "12"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS1EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM0_MAPX" "12"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS3EOM0_MAPX" "12"
    SYSTEM_CONSTANT "INJCRV_TIPII1BAS3EOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOR2EOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII1ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM0_MAPY" "12"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM0_MAPY" "12"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM0_MAPX" "12"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2BASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPII2ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI1SPLT2DIFF_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_TIPOI1SPLT2DIFF_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPOI1SPLT3DIFF_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_TIPOI1SPLT3DIFF_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2APSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM0_MAPX" "10"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM0_MAPY" "10"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2BASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM0_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM0_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2ETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "INJCRV_TIPOI2MAXOFS_MAPX" "8"
    SYSTEM_CONSTANT "INJCRV_TIPOI2MAXOFS_MAPY" "8"
    SYSTEM_CONSTANT "INJCRV_TIPOI2MAX_MAP_X" "8"
    SYSTEM_CONSTANT "INJCRV_TIPOI2MAX_MAP_Y" "8"
    SYSTEM_CONSTANT "INJCRV_TIPSEHYP_MAP_X" "10"
    SYSTEM_CONSTANT "INJCRV_TIPSEHYP_MAP_Y" "8"
    SYSTEM_CONSTANT "INJCRV_TIPSE_CONST" "0"
    SYSTEM_CONSTANT "INJCRV_TIPSE_UPD" "1"
    SYSTEM_CONSTANT "INJCRV_ZR" "0"
    SYSTEM_CONSTANT "INJCTL_QLIMERR_CUR_X" "25"
    SYSTEM_CONSTANT "INJMASS_AMPCDIVLAMBDA" "10000"
    SYSTEM_CONSTANT "INJMSPRTIMEQ0P001_INVRESO" "1000"
    SYSTEM_CONSTANT "INJMSPRTIMEQ0P001_RESO" "0.001"
    SYSTEM_CONSTANT "INJMSPRTIMEQ0P001_ZERO" "0"
    SYSTEM_CONSTANT "INJSYS_CRS_MI1_ZFCEXTD" "0"
    SYSTEM_CONSTANT "INJSYS_CRS_POI1_ZFCEXTD" "0"
    SYSTEM_CONSTANT "INJSYS_CRS_POI2_ZFCEXTD" "0"
    SYSTEM_CONSTANT "INJSYS_CRS_QWC" "1"
    SYSTEM_CONSTANT "INJSYS_FACMICMBCLDSTRT_MAPX" "16"
    SYSTEM_CONSTANT "INJSYS_FACMICMBCLDSTRT_MAPY" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI1CMBMODE1_MAPX" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI1CMBMODE1_MAPY" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI1CMBMODE2_MAPX" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI1CMBMODE2_MAPY" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI1CMBMODE3_MAPX" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI1CMBMODE3_MAPY" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI2CMBMODE1_MAPX" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI2CMBMODE1_MAPY" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI2CMBMODE2_MAPX" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI2CMBMODE2_MAPY" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI2CMBMODE3_MAPX" "16"
    SYSTEM_CONSTANT "INJSYS_FACPOI2CMBMODE3_MAPY" "16"
    SYSTEM_CONSTANT "INJSYS_FLSYSDEFLATETST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_INJCRVSHOFFTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_IVPLAUSCOMPRTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_IVPLAUSCYLFBCTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_IVPLAUSRUNUPTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_LAMPRECTL_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MEUNSETPTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MI1SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONCPC1_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MONCPC3_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MONCPC4_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MONMEUN1_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MONMEUN22_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONMEUN3_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MONMEUN42_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONMEUN5_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONMEUN7_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONMEUN9_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONPCV1_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MONPCV22_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONPCV3_SY" "1"
    SYSTEM_CONSTANT "INJSYS_MONPCV42_SY" "0"
    SYSTEM_CONSTANT "INJSYS_MONTNKLO_SY" "0"
    SYSTEM_CONSTANT "INJSYS_NUMINJMAX" "8"
    SYSTEM_CONSTANT "INJSYS_NUMOPMODE_X" "3"
    SYSTEM_CONSTANT "INJSYS_NUMPOI1SPLT_SY" "2"
    SYSTEM_CONSTANT "INJSYS_NUMSTAGE_Y" "2"
    SYSTEM_CONSTANT "INJSYS_PCVACTRTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_PCVSETPTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_PII1SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_PII2SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_PII3SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_PIIRLSSETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_POI1SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_POI2EFFFUNC_SY" "0"
    SYSTEM_CONSTANT "INJSYS_POI2SETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_RAILHIPRESTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_RAILPMEASTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_RAILSETPOINT_SY" "0"
    SYSTEM_CONSTANT "INJSYS_RAILSETPTST_SY" "1"
    SYSTEM_CONSTANT "INJSYS_SWTRC" "1"
    SYSTEM_CONSTANT "INJSYS_TYPINJCTL_SY" "1"
    SYSTEM_CONSTANT "INJTIME_US_MAX" "400"
    SYSTEM_CONSTANT "INJTIME_US_MIN" "20"
    SYSTEM_CONSTANT "INJTIME_US_ZERO" "0"
    SYSTEM_CONSTANT "INJUN_FACFLMASSCNV_MAP_X" "16"
    SYSTEM_CONSTANT "INJUN_FACFLMASSCNV_MAP_Y" "16"
    SYSTEM_CONSTANT "INJVCD_TIET2_MAP_X" "16"
    SYSTEM_CONSTANT "INJVCD_TIET2_MAP_Y" "20"
    SYSTEM_CONSTANT "INJVCD_TIET3_MAP_X" "16"
    SYSTEM_CONSTANT "INJVCD_TIET3_MAP_Y" "20"
    SYSTEM_CONSTANT "INJVCD_TIET4_MAP_X" "16"
    SYSTEM_CONSTANT "INJVCD_TIET4_MAP_Y" "20"
    SYSTEM_CONSTANT "INJVCD_TIET5_MAP_X" "16"
    SYSTEM_CONSTANT "INJVCD_TIET5_MAP_Y" "20"
    SYSTEM_CONSTANT "INJVCD_TIET6_MAP_X" "16"
    SYSTEM_CONSTANT "INJVCD_TIET6_MAP_Y" "20"
    SYSTEM_CONSTANT "INJVCD_TIET_MAP_X" "16"
    SYSTEM_CONSTANT "INJVCD_TIET_MAP_Y" "20"
    SYSTEM_CONSTANT "INJVCD_TIPICKUPCURR_CUR_X" "2"
    SYSTEM_CONSTANT "INJVLV_FACADDBALRLS_MAPX" "4"
    SYSTEM_CONSTANT "INJVLV_FACADDBALRLS_MAPY" "4"
    SYSTEM_CONSTANT "INJVLV_FACPII1QNTCOR_CUR_X" "10"
    SYSTEM_CONSTANT "INJVLV_FACT1000_FL" "1000"
    SYSTEM_CONSTANT "INJVLV_FACT1000_INV_FL" "0.001"
    SYSTEM_CONSTANT "INJVLV_FACTINJDRFTCOR_MAX" "6"
    SYSTEM_CONSTANT "INJVLV_FACTINJDRFTCOR_MIN" "-4"
    SYSTEM_CONSTANT "INJVLV_FACVOLMI1CLBVAL_MAP_X" "16"
    SYSTEM_CONSTANT "INJVLV_FACVOLMI1CLBVAL_MAP_Y" "16"
    SYSTEM_CONSTANT "INJVLV_FACVOLPOI1CLBVAL_MAP_X" "16"
    SYSTEM_CONSTANT "INJVLV_FACVOLPOI1CLBVAL_MAP_Y" "16"
    SYSTEM_CONSTANT "INJVLV_FACVOLPOI2CLBVAL_MAP_X" "16"
    SYSTEM_CONSTANT "INJVLV_FACVOLPOI2CLBVAL_MAP_Y" "16"
    SYSTEM_CONSTANT "INJVLV_MI1" "2"
    SYSTEM_CONSTANT "INJVLV_MI2" "3"
    SYSTEM_CONSTANT "INJVLV_NUMINJCHRGBAL_MAPX" "25"
    SYSTEM_CONSTANT "INJVLV_NUMINJCHRGBAL_MAPY" "10"
    SYSTEM_CONSTANT "INJVLV_NUM_BNK" "1"
    SYSTEM_CONSTANT "INJVLV_NUM_BUFVLTG" "1"
    SYSTEM_CONSTANT "INJVLV_NUM_BUF_PER_ADCCHN" "1"
    SYSTEM_CONSTANT "INJVLV_NUM_CHIPS" "1"
    SYSTEM_CONSTANT "INJVLV_NUM_INJ_PLC" "10"
    SYSTEM_CONSTANT "INJVLV_PII1" "4"
    SYSTEM_CONSTANT "INJVLV_PII2" "5"
    SYSTEM_CONSTANT "INJVLV_PII3" "6"
    SYSTEM_CONSTANT "INJVLV_PII4" "7"
    SYSTEM_CONSTANT "INJVLV_PMIN_CURX" "8"
    SYSTEM_CONSTANT "INJVLV_POI1" "0"
    SYSTEM_CONSTANT "INJVLV_POI2" "1"
    SYSTEM_CONSTANT "INJVLV_POI2EFF" "8"
    SYSTEM_CONSTANT "INJVLV_PRAILZFCETCOR_AXISX" "6"
    SYSTEM_CONSTANT "INJVLV_QNTINJDRFTCOR_MAX" "10"
    SYSTEM_CONSTANT "INJVLV_QNTINJDRFTCOR_MIN" "-10"
    SYSTEM_CONSTANT "INJVLV_QZFCETCOR_AXISX" "6"
    SYSTEM_CONSTANT "INJVLV_RATINJDUR_RES" "1024"
    SYSTEM_CONSTANT "INJVLV_RMI1TCSC_CURX" "16"
    SYSTEM_CONSTANT "INJVLV_SEL_MI1" "6"
    SYSTEM_CONSTANT "INJVLV_SEL_MI1PII1" "7"
    SYSTEM_CONSTANT "INJVLV_SEL_MI1PII1PII2" "8"
    SYSTEM_CONSTANT "INJVLV_SEL_MI1PII1PII3" "9"
    SYSTEM_CONSTANT "INJVLV_SEL_MI1_ESTET" "3"
    SYSTEM_CONSTANT "INJVLV_SEL_PII1" "10"
    SYSTEM_CONSTANT "INJVLV_SEL_PII1PII2" "11"
    SYSTEM_CONSTANT "INJVLV_SEL_PII1_ESTET" "0"
    SYSTEM_CONSTANT "INJVLV_SEL_PII2" "12"
    SYSTEM_CONSTANT "INJVLV_SEL_PII2_ESTET" "1"
    SYSTEM_CONSTANT "INJVLV_SEL_PII3" "13"
    SYSTEM_CONSTANT "INJVLV_SEL_PII3_ESTET" "2"
    SYSTEM_CONSTANT "INJVLV_SEL_POI1" "14"
    SYSTEM_CONSTANT "INJVLV_SEL_POI1_ESTET" "4"
    SYSTEM_CONSTANT "INJVLV_SEL_POI2" "15"
    SYSTEM_CONSTANT "INJVLV_SEL_POI2_ESTET" "5"
    SYSTEM_CONSTANT "INJVLV_STCHAININTR_SY" "0"
    SYSTEM_CONSTANT "INJVLV_TCTLINJ" "63"
    SYSTEM_CONSTANT "INJVLV_TIET2_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIET2_MAPY" "20"
    SYSTEM_CONSTANT "INJVLV_TIET3_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIET3_MAPY" "20"
    SYSTEM_CONSTANT "INJVLV_TIET4_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIET4_MAPY" "20"
    SYSTEM_CONSTANT "INJVLV_TIET5_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIET5_MAPY" "20"
    SYSTEM_CONSTANT "INJVLV_TIET6_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIET6_MAPY" "20"
    SYSTEM_CONSTANT "INJVLV_TIET_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIET_MAPY" "20"
    SYSTEM_CONSTANT "INJVLV_TIMI1CSCMAX_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIMI1CSCMAX_MAPY" "16"
    SYSTEM_CONSTANT "INJVLV_TIMI1CSCMIN_MAPX" "16"
    SYSTEM_CONSTANT "INJVLV_TIMI1CSCMIN_MAPY" "16"
    SYSTEM_CONSTANT "INJVLV_TIMI1CSC_CURX" "16"
    SYSTEM_CONSTANT "INJVLV_TIOFSSOEHYD_CUR_X" "16"
    SYSTEM_CONSTANT "INJVLV_TIPICKUPCURR_CURX" "2"
    SYSTEM_CONSTANT "INJVLV_VOLMI1INJDRFTCORMAX_CUR_X" "25"
    SYSTEM_CONSTANT "INJVLV_VOLMI1INJDRFTCORMIN_CUR_X" "25"
    SYSTEM_CONSTANT "INJVLV_VOLMI1INJDRFTCOR_MAP_X" "16"
    SYSTEM_CONSTANT "INJVLV_VOLMI1INJDRFTCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "INJVLV_VOLPOI1INJDRFTCORMAX_CUR_X" "25"
    SYSTEM_CONSTANT "INJVLV_VOLPOI1INJDRFTCORMIN_CUR_X" "25"
    SYSTEM_CONSTANT "INJVLV_VOLPOI1INJDRFTCOR_MAP_X" "16"
    SYSTEM_CONSTANT "INJVLV_VOLPOI1INJDRFTCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "INJVLV_VOLPOI2INJDRFTCORMAX_CUR_X" "25"
    SYSTEM_CONSTANT "INJVLV_VOLPOI2INJDRFTCORMIN_CUR_X" "25"
    SYSTEM_CONSTANT "INJVLV_VOLPOI2INJDRFTCOR_MAP_X" "16"
    SYSTEM_CONSTANT "INJVLV_VOLPOI2INJDRFTCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "INJVLV_ZFC" "9"
    SYSTEM_CONSTANT "INJ_MASS100_MAX" "100"
    SYSTEM_CONSTANT "INJ_MASSCYC_MAX" "327.67"
    SYSTEM_CONSTANT "INJ_MASSCYC_MIN" "0"
    SYSTEM_CONSTANT "INJ_MASSCYC_RES" "0.01"
    SYSTEM_CONSTANT "INJ_MASSCYC_RES_INV" "100"
    SYSTEM_CONSTANT "INJ_MASSCYC_RES_REV" "100"
    SYSTEM_CONSTANT "INJ_MASSCYC_ZERO" "0"
    SYSTEM_CONSTANT "INJ_MASSETCTL_MAX" "200"
    SYSTEM_CONSTANT "INJ_MASSETCTL_MIN" "-200"
    SYSTEM_CONSTANT "INJ_MASSINJ_MAX" "327.67"
    SYSTEM_CONSTANT "INJ_MASSINJ_MIN" "0"
    SYSTEM_CONSTANT "INJ_MASSINJ_RES" "0.01"
    SYSTEM_CONSTANT "INJ_MASSINJ_RES_REV" "100"
    SYSTEM_CONSTANT "INJ_MASSMIN_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPII1_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPII2_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPII3_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPOI1_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASSPOI2_MAX" "10"
    SYSTEM_CONSTANT "INJ_MASS_01_RES_RSA" "0.1"
    SYSTEM_CONSTANT "INJ_MASS_ETCTL" "0.1"
    SYSTEM_CONSTANT "INJ_MASS_MAX" "327.67"
    SYSTEM_CONSTANT "INJ_MASS_MIN" "0"
    SYSTEM_CONSTANT "INJ_MASS_ONE" "1"
    SYSTEM_CONSTANT "INJ_MASS_RES" "0.01"
    SYSTEM_CONSTANT "INJ_MASS_RES_FL" "0.01"
    SYSTEM_CONSTANT "INJ_MASS_RES_FL_1" "0.01"
    SYSTEM_CONSTANT "INJ_MASS_RES_INV" "100"
    SYSTEM_CONSTANT "INJ_MASS_RES_INV_FL" "100"
    SYSTEM_CONSTANT "INJ_MASS_RES_RSA" "0.01"
    SYSTEM_CONSTANT "INJ_MASS_ZERO" "0"
    SYSTEM_CONSTANT "INJ_QNTINJ_MAX" "100"
    SYSTEM_CONSTANT "INJ_QNTINJ_MIN" "0"
    SYSTEM_CONSTANT "INJ_QNTINJ_RES" "0.01"
    SYSTEM_CONSTANT "INJ_QNTINJ_ZERO" "0"
    SYSTEM_CONSTANT "INJ_QNT_RES" "0.1"
    SYSTEM_CONSTANT "INJ_TIME_RES_RSA" "1"
    SYSTEM_CONSTANT "INTAMP_FAC_RES" "0.001"
    SYSTEM_CONSTANT "IVACTR_SWTSELTEMP_CLNT" "0"
    SYSTEM_CONSTANT "IVACTR_SWTSELTEMP_FUEL" "1"
    SYSTEM_CONSTANT "IVADJ_NUMCHKPNT" "5"
    SYSTEM_CONSTANT "IVADJ_NUMREPLVAL" "12"
    SYSTEM_CONSTANT "IVADJ_STQNTADJ_MAPX" "6"
    SYSTEM_CONSTANT "IVADJ_STQNTADJ_MAPY" "8"
    SYSTEM_CONSTANT "IVDIA_DFCBNKSHCIR" "5"
    SYSTEM_CONSTANT "IVDIA_DFCBNKSHCIRCHSWT" "4"
    SYSTEM_CONSTANT "IVDIA_DFCCHP" "6"
    SYSTEM_CONSTANT "IVDIA_DFCCYLNOCLS" "7"
    SYSTEM_CONSTANT "IVDIA_DFCCYLNOLD" "1"
    SYSTEM_CONSTANT "IVDIA_DFCCYLSHCIR" "2"
    SYSTEM_CONSTANT "IVDIA_DFCCYLSHCIRHSLS" "0"
    SYSTEM_CONSTANT "IVDIA_DFCCYLSHCIRMEAS" "3"
    SYSTEM_CONSTANT "IVDIA_ERR_MAX" "32"
    SYSTEM_CONSTANT "IVDIA_NUMCYLDFC" "4"
    SYSTEM_CONSTANT "IVPLAUS_MODERUNUPTST" "0"
    SYSTEM_CONSTANT "IVPLAUS_WAIT_TIME_COMPR_TST" "1000"
    SYSTEM_CONSTANT "I_COIL_MAX" "5000"
    SYSTEM_CONSTANT "I_COIL_MIN" "0"
    SYSTEM_CONSTANT "JUL_RES" "0.1"
    SYSTEM_CONSTANT "KD_10" "10"
    SYSTEM_CONSTANT "KD_1_MAX" "50"
    SYSTEM_CONSTANT "KD_1_NRM" "7"
    SYSTEM_CONSTANT "KD_LIN_16_RES" "32767"
    SYSTEM_CONSTANT "KD_MIN" "0"
    SYSTEM_CONSTANT "KD_PRAIL2Q_1_MAX" "0.5"
    SYSTEM_CONSTANT "KD_PRAIL2Q_1_NRM" "4"
    SYSTEM_CONSTANT "KD_RES16_REV" "1024"
    SYSTEM_CONSTANT "KD_RES_LOW_REV" "256"
    SYSTEM_CONSTANT "KD_RES_REV" "65536"
    SYSTEM_CONSTANT "KFACT_MAX" "1"
    SYSTEM_CONSTANT "KFACT_MIN" "0"
    SYSTEM_CONSTANT "KGH_TO_KGS" "3600"
    SYSTEM_CONSTANT "KGPHR2MGPSEC" "277.77"
    SYSTEM_CONSTANT "KGPHR2MGPSEC_CNV" "27777"
    SYSTEM_CONSTANT "KG_0001_RSA_RES" "0.0001"
    SYSTEM_CONSTANT "KIRMNSOTMS_INVRESO_SY" "2"
    SYSTEM_CONSTANT "KIRMNSOTMS_NRMEXPO_SY" "1"
    SYSTEM_CONSTANT "KI_100" "100"
    SYSTEM_CONSTANT "KI_1000" "1000"
    SYSTEM_CONSTANT "KI_1_MAX" "250"
    SYSTEM_CONSTANT "KI_1_NRM" "5"
    SYSTEM_CONSTANT "KI_ACTR_RES_REV" "65"
    SYSTEM_CONSTANT "KI_BPA1_RES_REV" "1"
    SYSTEM_CONSTANT "KI_BPA_RES_REV" "65"
    SYSTEM_CONSTANT "KI_EGR_RES_REV" "5368.70912"
    SYSTEM_CONSTANT "KI_EGTFACT_EXP" "1"
    SYSTEM_CONSTANT "KI_EGTFACT_NRM" "2"
    SYSTEM_CONSTANT "KI_ETCTLGOV_FAC_MAX" "0.06"
    SYSTEM_CONSTANT "KI_ETCTLGOV_FAC_MIN" "0"
    SYSTEM_CONSTANT "KI_ETCTLGOV_P0Q001_EXP" "1"
    SYSTEM_CONSTANT "KI_ETCTLGOV_P0Q001_NRM" "2"
    SYSTEM_CONSTANT "KI_ETCTL_MAX" "100"
    SYSTEM_CONSTANT "KI_ETCTL_MIN" "0"
    SYSTEM_CONSTANT "KI_EXHFLPLP_RES_REV" "65"
    SYSTEM_CONSTANT "KI_FACTEGT_MAX" "0.06"
    SYSTEM_CONSTANT "KI_FACTEGT_MIN" "0"
    SYSTEM_CONSTANT "KI_LAMCTL_RES" "0.003814697265625"
    SYSTEM_CONSTANT "KI_LAMCTL_RES_REV" "262.144"
    SYSTEM_CONSTANT "KI_MIN" "0"
    SYSTEM_CONSTANT "KI_MSOOT_RES_REV" "819"
    SYSTEM_CONSTANT "KI_PRAIL2Q_1_MAX" "2"
    SYSTEM_CONSTANT "KI_PRAIL2Q_1_NRM" "1"
    SYSTEM_CONSTANT "KI_PRCEGRRMP2PRC_ONE" "1"
    SYSTEM_CONSTANT "KI_RES_REV" "2147.483648"
    SYSTEM_CONSTANT "KI_THRVLV_RES_REV" "65"
    SYSTEM_CONSTANT "KMPH2CMPS" "27.7777777777778"
    SYSTEM_CONSTANT "KMPH2CMPS_1" "1000"
    SYSTEM_CONSTANT "KMPH2CMPS_2" "36"
    SYSTEM_CONSTANT "KM_16_RSA_RES" "0.0625"
    SYSTEM_CONSTANT "KM_16_RSA_RES_REV" "16"
    SYSTEM_CONSTANT "KM_2_RSA_RES" "0.5"
    SYSTEM_CONSTANT "KP_10" "10"
    SYSTEM_CONSTANT "KP_1_MAX" "300"
    SYSTEM_CONSTANT "KP_1_NRM" "9"
    SYSTEM_CONSTANT "KP_EGTFACT_EXP" "7"
    SYSTEM_CONSTANT "KP_EGTFACT_RES_REV" "128"
    SYSTEM_CONSTANT "KP_ETCTLGOV_FAC_MAX" "0.06"
    SYSTEM_CONSTANT "KP_ETCTLGOV_FAC_MIN" "0"
    SYSTEM_CONSTANT "KP_ETCTLGOV_P0Q001_EXP" "7"
    SYSTEM_CONSTANT "KP_ETCTLGOV_P0Q001_RES_REV" "128"
    SYSTEM_CONSTANT "KP_ETCTL_MAX" "4"
    SYSTEM_CONSTANT "KP_ETCTL_MIN" "0"
    SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_MAX" "250"
    SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_NRM" "2"
    SYSTEM_CONSTANT "KP_LMBDREC2INJMASS_1_RES_REV" "4"
    SYSTEM_CONSTANT "KP_MIN" "0"
    SYSTEM_CONSTANT "KP_PRAIL2Q_1_MAX" "0.2"
    SYSTEM_CONSTANT "KP_PRAIL2Q_1_NRM" "2"
    SYSTEM_CONSTANT "KP_RES_LOW_REV" "128"
    SYSTEM_CONSTANT "KP_RES_REV" "32768"
    SYSTEM_CONSTANT "K_CURVE_PRCVOLT_RES_REV" "1000"
    SYSTEM_CONSTANT "LAMBDAREC_ONE" "1"
    SYSTEM_CONSTANT "LAMBDAREC_RES" "0.0001"
    SYSTEM_CONSTANT "LAMBDAREC_RESVAL" "0.001"
    SYSTEM_CONSTANT "LAMBDAREC_RESVAL_FL" "0.001"
    SYSTEM_CONSTANT "LAMBDAREC_RESVAL_REV" "1000"
    SYSTEM_CONSTANT "LAMBDAREC_RESVAL_RSA" "0.001"
    SYSTEM_CONSTANT "LAMBDAREC_RES_REV" "10000"
    SYSTEM_CONSTANT "LAMBDATEMPRESREV_SY" "1000"
    SYSTEM_CONSTANT "LAMBDA_DIFFQUOT_RES" "0.05"
    SYSTEM_CONSTANT "LAMBDA_DIFFQUOT_RES_INV" "20"
    SYSTEM_CONSTANT "LAMBDA_INJMASS_RES" "1450"
    SYSTEM_CONSTANT "LAMBDA_MAX" "30"
    SYSTEM_CONSTANT "LAMBDA_MIN" "0"
    SYSTEM_CONSTANT "LAMBDA_ONE" "1"
    SYSTEM_CONSTANT "LAMBDA_RES" "0.001"
    SYSTEM_CONSTANT "LAMBDA_RES2LAMBDAREC_RES" "10"
    SYSTEM_CONSTANT "LAMBDA_RES_REV" "1000"
    SYSTEM_CONSTANT "LAMBDA_TEN" "10"
    SYSTEM_CONSTANT "LAMBDA_ZERO" "0"
    SYSTEM_CONSTANT "LAMCTLDESVAL_NUM" "2"
    SYSTEM_CONSTANT "LAMCTLGOV_NUM" "2"
    SYSTEM_CONSTANT "LAMCTLMON_DVT_MAX" "10"
    SYSTEM_CONSTANT "LAMCTLMON_NUM_RM" "2"
    SYSTEM_CONSTANT "LAMCTLMON_TIME_MAX" "20"
    SYSTEM_CONSTANT "LAMCTLPRECTL_NUM" "2"
    SYSTEM_CONSTANT "LAMCTL_DFL" "0"
    SYSTEM_CONSTANT "LAMCTL_NUMGOVENBLMSK_SY" "2"
    SYSTEM_CONSTANT "LAMCTL_NUMPFLTRGNMSK_SY" "2"
    SYSTEM_CONSTANT "LAMCTL_NUMPRECTLENBLMSK_SY" "2"
    SYSTEM_CONSTANT "LAMCTL_RATADAPTCONST_SY" "0.04"
    SYSTEM_CONSTANT "LAMCTL_SWTACTV_BP" "0"
    SYSTEM_CONSTANT "LEARN" "3"
    SYSTEM_CONSTANT "LENGTHFINE_RES" "0.001"
    SYSTEM_CONSTANT "LENGTHFINE_RES_FL" "0.001"
    SYSTEM_CONSTANT "LENGTHKM1_MAX" "1000"
    SYSTEM_CONSTANT "LENGTHKM1_MIN" "0"
    SYSTEM_CONSTANT "LENGTHKM1_RES" "1"
    SYSTEM_CONSTANT "LENGTHKM1_RES_REV" "1"
    SYSTEM_CONSTANT "LENGTH_KM2M" "1000"
    SYSTEM_CONSTANT "LENGTH_KM_RES" "20"
    SYSTEM_CONSTANT "LENGTH_RES" "1"
    SYSTEM_CONSTANT "LENGTH_RES_CPP_SY" "1e-005"
    SYSTEM_CONSTANT "LENGTH_RES_FINE" "0.001"
    SYSTEM_CONSTANT "LENGTH_RES_FINE_REV" "1000"
    SYSTEM_CONSTANT "LENGTH_RES_INV" "1"
    SYSTEM_CONSTANT "LENGTH_RES_REV" "1"
    SYSTEM_CONSTANT "LENGTH_ZERO_KM" "0"
    SYSTEM_CONSTANT "LSU_CT_SENSORS" "1"
    SYSTEM_CONSTANT "LSU_CT_SENSORS_MAX" "4"
    SYSTEM_CONSTANT "LSU_CT_SENSORS_SY" "1"
    SYSTEM_CONSTANT "LSU_CT_SENSORS_TWFLW_SYS" "1"
    SYSTEM_CONSTANT "LSU_DT1_RES" "4294.967296"
    SYSTEM_CONSTANT "LSU_FSTLRN" "25"
    SYSTEM_CONSTANT "LSU_NUM_SENSCMPCHKS" "0"
    SYSTEM_CONSTANT "LSU_PRESCOMPADAP_SY" "1"
    SYSTEM_CONSTANT "LSU_PRES_ENV" "1013"
    SYSTEM_CONSTANT "LSU_TEMPCOMP_NORM" "100"
    SYSTEM_CONSTANT "LSU_UHTPERFBATTMIN_MAP_X" "25"
    SYSTEM_CONSTANT "LSU_UHTPERFBATTMIN_MAP_Y" "25"
    SYSTEM_CONSTANT "LUB_CRITOILLVLMSK_SY" "2"
    SYSTEM_CONSTANT "LUB_DMFLADDBAS_MAP_X" "16"
    SYSTEM_CONSTANT "LUB_DMFLADDBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "LUB_DMFLEVPBAS_MAP_X" "16"
    SYSTEM_CONSTANT "LUB_DMFLEVPBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "LUB_DMFLOILRMVBAS_MAP_X" "16"
    SYSTEM_CONSTANT "LUB_DMFLOILRMVBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "LUB_FACFLADDTEMPENG_CUR_X" "8"
    SYSTEM_CONSTANT "LUB_FACFLEVPTEMP_CUR_X" "8"
    SYSTEM_CONSTANT "LUB_FACFLOILRMVMS_CUR_X" "8"
    SYSTEM_CONSTANT "LUB_FACFLOILRMVTEMP_CUR_X" "8"
    SYSTEM_CONSTANT "LUB_MLVL2MS_MAP_X" "16"
    SYSTEM_CONSTANT "LUB_MLVL2MS_MAP_Y" "16"
    SYSTEM_CONSTANT "MASS2TEMP_Q0P1000003_RES" "3e-006"
    SYSTEM_CONSTANT "MASS2TEMP_Q0P1000003_RES_REV" "333333.333333333"
    SYSTEM_CONSTANT "MASSLENGTH_RES" "0.2"
    SYSTEM_CONSTANT "MASSPERTIMEQ0P001_RES" "0.001"
    SYSTEM_CONSTANT "MASSPERTIMEQ0P001_RES_REV" "1000"
    SYSTEM_CONSTANT "MASS_CONV_G2MG" "1000"
    SYSTEM_CONSTANT "MASS_CONV_KG2G" "1000"
    SYSTEM_CONSTANT "MASS_MOL_EG" "28.5"
    SYSTEM_CONSTANT "MASS_Q1_RES" "1"
    SYSTEM_CONSTANT "MASS_Q1_RES_REV" "1"
    SYSTEM_CONSTANT "MASS_RES" "1"
    SYSTEM_CONSTANT "MAXSINT16" "32767"
    SYSTEM_CONSTANT "MAXSINT32" "2147483647"
    SYSTEM_CONSTANT "MAXSINT8" "127"
    SYSTEM_CONSTANT "MAXUINT16" "65535"
    SYSTEM_CONSTANT "MAXUINT32" "4294967295"
    SYSTEM_CONSTANT "MAXUINT8" "255"
    SYSTEM_CONSTANT "MEUN_AVRG_COUNT_SY" "3"
    SYSTEM_CONSTANT "MEUN_FACCRNTCTLINIT_CURX" "6"
    SYSTEM_CONSTANT "MEUN_ICNVFLOWRATE_CURX" "10"
    SYSTEM_CONSTANT "MEUN_ILIN_CURX" "2"
    SYSTEM_CONSTANT "MEUN_RLIM_CURX" "2"
    SYSTEM_CONSTANT "MEUN_RSETLIN_CURX" "4"
    SYSTEM_CONSTANT "MEUN_SPEED_COUNT_SY" "4"
    SYSTEM_CONSTANT "MEUN_TIPER_CURX" "30"
    SYSTEM_CONSTANT "MINSINT16" "-32768"
    SYSTEM_CONSTANT "MINSINT32" "-2147483648"
    SYSTEM_CONSTANT "MINSINT8" "-128"
    SYSTEM_CONSTANT "MM3_RSA_RES" "0.0125"
    SYSTEM_CONSTANT "MOCCPU_FIT_SY" "0"
    SYSTEM_CONSTANT "MOCCPU_IPOTST_CURX" "20"
    SYSTEM_CONSTANT "MOCMEM_DATA_CHECK" "13"
    SYSTEM_CONSTANT "MOCMEM_DATA_DME_SY" "13"
    SYSTEM_CONSTANT "MOCMEM_DATA_ROM_SY" "10"
    SYSTEM_CONSTANT "MOCMEM_DATA_USAP_MEDC17_OFFSET_SY" "11"
    SYSTEM_CONSTANT "MOCMEM_DATA_USAP_MEDC17_R9_SY" "12"
    SYSTEM_CONSTANT "MOCRAM_PROTRAMCLEARED" "51"
    SYSTEM_CONSTANT "MOCRAM_PROTRAMNOTCLEARED" "204"
    SYSTEM_CONSTANT "MOCSOP_CJ840AT_SY" "0"
    SYSTEM_CONSTANT "MOCSOP_CJ840_SY" "0"
    SYSTEM_CONSTANT "MOCSOP_GET_STATUS_FAIL" "255"
    SYSTEM_CONSTANT "MOCSOP_POWERSTAGE_OFF_SY" "0"
    SYSTEM_CONSTANT "MOCSOP_POWERSTAGE_ON_SY" "1"
    SYSTEM_CONSTANT "MOCSOP_TSTMPENBL_SY" "1"
    SYSTEM_CONSTANT "MOFACS_FACALTTCOMP_CURX" "4"
    SYSTEM_CONSTANT "MOFACS_RTRQAC_CURX" "4"
    SYSTEM_CONSTANT "MOFACS_RTRQALT_CURX" "4"
    SYSTEM_CONSTANT "MOFACS_RTRQCOMP_CURX" "4"
    SYSTEM_CONSTANT "MOFACS_RTRQLDTEMPDEPLIM_CURX" "4"
    SYSTEM_CONSTANT "MOFCOENG_RTRQADDOVRSHOFF_MAPX" "8"
    SYSTEM_CONSTANT "MOFCOENG_RTRQADDOVRSHOFF_MAPY" "8"
    SYSTEM_CONSTANT "MOFCOENG_RTRQLOS_MAPX" "8"
    SYSTEM_CONSTANT "MOFCOENG_RTRQLOS_MAPY" "8"
    SYSTEM_CONSTANT "MOFCOOFS_RTRQPTDOFS_MAPX" "8"
    SYSTEM_CONSTANT "MOFCOOFS_RTRQPTDOFS_MAPY" "8"
    SYSTEM_CONSTANT "MOFCOVEH_FACCOMPTOT_CURX" "6"
    SYSTEM_CONSTANT "MOFCOVEH_FACTRQCOMP_MAPX" "6"
    SYSTEM_CONSTANT "MOFCOVEH_FACTRQCOMP_MAPY" "6"
    SYSTEM_CONSTANT "MOFDRDEM_RTRQENG_MAPX" "8"
    SYSTEM_CONSTANT "MOFDRDEM_RTRQENG_MAPY" "8"
    SYSTEM_CONSTANT "MOFEXTINT_DCSPTD_BP" "1"
    SYSTEM_CONSTANT "MOFEXTINT_TSCPTD_BP" "1"
    SYSTEM_CONSTANT "MOFINJDAT_FACINJEFF_MAPX" "6"
    SYSTEM_CONSTANT "MOFINJDAT_FACINJEFF_MAPY" "4"
    SYSTEM_CONSTANT "MOFINJDAT_FACINJEFF_MAP_X" "6"
    SYSTEM_CONSTANT "MOFINJDAT_FACINJEFF_MAP_Y" "4"
    SYSTEM_CONSTANT "MOFINJDAT_PLIN_CURX" "4"
    SYSTEM_CONSTANT "MOFINJQNT_STQNTADJ_MAPX" "8"
    SYSTEM_CONSTANT "MOFINJQNT_STQNTADJ_MAPY" "7"
    SYSTEM_CONSTANT "MOFINJQNT_TIZFCETMAX_CURX" "6"
    SYSTEM_CONSTANT "MOFINJQNT_TIZFCETMIN_CURX" "6"
    SYSTEM_CONSTANT "MOFINJQNT_VOL_MAPX" "25"
    SYSTEM_CONSTANT "MOFINJQNT_VOL_MAPY" "16"
    SYSTEM_CONSTANT "MOFLOS_RTRQENGLOS_MAPX" "8"
    SYSTEM_CONSTANT "MOFLOS_RTRQENGLOS_MAPY" "8"
    SYSTEM_CONSTANT "MOFMODE_FACMAX_CURX" "4"
    SYSTEM_CONSTANT "MOFMODE_FACMIN_CURX" "4"
    SYSTEM_CONSTANT "MOFMODE_PHIPOI2_MAPX" "8"
    SYSTEM_CONSTANT "MOFMODE_PHIPOI2_MAPY" "8"
    SYSTEM_CONSTANT "MOFOVR_TILIMET_CURX" "4"
    SYSTEM_CONSTANT "MOFOVR_TILIMET_MAP_X" "6"
    SYSTEM_CONSTANT "MOFOVR_TILIMET_MAP_Y" "6"
    SYSTEM_CONSTANT "MOFQNTCOR_FACFTSWCOR_MAPX" "8"
    SYSTEM_CONSTANT "MOFQNTCOR_FACFTSWCOR_MAPY" "16"
    SYSTEM_CONSTANT "MOFQNTCOR_FACWVCOR1_MAPX" "20"
    SYSTEM_CONSTANT "MOFQNTCOR_FACWVCOR1_MAPY" "20"
    SYSTEM_CONSTANT "MOFQNTCOR_FACWVCOR2_MAPX" "20"
    SYSTEM_CONSTANT "MOFQNTCOR_FACWVCOR2_MAPY" "20"
    SYSTEM_CONSTANT "MOFQNTCOR_QWVCOR1_MAPX" "4"
    SYSTEM_CONSTANT "MOFQNTCOR_QWVCOR1_MAPY" "32"
    SYSTEM_CONSTANT "MOFQNTCOR_QWVCOR2_MAPX" "6"
    SYSTEM_CONSTANT "MOFQNTCOR_QWVCOR2_MAPY" "49"
    SYSTEM_CONSTANT "MOFQNTCOR_QWVCORNORM_CURX" "14"
    SYSTEM_CONSTANT "MOFQNTCOR_TIDIFFHYD_MAPX" "16"
    SYSTEM_CONSTANT "MOFQNTCOR_TIDIFFHYD_MAPY" "10"
    SYSTEM_CONSTANT "MOFSPDG_RTRQMAX_MAPX" "6"
    SYSTEM_CONSTANT "MOFSPDG_RTRQMAX_MAPY" "6"
    SYSTEM_CONSTANT "MOFSPDG_RTRQPTD_MAPX" "6"
    SYSTEM_CONSTANT "MOFSPDG_RTRQPTD_MAPY" "6"
    SYSTEM_CONSTANT "MOFTENG_TIMINTEMPINI_CURX" "8"
    SYSTEM_CONSTANT "MOFTENG_TMIN_CURX" "8"
    SYSTEM_CONSTANT "MOFTRQIDC_Q2TRQ2_MAPX" "16"
    SYSTEM_CONSTANT "MOFTRQIDC_Q2TRQ2_MAPY" "16"
    SYSTEM_CONSTANT "MOFTRQIDC_Q2TRQ_MAPX" "16"
    SYSTEM_CONSTANT "MOFTRQIDC_Q2TRQ_MAPY" "16"
    SYSTEM_CONSTANT "MOIINJDAT_FACINJEFF_MAPX" "3"
    SYSTEM_CONSTANT "MOIINJDAT_FACINJEFF_MAPY" "3"
    SYSTEM_CONSTANT "MOIINJDAT_PLIN_CURX" "3"
    SYSTEM_CONSTANT "MOIOVR_CTDEBAPP_CAX" "8"
    SYSTEM_CONSTANT "MOIOVR_TILIMET_CURX" "4"
    SYSTEM_CONSTANT "MOLMASS_RES" "0.01"
    SYSTEM_CONSTANT "MO_CTDEBCTR_U16_SY" "2"
    SYSTEM_CONSTANT "MO_CTDEBCTR_U8_SY" "21"
    SYSTEM_CONSTANT "MO_PRCMAX_SY" "256"
    SYSTEM_CONSTANT "MO_ROM_SY" "0"
    SYSTEM_CONSTANT "MO_ROOM_RES_SY" "256"
    SYSTEM_CONSTANT "MSPERVOL_RES" "0.001"
    SYSTEM_CONSTANT "MSPERVOL_RES_REV" "1000"
    SYSTEM_CONSTANT "MSQ0P01_INVRESO" "100"
    SYSTEM_CONSTANT "MSQ0P01_RESO" "0.01"
    SYSTEM_CONSTANT "MS_G2MG" "1000"
    SYSTEM_CONSTANT "MS_NOX_MIN" "0"
    SYSTEM_CONSTANT "MS_O2_FINE_RES" "1e-005"
    SYSTEM_CONSTANT "MS_O2_FINE_RES_REV" "100000"
    SYSTEM_CONSTANT "MS_O2_RES" "0.001"
    SYSTEM_CONSTANT "MS_O2_RES_REV" "1000"
    SYSTEM_CONSTANT "MS_RDCAGT_MIN" "0"
    SYSTEM_CONSTANT "MS_SOXLDTOT_RES" "0.5"
    SYSTEM_CONSTANT "MS_SOXLDTOT_RES_FL" "0.5"
    SYSTEM_CONSTANT "MS_SOXLDTOT_RES_REV" "2"
    SYSTEM_CONSTANT "MS_SOXLDUNLD_RES" "3.0517578125"
    SYSTEM_CONSTANT "MS_SOXLDUNLD_RES_FL" "3.0517578125"
    SYSTEM_CONSTANT "MS_SOXNOX_RES" "1e-005"
    SYSTEM_CONSTANT "MS_SOXNOX_RES_FL" "1e-005"
    SYSTEM_CONSTANT "MS_SOXNOX_RES_REV" "100000"
    SYSTEM_CONSTANT "MS_SOX_RES" "0.000305"
    SYSTEM_CONSTANT "MUL_INJTIME_US" "5"
    SYSTEM_CONSTANT "M_001_RSA_RES" "1000"
    SYSTEM_CONSTANT "M_NOXLD_LORES_MAX" "100"
    SYSTEM_CONSTANT "M_NOXLD_LORES_MIN" "0"
    SYSTEM_CONSTANT "M_NOXLD_LORES_RES" "0.004"
    SYSTEM_CONSTANT "M_NOXLD_LORES_RES_REV" "250"
    SYSTEM_CONSTANT "M_NOXLD_RES" "1e-005"
    SYSTEM_CONSTANT "M_NOXLD_RES_REV" "100000"
    SYSTEM_CONSTANT "M_NOXMSSOX_RES" "0.00030517578125"
    SYSTEM_CONSTANT "M_NOXMSSOX_RES_REV" "3276.8"
    SYSTEM_CONSTANT "M_OILASH_RES" "0.01"
    SYSTEM_CONSTANT "M_SOOT_MAX" "300"
    SYSTEM_CONSTANT "M_SOOT_MIN" "0"
    SYSTEM_CONSTANT "M_SOOT_RES" "0.01"
    SYSTEM_CONSTANT "M_SOOT_RES1" "0.004"
    SYSTEM_CONSTANT "M_SOOT_RES1_REV" "250"
    SYSTEM_CONSTANT "NEUTVAL_S16" "-32768"
    SYSTEM_CONSTANT "NEUTVAL_S32" "-2147483648"
    SYSTEM_CONSTANT "NEUTVAL_S8" "-128"
    SYSTEM_CONSTANT "NEUTVAL_U16" "65534"
    SYSTEM_CONSTANT "NEUTVAL_U32" "4294967294"
    SYSTEM_CONSTANT "NEUTVAL_U8" "254"
    SYSTEM_CONSTANT "NORM_ACC2TRQPRPHIGH" "500"
    SYSTEM_CONSTANT "NORM_AIRMASS_INJCRV_FACT1" "1280"
    SYSTEM_CONSTANT "NORM_DVOLPERSTRK_X_N" "6666.66666666667"
    SYSTEM_CONSTANT "NORM_DVOL_ML" "3600"
    SYSTEM_CONSTANT "NORM_DVOL_X_DT" "360000"
    SYSTEM_CONSTANT "NORM_ENGN2RMPENGN" "3276.8"
    SYSTEM_CONSTANT "NORM_FANSPD2RELFANSPD" "8192"
    SYSTEM_CONSTANT "NORM_HCMPTQ0P00000042HCMPT" "4"
    SYSTEM_CONSTANT "NORM_HCMPTQ0P82HCMPT" "8"
    SYSTEM_CONSTANT "NORM_LMBD_RES" "0.00145"
    SYSTEM_CONSTANT "NORM_MNOXLOAD2LR" "400"
    SYSTEM_CONSTANT "NORM_Q2PWR" "10644.4551086344"
    SYSTEM_CONSTANT "NORM_Q_BY_FAC" "8192"
    SYSTEM_CONSTANT "NORM_Q_BY_RHO" "1000"
    SYSTEM_CONSTANT "NORM_RATNOXM_MFLEG" "3600"
    SYSTEM_CONSTANT "NORM_RATNOXM_MFLEG_1" "36000"
    SYSTEM_CONSTANT "NORM_R_X_R" "100"
    SYSTEM_CONSTANT "NORM_R_X_TRQ" "100"
    SYSTEM_CONSTANT "NORM_SEC_US" "1000000"
    SYSTEM_CONSTANT "NORM_TEMPCONV_FACT" "10"
    SYSTEM_CONSTANT "NORM_TIME2LR" "100"
    SYSTEM_CONSTANT "NORM_TRQ2PWR" "3599.99660074774"
    SYSTEM_CONSTANT "NORM_TRQ2TRQPRP" "1600"
    SYSTEM_CONSTANT "NORM_TRQ2TRQPRPHIGH" "100"
    SYSTEM_CONSTANT "NORM_TRQACS" "1800"
    SYSTEM_CONSTANT "NORM_TRQPRPHIGH2ACC" "500"
    SYSTEM_CONSTANT "NORM_TRQTONSQR" "4000000"
    SYSTEM_CONSTANT "NORM_TRQ_BY_ETA" "1280"
    SYSTEM_CONSTANT "NORM_TRQ_BY_Q" "1280"
    SYSTEM_CONSTANT "NORM_TRQ_BY_R" "100"
    SYSTEM_CONSTANT "NORM_TRQ_INRT" "500"
    SYSTEM_CONSTANT "NORM_TRQ_X_FAC" "8192"
    SYSTEM_CONSTANT "NORM_VEL_LENGTH2ENGN" "50"
    SYSTEM_CONSTANT "NORM_VXT" "100000"
    SYSTEM_CONSTANT "NORM_W2PWR_PZOACTR" "500"
    SYSTEM_CONSTANT "NORM_WHL_RADIUS" "200"
    SYSTEM_CONSTANT "NOXFLWEG_RES" "0.025"
    SYSTEM_CONSTANT "NOXFLW_RES" "0.001"
    SYSTEM_CONSTANT "NOXFLW_RES_REV" "1000"
    SYSTEM_CONSTANT "NOXLD_FUEL_RES" "0.0001220703125"
    SYSTEM_CONSTANT "NOXLD_FUEL_RES_REV" "8192"
    SYSTEM_CONSTANT "NOXMASSFLW_RES" "0.001"
    SYSTEM_CONSTANT "NOXMASSFLW_RES_REV" "1000"
    SYSTEM_CONSTANT "NOXMPT_RES" "0.1"
    SYSTEM_CONSTANT "NOXMPT_RES_REV" "10"
    SYSTEM_CONSTANT "NOXMPT_ZERO" "0"
    SYSTEM_CONSTANT "NOX_FLD" "10"
    SYSTEM_CONSTANT "NOX_RES" "1"
    SYSTEM_CONSTANT "NOX_ZERO" "0"
    SYSTEM_CONSTANT "NO_AC" "0"
    SYSTEM_CONSTANT "NRM_DVOLPERSTRK_X_N" "6666.66666666667"
    SYSTEM_CONSTANT "NRM_DVOL_X_DT" "360000"
    SYSTEM_CONSTANT "NRM_DVOL_X_DT_HIGH" "18000"
    SYSTEM_CONSTANT "NRM_EXPO_AG_CRS_HI_RESO" "7"
    SYSTEM_CONSTANT "NRM_EXPO_T_INC_PER_DUR_HI_RESO" "8"
    SYSTEM_CONSTANT "NRM_EXP_RES_TRIGO_FUNC" "12"
    SYSTEM_CONSTANT "NRM_Q_BY_RHO" "1000"
    SYSTEM_CONSTANT "NRM_VOL_L_TO_UL" "20"
    SYSTEM_CONSTANT "NSCDS_CT_SENSORS" "1"
    SYSTEM_CONSTANT "NSCLD_FACNOXRDCBAS_MAP_X" "8"
    SYSTEM_CONSTANT "NSCLD_FACNOXRDCBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "NSCLD_FACO2ADAP" "1"
    SYSTEM_CONSTANT "NSCLD_MNOXLD_MIN" "0"
    SYSTEM_CONSTANT "NSCLD_MTOTSTRTRGN_MIN" "0.001"
    SYSTEM_CONSTANT "NSCLD_RDCAGTMIN" "-1e-005"
    SYSTEM_CONSTANT "NSCLD_RLAMDESBAS_MAP_X" "8"
    SYSTEM_CONSTANT "NSCLD_RLAMDESBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "NSCLD_SAM_NUM" "60"
    SYSTEM_CONSTANT "NSCMON_FACAGENOXCOR_CUR_X" "8"
    SYSTEM_CONSTANT "NSCMON_FACAGENOXSLIPCOR_CUR_X" "8"
    SYSTEM_CONSTANT "NSCMON_LAMBDA_MAX" "32"
    SYSTEM_CONSTANT "NSCMON_MNOXRDCCOR_CUR_X" "8"
    SYSTEM_CONSTANT "NSCMON_MRDCOSCNEW_CUR_X" "8"
    SYSTEM_CONSTANT "NSCMON_MRDCOSCOLD_CUR_X" "8"
    SYSTEM_CONSTANT "NSCMON_NUMSDETMAX" "3"
    SYSTEM_CONSTANT "NSCMON_ST_ZERO" "0"
    SYSTEM_CONSTANT "NSCMON_TIAFTLM_MAX" "65.536"
    SYSTEM_CONSTANT "NSCMON_UBINLAM_MAX" "2000"
    SYSTEM_CONSTANT "NSCRGN_DEMMSNOXHTG_AXIS_Y" "16"
    SYSTEM_CONSTANT "NSCRGN_DEMMSNOX_AXIS_Y" "16"
    SYSTEM_CONSTANT "NSCRGN_DEMNENG_AXIS_X" "10"
    SYSTEM_CONSTANT "NSCRGN_DEMNUMTRAGEAR_AXIS_Y" "6"
    SYSTEM_CONSTANT "NSCRGN_DEMTEMPBRICK1HTG_AXIS_X" "16"
    SYSTEM_CONSTANT "NSCRGN_DEMTEMPBRICK1_AXIS_X" "16"
    SYSTEM_CONSTANT "NSCRGN_DEMTRQINRSET_AXIS_Y" "10"
    SYSTEM_CONSTANT "NSCRGN_DEMV_AXIS_X" "6"
    SYSTEM_CONSTANT "NSCRGN_NUMAIRSYSMSK_SY" "2"
    SYSTEM_CONSTANT "NSCRGN_NUMNONSCRGNMSK_SY" "2"
    SYSTEM_CONSTANT "NSCRGN_NUMNSCWRMUPMSK_SY" "2"
    SYSTEM_CONSTANT "NSCRGN_NUMPFLTRGNMSK_SY" "2"
    SYSTEM_CONSTANT "NSCRGN_RLSLOGICNENG_AXIS_X" "10"
    SYSTEM_CONSTANT "NSCRGN_RLSLOGICTIAIR_AXIS_X" "10"
    SYSTEM_CONSTANT "NSCRGN_RLSLOGICTIDNOX_AXIS_X" "10"
    SYSTEM_CONSTANT "NSCRGN_RLSLOGICTIDSOX_AXIS_X" "10"
    SYSTEM_CONSTANT "NSCRGN_RLSLOGICTIHTG_AXIS_X" "10"
    SYSTEM_CONSTANT "NSCRGN_STNONSCRGNMSK_CA_X" "2"
    SYSTEM_CONSTANT "NSCRGN_STOPMODEBAS_CA_X" "13"
    SYSTEM_CONSTANT "NSCRGN_TIME_100_RES" "0.01"
    SYSTEM_CONSTANT "NSCRGN_TIRGNMAX_CUR_X" "8"
    SYSTEM_CONSTANT "NSCRGN_TIRMPSLPMAX_CA_X" "18"
    SYSTEM_CONSTANT "NSC_ACTV_BP" "1"
    SYSTEM_CONSTANT "NSC_AMPTNOXLDUNLD_MAX" "0"
    SYSTEM_CONSTANT "NSC_AMPTNOXLDUNLD_MIN" "-10"
    SYSTEM_CONSTANT "NSC_AMPTNOXRGN_MAX" "0"
    SYSTEM_CONSTANT "NSC_AMPTNOX_MIN" "0"
    SYSTEM_CONSTANT "NSC_CT_SENSORS" "0"
    SYSTEM_CONSTANT "NSC_CT_SENSORS_MAX" "2"
    SYSTEM_CONSTANT "NSC_CT_SENSORS_SY" "0"
    SYSTEM_CONSTANT "NSC_CT_SENSORS_TWFLW_SYS" "0"
    SYSTEM_CONSTANT "NSC_MSO2_FINE_MIN" "0"
    SYSTEM_CONSTANT "NSC_MSO2_MIN" "0"
    SYSTEM_CONSTANT "NSC_MSPERVOL_MIN" "0"
    SYSTEM_CONSTANT "NSC_MSSOXNOX_MAX" "0.1"
    SYSTEM_CONSTANT "NSC_MSSOXNOX_MIN" "0"
    SYSTEM_CONSTANT "NSC_NDESCALCBBAS_CUR_X" "8"
    SYSTEM_CONSTANT "NSC_NDESCALCDNOX_CUR_X" "8"
    SYSTEM_CONSTANT "NSC_NDESCALCDSOX_CUR_X" "8"
    SYSTEM_CONSTANT "NSC_NDESCALCTEMPDNOX_CUR_X" "8"
    SYSTEM_CONSTANT "NSC_NDESCALCTEMPDSOX_CUR_X" "8"
    SYSTEM_CONSTANT "NSC_NDESCALCTEMP_CUR_X" "8"
    SYSTEM_CONSTANT "NSC_NOXMASSFLW_MIN" "0"
    SYSTEM_CONSTANT "NSC_NOX_ZERO" "0"
    SYSTEM_CONSTANT "NSC_NSCHTGLAMDSOX_SY" "0"
    SYSTEM_CONSTANT "NSC_NUMBRICK" "2"
    SYSTEM_CONSTANT "NSC_NUMBRICK_CA_X" "3"
    SYSTEM_CONSTANT "NSC_NUMLAMSETVAL_SY" "4"
    SYSTEM_CONSTANT "NSC_NUMRMDSTHRESVLD_SY" "8"
    SYSTEM_CONSTANT "NSC_NUMTEMPBRICK_SY" "8"
    SYSTEM_CONSTANT "NSC_NUMTEMPSETVAL_SY" "2"
    SYSTEM_CONSTANT "NSC_SWTACTV_BP" "0"
    SYSTEM_CONSTANT "NSC_THRESLDMODVAR_SY" "0"
    SYSTEM_CONSTANT "NSC_TIMEMAX_SY" "327.5"
    SYSTEM_CONSTANT "NSC_TRQDESCALCBAS_CUR_Y" "8"
    SYSTEM_CONSTANT "NSC_TRQDESCALCDNOX_CUR_Y" "8"
    SYSTEM_CONSTANT "NSC_TRQDESCALCDSOX_CUR_Y" "8"
    SYSTEM_CONSTANT "NSC_TRQDESCALCTEMPDNOX_CUR_Y" "8"
    SYSTEM_CONSTANT "NSC_TRQDESCALCTEMPDSOX_CUR_Y" "8"
    SYSTEM_CONSTANT "NSC_TRQDESCALCTEMP_CUR_Y" "8"
    SYSTEM_CONSTANT "NTRBCH_RES_FL" "10"
    SYSTEM_CONSTANT "NTRBCH_ZERO" "0"
    SYSTEM_CONSTANT "NTRBCH_ZERO_FL" "0"
    SYSTEM_CONSTANT "NUMCASFRQ_MAX" "3"
    SYSTEM_CONSTANT "NUMCASMAX" "1"
    SYSTEM_CONSTANT "NUMCYLACT_SY" "6"
    SYSTEM_CONSTANT "NUMCYLMAX_SY" "6"
    SYSTEM_CONSTANT "NUMFANS_SY" "2"
    SYSTEM_CONSTANT "NUMINJCHRGBALRAW_RES" "0.01"
    SYSTEM_CONSTANT "NUMINJCHRGBALRAW_RES_REV" "100"
    SYSTEM_CONSTANT "NUMPSICBNK_SY" "1"
    SYSTEM_CONSTANT "NUMPSICCHP_SY" "1"
    SYSTEM_CONSTANT "NUM_BNK" "2"
    SYSTEM_CONSTANT "NUM_CHIP" "1"
    SYSTEM_CONSTANT "NUM_EXH_SENSORS" "1"
    SYSTEM_CONSTANT "NUM_EXH_SENSORS_MAX" "6"
    SYSTEM_CONSTANT "NUM_INJ_MAX" "6"
    SYSTEM_CONSTANT "NUM_MAX_FBC_SEG" "8"
    SYSTEM_CONSTANT "NUM_SINTAB_IDX" "10"
    SYSTEM_CONSTANT "NUM_WAHTPS_SY" "3"
    SYSTEM_CONSTANT "NUM_WAHT_SY" "3"
    SYSTEM_CONSTANT "N_20K_OFS_RSA" "20000"
    SYSTEM_CONSTANT "N_2_RES_RSA" "2"
    SYSTEM_CONSTANT "O2MASS_MAX" "50"
    SYSTEM_CONSTANT "O2MASS_MIN" "0"
    SYSTEM_CONSTANT "O2MPT_RES" "0.01"
    SYSTEM_CONSTANT "O2MPT_RESLO" "0.02"
    SYSTEM_CONSTANT "O2MPT_RESLO_FL" "0.02"
    SYSTEM_CONSTANT "O2MPT_RESLO_REV" "50"
    SYSTEM_CONSTANT "O2MPT_RES_FL" "0.01"
    SYSTEM_CONSTANT "O2MPT_RES_REV" "100"
    SYSTEM_CONSTANT "O2_NORM" "0.21"
    SYSTEM_CONSTANT "O2_NORM_INV" "4.773"
    SYSTEM_CONSTANT "O2_RES" "1e-005"
    SYSTEM_CONSTANT "O2_RES_FL" "1e-005"
    SYSTEM_CONSTANT "O2_RES_REV" "100000"
    SYSTEM_CONSTANT "O2_RMASS_AIR" "0.2314975"
    SYSTEM_CONSTANT "O2_RMASS_AIR_FL" "0.2314975"
    SYSTEM_CONSTANT "O2_RVOL_AIR" "0.2095"
    SYSTEM_CONSTANT "O2_THRES1_ADD" "0.063"
    SYSTEM_CONSTANT "O2_THRES1_FAC" "0.7"
    SYSTEM_CONSTANT "O2_THRES2_ADD" "0.126"
    SYSTEM_CONSTANT "O2_THRES2_FAC" "0.4"
    SYSTEM_CONSTANT "OFS_INJ_RSA" "32768"
    SYSTEM_CONSTANT "OILLVL_MMQ0P004_RES" "0.004"
    SYSTEM_CONSTANT "OILLVL_MMQ0P004_RESREV" "250"
    SYSTEM_CONSTANT "OILMFL_MGPS_Q0P1_RES" "0.1"
    SYSTEM_CONSTANT "OILMFL_MGPS_Q0P1_RES_REV" "10"
    SYSTEM_CONSTANT "OILMPT_RES" "0.0001"
    SYSTEM_CONSTANT "OILMSPRCQ0P01_100" "100"
    SYSTEM_CONSTANT "OILMSPRC_Q0P01_RES" "0.01"
    SYSTEM_CONSTANT "OILMSPRC_Q0P01_RES_REV" "100"
    SYSTEM_CONSTANT "OILMS_MG_RES" "1"
    SYSTEM_CONSTANT "OILMS_MG_RES_REV" "1"
    SYSTEM_CONSTANT "OILMS_Q0P1_RES" "0.1"
    SYSTEM_CONSTANT "OILMS_Q0P1_RES_REV" "10"
    SYSTEM_CONSTANT "OILMS_Q10_RES" "10"
    SYSTEM_CONSTANT "ONE_FACT26" "1"
    SYSTEM_CONSTANT "ONE_LAMBDAREC_VAL" "1"
    SYSTEM_CONSTANT "OTSCD_TLIN_CUR_X" "25"
    SYSTEM_CONSTANT "OVRMON_TILIMET_CUR_X" "16"
    SYSTEM_CONSTANT "OVRRUN" "5"
    SYSTEM_CONSTANT "PCR_CURLIM" "0"
    SYSTEM_CONSTANT "PCR_FACCTLIAT_CUR_X" "25"
    SYSTEM_CONSTANT "PCR_FACCTQNT_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_FACCTQNT_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_FACD_MAP_X" "10"
    SYSTEM_CONSTANT "PCR_FACD_MAP_Y" "10"
    SYSTEM_CONSTANT "PCR_FACIAT_CUR_X" "16"
    SYSTEM_CONSTANT "PCR_FACI_MAP_X" "10"
    SYSTEM_CONSTANT "PCR_FACI_MAP_Y" "10"
    SYSTEM_CONSTANT "PCR_FACN_CUR_X" "6"
    SYSTEM_CONSTANT "PCR_FACP_MAP_X" "10"
    SYSTEM_CONSTANT "PCR_FACP_MAP_Y" "10"
    SYSTEM_CONSTANT "PCR_MAPLIM" "1"
    SYSTEM_CONSTANT "PCR_PAPQNTCOR_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_PAPQNTCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_PDESBAS_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_PDESBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_PDESMAXAP_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_PDESMAXAP_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_PDVTMAX_MAP_X" "12"
    SYSTEM_CONSTANT "PCR_PDVTMAX_MAP_Y" "12"
    SYSTEM_CONSTANT "PCR_PDVTMIN_MAP_X" "12"
    SYSTEM_CONSTANT "PCR_PDVTMIN_MAP_Y" "12"
    SYSTEM_CONSTANT "PCR_PNQNTCTCOR_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_PNQNTCTCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_PRESPRCCNV" "82"
    SYSTEM_CONSTANT "PCR_QGVNROFF_CUR_X" "25"
    SYSTEM_CONSTANT "PCR_QGVNRON_CUR_X" "25"
    SYSTEM_CONSTANT "PCR_QNTCTL_QCURR" "0"
    SYSTEM_CONSTANT "PCR_QNTCTL_QRAW" "1"
    SYSTEM_CONSTANT "PCR_Q_QCURR" "0"
    SYSTEM_CONSTANT "PCR_Q_QRAW" "1"
    SYSTEM_CONSTANT "PCR_RCTLAPCOR_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_RCTLAPCOR_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_RCTLBAS_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_RCTLBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_RELABS_ABS" "0"
    SYSTEM_CONSTANT "PCR_RELABS_REL" "1"
    SYSTEM_CONSTANT "PCR_RGVNRMAX_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_RGVNRMAX_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_RGVNRMIN_MAP_X" "16"
    SYSTEM_CONSTANT "PCR_RGVNRMIN_MAP_Y" "16"
    SYSTEM_CONSTANT "PCR_SWTLIMSEL_TYPE" "0"
    SYSTEM_CONSTANT "PCR_SWTLIMSEL_VAL" "1"
    SYSTEM_CONSTANT "PCR_SWTQNTCTL_TYPE" "2"
    SYSTEM_CONSTANT "PCR_SWTQNTCTL_VAL" "0"
    SYSTEM_CONSTANT "PCR_SWTQNTDES_TYPE" "2"
    SYSTEM_CONSTANT "PCR_SWTQNTDES_VAL" "0"
    SYSTEM_CONSTANT "PCR_SWTRELABS_TYPE" "2"
    SYSTEM_CONSTANT "PCR_SWTRELABS_VAL" "0"
    SYSTEM_CONSTANT "PCR_SWTTEMPCOR_TYPE" "2"
    SYSTEM_CONSTANT "PCR_SWTTEMPCOR_VAL" "0"
    SYSTEM_CONSTANT "PCR_SWTTRQCTL_TYPE" "2"
    SYSTEM_CONSTANT "PCR_SWTTRQCTL_VAL" "0"
    SYSTEM_CONSTANT "PCR_SWTTRQDES_TYPE" "2"
    SYSTEM_CONSTANT "PCR_SWTTRQDES_VAL" "0"
    SYSTEM_CONSTANT "PCR_TAIR" "1"
    SYSTEM_CONSTANT "PCR_TENG" "0"
    SYSTEM_CONSTANT "PCR_TICLDSTRT_CUR_X" "30"
    SYSTEM_CONSTANT "PCR_TIGVNROFFDEL_CUR_X" "6"
    SYSTEM_CONSTANT "PCVCD_CTLSTATE_CONST" "0"
    SYSTEM_CONSTANT "PCVCD_CTLSTATE_DEP" "1"
    SYSTEM_CONSTANT "PCVCD_SWTCTLSTATE_TYPE" "2"
    SYSTEM_CONSTANT "PCVCD_SWTCTLSTATE_VAL" "0"
    SYSTEM_CONSTANT "PCV_ACTRTST_NUMMAXCALCAVRG" "20"
    SYSTEM_CONSTANT "PCV_CTLSTATE_CONST" "0"
    SYSTEM_CONSTANT "PCV_CTLSTATE_DEP" "1"
    SYSTEM_CONSTANT "PCV_DVOLLEAK_CURX" "6"
    SYSTEM_CONSTANT "PCV_DVOLPRECTLBASNOM_MAPX" "8"
    SYSTEM_CONSTANT "PCV_DVOLPRECTLBASNOM_MAPY" "8"
    SYSTEM_CONSTANT "PCV_DVOLUPLIM_CURX" "10"
    SYSTEM_CONSTANT "PCV_FACADAPTFLOW_MAPX" "6"
    SYSTEM_CONSTANT "PCV_FACADAPTFLOW_MAPY" "4"
    SYSTEM_CONSTANT "PCV_FACCRNTCTLINIT_CURX" "6"
    SYSTEM_CONSTANT "PCV_FACWINACTRTST_CURX" "10"
    SYSTEM_CONSTANT "PCV_ICNVPRES_CURX" "10"
    SYSTEM_CONSTANT "PCV_IGOV_ACTV" "0"
    SYSTEM_CONSTANT "PCV_IGOV_ACTVOPNLOP" "1"
    SYSTEM_CONSTANT "PCV_ILIN_CURX" "2"
    SYSTEM_CONSTANT "PCV_ISETCLOSE_CURX" "8"
    SYSTEM_CONSTANT "PCV_RSETLIN_CURX" "4"
    SYSTEM_CONSTANT "PCV_SWTCTLSTATE_TYPE" "2"
    SYSTEM_CONSTANT "PCV_SWTCTLSTATE_VAL" "0"
    SYSTEM_CONSTANT "PERIOD_RES" "100"
    SYSTEM_CONSTANT "PERKM_RES" "1"
    SYSTEM_CONSTANT "PERMSPLYSYS_SY" "0"
    SYSTEM_CONSTANT "PER_CNT_MAX" "1000000"
    SYSTEM_CONSTANT "PER_DUR_RES" "1"
    SYSTEM_CONSTANT "PER_DUR_SHIFT" "256"
    SYSTEM_CONSTANT "PFLTENGPOPMAX_SY" "11"
    SYSTEM_CONSTANT "PFLTLD_DMSOTSIMRGNBAS_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTLD_FACCNVCATNO2_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTLD_FACMLTCOR_CUR_X" "16"
    SYSTEM_CONSTANT "PFLTLD_FACO2SIMRGN_MAP_X" "8"
    SYSTEM_CONSTANT "PFLTLD_FACO2SIMRGN_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLTLD_FACPOPOILASH_MAP_X" "16"
    SYSTEM_CONSTANT "PFLTLD_FACPOPOILASH_MAP_Y" "16"
    SYSTEM_CONSTANT "PFLTLD_FACSOTSIMRGNNO2_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTLD_FACTEMPNO2_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTLD_FACTEMPSIMRGN_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTLD_FACVOLFLWNO2_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTLD_MSOTRESAFTRGN_MAP_X" "16"
    SYSTEM_CONSTANT "PFLTLD_MSOTRESAFTRGN_MAP_Y" "16"
    SYSTEM_CONSTANT "PFLTLD_RESFLW_MAP_X" "8"
    SYSTEM_CONSTANT "PFLTLD_RESFLW_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLTLD_RO2EG" "0.2315"
    SYSTEM_CONSTANT "PFLTLD_RO2EGONE" "1"
    SYSTEM_CONSTANT "PFLTLD_RO2EGONE_SY" "1"
    SYSTEM_CONSTANT "PFLTLD_RO2EG_SY" "0.2315"
    SYSTEM_CONSTANT "PFLTLD_RO2STOICH" "0.2315"
    SYSTEM_CONSTANT "PFLTLD_RO2STOICHONE" "1"
    SYSTEM_CONSTANT "PFLTLD_RO2STOICHONE_SY" "1"
    SYSTEM_CONSTANT "PFLTLD_RO2STOICH_SY" "0.2315"
    SYSTEM_CONSTANT "PFLTLD_TIME_DT" "1000000"
    SYSTEM_CONSTANT "PFLTLD_TIME_S" "10000"
    SYSTEM_CONSTANT "PFLTLD_TINO2RGNDEL_MAP_X" "8"
    SYSTEM_CONSTANT "PFLTLD_TINO2RGNDEL_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLTLD_VOLOILASHTIENGON_CUR_X" "16"
    SYSTEM_CONSTANT "PFLTLMP_ATSINTVMOD_SY" "1"
    SYSTEM_CONSTANT "PFLTNUMCHNGIMMD_SY" "3"
    SYSTEM_CONSTANT "PFLTNUMCHNG_SY" "6"
    SYSTEM_CONSTANT "PFLTNUMRGNMAX_SY" "6"
    SYSTEM_CONSTANT "PFLTPOP_NUMTHRESH_X" "11"
    SYSTEM_CONSTANT "PFLTPOP_NUMTHRESH_Y" "2"
    SYSTEM_CONSTANT "PFLTPOP_QSETUNBAL_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTRGNSTGMAX_SY" "10"
    SYSTEM_CONSTANT "PFLTRGN_ADYNMINLIM_MAP_X" "8"
    SYSTEM_CONSTANT "PFLTRGN_ADYNMINLIM_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLTRGN_FACFULLLDCOR_MAP_X" "8"
    SYSTEM_CONSTANT "PFLTRGN_FACFULLLDCOR_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLTRGN_MSOTMEAS_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTRGN_NUMENGPOPDEL_CA_X" "12"
    SYSTEM_CONSTANT "PFLTRGN_NUMENGPOPDEL_CA_Y" "7"
    SYSTEM_CONSTANT "PFLTRGN_NUMENGPOP_CA_X" "12"
    SYSTEM_CONSTANT "PFLTRGN_NUMENGPOP_CA_Y" "7"
    SYSTEM_CONSTANT "PFLTRGN_NUMREQMSK_SY" "2"
    SYSTEM_CONSTANT "PFLTRGN_RFULLLDBAS_MAP_X" "8"
    SYSTEM_CONSTANT "PFLTRGN_RFULLLDBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLTRGN_TICHNGRGNDELBAS_MAP_X" "8"
    SYSTEM_CONSTANT "PFLTRGN_TICHNGRGNDELBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLTRGN_TILCKRGNERR_CA_X" "7"
    SYSTEM_CONSTANT "PFLTRGN_TILCKRGN_CA_X" "7"
    SYSTEM_CONSTANT "PFLTRGN_TIRGNMAX_CA_X" "7"
    SYSTEM_CONSTANT "PFLTSRV_TRQMAX_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTSRV_TRQMIN_CUR_X" "8"
    SYSTEM_CONSTANT "PFLTSTATS_ACTV_SY" "1"
    SYSTEM_CONSTANT "PFLT_ACTV_BP" "0"
    SYSTEM_CONSTANT "PFLT_NUMOPMODEMSKNMINSRV_SY" "4"
    SYSTEM_CONSTANT "PFLT_NUMOPMODEMSKNMIN_SY" "2"
    SYSTEM_CONSTANT "PFLT_NUMOPMODEMSK_SY" "2"
    SYSTEM_CONSTANT "PFLT_PDIFFCHARMONMAX_MAP_X" "8"
    SYSTEM_CONSTANT "PFLT_PDIFFCHARMONMAX_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLT_PDIFFCHARMONMIN_MAP_X" "8"
    SYSTEM_CONSTANT "PFLT_PDIFFCHARMONMIN_MAP_Y" "8"
    SYSTEM_CONSTANT "PFLT_PDIFFNODSTRMIN_CUR_X" "8"
    SYSTEM_CONSTANT "PFLT_PRIOMAX_SY" "2047"
    SYSTEM_CONSTANT "PFLT_RESFLWMAX_CUR_X" "8"
    SYSTEM_CONSTANT "PFLT_RESFLWMIN_CUR_X" "8"
    SYSTEM_CONSTANT "PFLT_STGMAX_SY" "15"
    SYSTEM_CONSTANT "PHC_EGRMAXDEV_MAP_X" "12"
    SYSTEM_CONSTANT "PHC_EGRMAXDEV_MAP_Y" "8"
    SYSTEM_CONSTANT "PHC_EGRMINDEV_MAP_X" "12"
    SYSTEM_CONSTANT "PHC_EGRMINDEV_MAP_Y" "8"
    SYSTEM_CONSTANT "PHC_STDIRSWT_CA_X" "4"
    SYSTEM_CONSTANT "PHC_TIOVRRUN_CUR_X" "25"
    SYSTEM_CONSTANT "PHC_TISTG2DELAY_CUR_X" "8"
    SYSTEM_CONSTANT "PHC_TRQINRHIGH_MAP_X" "16"
    SYSTEM_CONSTANT "PHC_TRQINRHIGH_MAP_Y" "8"
    SYSTEM_CONSTANT "PHC_TRQINRLOW_MAP_X" "16"
    SYSTEM_CONSTANT "PHC_TRQINRLOW_MAP_Y" "8"
    SYSTEM_CONSTANT "PHC_TRQINROVRRUN_CUR_X" "25"
    SYSTEM_CONSTANT "PHI_COR_MAX" "10"
    SYSTEM_CONSTANT "PHI_ETCTL_MAX" "200"
    SYSTEM_CONSTANT "PHI_ETCTL_MIN" "-200"
    SYSTEM_CONSTANT "PHI_INJBEG_UIS_EARL" "50"
    SYSTEM_CONSTANT "PHI_INJBEG_UIS_LATE" "-60"
    SYSTEM_CONSTANT "PHI_MI_EARL" "40"
    SYSTEM_CONSTANT "PHI_MI_LATE" "-10"
    SYSTEM_CONSTANT "PHI_PII_EARL_ABS" "100"
    SYSTEM_CONSTANT "PHI_PII_EARL_REL" "90"
    SYSTEM_CONSTANT "PHI_PII_LATE_REL" "5"
    SYSTEM_CONSTANT "PHI_POI1_EARL" "-40"
    SYSTEM_CONSTANT "PHI_POI1_LATE" "-100"
    SYSTEM_CONSTANT "PHI_POI1_ZERO" "0"
    SYSTEM_CONSTANT "PHI_POI2_LATE" "-40"
    SYSTEM_CONSTANT "PHI_TIME_BY_N" "1831.05468750045"
    SYSTEM_CONSTANT "PHI_ZERO" "0"
    SYSTEM_CONSTANT "PhyMod_pwrEGLos_MAP_X" "8"
    SYSTEM_CONSTANT "PhyMod_pwrEGLos_MAP_Y" "8"
    SYSTEM_CONSTANT "PHYMOD_QBAS_MAP_X" "16"
    SYSTEM_CONSTANT "PHYMOD_QBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "PI" "3.14159265359"
    SYSTEM_CONSTANT "PIICLB_ANGLE32FAC2ANGLE_CNV" "6553600"
    SYSTEM_CONSTANT "PIICLB_ANGLECRSS32_RES" "2982616.17777705"
    SYSTEM_CONSTANT "PIICLB_ANGLECRSS32_ZERO" "0"
    SYSTEM_CONSTANT "PIICLB_FACTS32_RES" "65536"
    SYSTEM_CONSTANT "PIICLB_INJMASSS32_RES" "6553600"
    SYSTEM_CONSTANT "PIICLB_INJMASSS32_ZERO" "0"
    SYSTEM_CONSTANT "PIICLB_QNT32FAC2ANGLE32_CNV" "144000.000000035"
    SYSTEM_CONSTANT "PIICLB_RCNFDMAX" "32766"
    SYSTEM_CONSTANT "PIICLB_STATE_CALC" "2"
    SYSTEM_CONSTANT "PIICLB_STATE_CLB" "1"
    SYSTEM_CONSTANT "PIICLB_STATE_INIT" "255"
    SYSTEM_CONSTANT "PIICLB_STATE_START" "0"
    SYSTEM_CONSTANT "PIICLB_STRLS_DISABLED" "1"
    SYSTEM_CONSTANT "PIICLB_STRLS_RELEASED" "0"
    SYSTEM_CONSTANT "PIICLB_TRQBYETA2QNT32_CNV" "83886080"
    SYSTEM_CONSTANT "PIICLB_TRQDT1KDDIV" "42949.67296"
    SYSTEM_CONSTANT "PIICLB_TRQDT1KDMUL" "65536000"
    SYSTEM_CONSTANT "PIICLB_TRQPERSEC_RES" "1000"
    SYSTEM_CONSTANT "PIICLB_UPDT_COL" "1"
    SYSTEM_CONSTANT "PIICLB_UPDT_SEQ" "0"
    SYSTEM_CONSTANT "PIICLB_VARIANT_NONE" "0"
    SYSTEM_CONSTANT "PIICLB_VARIANT_PIC" "1"
    SYSTEM_CONSTANT "PIICLB_VARIANT_PICALL" "2"
    SYSTEM_CONSTANT "PMAXCTLKI_RES" "0.00130967237055334"
    SYSTEM_CONSTANT "PMAXCTLKP_RES" "8.58306884765835e-005"
    SYSTEM_CONSTANT "PMAXCTLKP_RES_8" "0.000686645507812668"
    SYSTEM_CONSTANT "PMAXCTL_FACKPNRM8" "8"
    SYSTEM_CONSTANT "PMP_QNT_MAX" "1500"
    SYSTEM_CONSTANT "PMP_QNT_RES" "0.1"
    SYSTEM_CONSTANT "PMP_QNT_ZERO" "0"
    SYSTEM_CONSTANT "POSMCAIRAMPC2RAT_RES" "0.0078125"
    SYSTEM_CONSTANT "POSMCAIRKI_RES" "0.00465661287307739"
    SYSTEM_CONSTANT "POSMCAIRKP_RES" "0.00030517578125"
    SYSTEM_CONSTANT "POSMCCTL_FACKDNRM4" "4"
    SYSTEM_CONSTANT "POSMCCTL_FACKINRM2" "2"
    SYSTEM_CONSTANT "POSMCCTL_FACKPNRM32" "32"
    SYSTEM_CONSTANT "POSMCDES_NUMGMAPSNRM_SY" "7"
    SYSTEM_CONSTANT "POSMCDES_NUMGMAPSPHC_SY" "5"
    SYSTEM_CONSTANT "POSMCDES_NUMPHC_SY" "4"
    SYSTEM_CONSTANT "POSMCDES_RMP_FACT" "100"
    SYSTEM_CONSTANT "POSMCEGR_SYS" "10"
    SYSTEM_CONSTANT "POSMCKD_RES" "6.94444444444275e-006"
    SYSTEM_CONSTANT "POSMCKD_RES_4" "2.7777777777771e-005"
    SYSTEM_CONSTANT "POSMCKI_RES" "0.000211927625868004"
    SYSTEM_CONSTANT "POSMCKI_RES_2" "0.000423855251736008"
    SYSTEM_CONSTANT "POSMCKP_RES" "1.38888888888855e-005"
    SYSTEM_CONSTANT "POSMCKP_RES_32" "0.000444444444444336"
    SYSTEM_CONSTANT "POSTDRV_NOMAXTI_SY" "0"
    SYSTEM_CONSTANT "POSTDRV_SOFTRST_SY" "0"
    SYSTEM_CONSTANT "POSTDRV_T15RST_SY" "0"
    SYSTEM_CONSTANT "POS_PRC_RES_FL" "0.01220703125"
    SYSTEM_CONSTANT "PPFLTDIFF_ATS_SY" "1"
    SYSTEM_CONSTANT "PRC001_RSA_RES" "0.01"
    SYSTEM_CONSTANT "PRC001_RSA_RES_REV" "100"
    SYSTEM_CONSTANT "PRC002_RSA_RES" "0.00125"
    SYSTEM_CONSTANT "PRC002_RSA_RES_REV" "800"
    SYSTEM_CONSTANT "PRC01_RSA_RB_OFFSET" "1000"
    SYSTEM_CONSTANT "PRC2EFFGRAD_RES" "1.220703125e-006"
    SYSTEM_CONSTANT "PRC2EFFGRAD_RES_REV" "819200"
    SYSTEM_CONSTANT "PRCFACT100_FULLNEG" "-100"
    SYSTEM_CONSTANT "PRCFACT100_FULLPOS" "100"
    SYSTEM_CONSTANT "PRCFACT100_ZERO" "0"
    SYSTEM_CONSTANT "PRC_1" "1"
    SYSTEM_CONSTANT "PRC_10" "10"
    SYSTEM_CONSTANT "PRC_100" "100"
    SYSTEM_CONSTANT "PRC_100_RSA" "100"
    SYSTEM_CONSTANT "PRC_120" "120"
    SYSTEM_CONSTANT "PRC_150" "150"
    SYSTEM_CONSTANT "PRC_20" "20"
    SYSTEM_CONSTANT "PRC_255_RSA" "255"
    SYSTEM_CONSTANT "PRC_30" "30"
    SYSTEM_CONSTANT "PRC_488_RES" "488"
    SYSTEM_CONSTANT "PRC_50" "50"
    SYSTEM_CONSTANT "PRC_65535_RES" "65535"
    SYSTEM_CONSTANT "PRC_EGRRMP_RES" "0.152587890625"
    SYSTEM_CONSTANT "PRC_M_100" "-100"
    SYSTEM_CONSTANT "PRC_OFS_10_RSA" "10"
    SYSTEM_CONSTANT "PRC_Q0P01_RES" "0.01"
    SYSTEM_CONSTANT "PRC_Q0P01_RES_REV" "100"
    SYSTEM_CONSTANT "PRC_RES" "0.01220703125"
    SYSTEM_CONSTANT "PRC_RES_REV" "81.92"
    SYSTEM_CONSTANT "PRC_SLP_10" "10"
    SYSTEM_CONSTANT "PRC_SLP_MIN" "0"
    SYSTEM_CONSTANT "PRC_ZERO" "0"
    SYSTEM_CONSTANT "PREDRV_T15RST_SY" "0"
    SYSTEM_CONSTANT "PREFSCALE_RES" "1000"
    SYSTEM_CONSTANT "Pres1Bar_RSA_RES_ADAPT" "10"
    SYSTEM_CONSTANT "PRESBAR_RSA_DIFF_MAX" "2000"
    SYSTEM_CONSTANT "PRESBAR_RSA_DIFF_MIN" "-2000"
    SYSTEM_CONSTANT "PRESHPA_FNRESO" "0.1"
    SYSTEM_CONSTANT "PRESHPA_FNRESO_REV" "10"
    SYSTEM_CONSTANT "PRESHPA_HIRES" "0.01"
    SYSTEM_CONSTANT "PRESHPA_HIRES_REV" "100"
    SYSTEM_CONSTANT "PRESINV_RES" "1e-007"
    SYSTEM_CONSTANT "PRESINV_RES_REV" "10000000"
    SYSTEM_CONSTANT "PRES_AC_HPA_RES" "2"
    SYSTEM_CONSTANT "PRES_AC_HPA_RES_CODE" "2"
    SYSTEM_CONSTANT "PRES_AIR_MAX" "3500"
    SYSTEM_CONSTANT "PRES_AIR_MIN" "0"
    SYSTEM_CONSTANT "PRES_BAR_RES" "1"
    SYSTEM_CONSTANT "PRES_HPA_2000" "2000"
    SYSTEM_CONSTANT "PRES_HPA_RES" "1"
    SYSTEM_CONSTANT "PRES_HPA_RES_FL" "1"
    SYSTEM_CONSTANT "PRES_HPA_RES_INV" "1"
    SYSTEM_CONSTANT "PRES_HPA_RES_REV" "1"
    SYSTEM_CONSTANT "PRES_HPA_ZERO" "0"
    SYSTEM_CONSTANT "PRES_LORES_RES" "0.01"
    SYSTEM_CONSTANT "PRES_RAIL_GRAD_TO_VAL" "4"
    SYSTEM_CONSTANT "PRES_RAIL_RES" "100"
    SYSTEM_CONSTANT "PRES_RES" "0.1"
    SYSTEM_CONSTANT "PRES_SI_RES" "100"
    SYSTEM_CONSTANT "PRES_TIME_RES" "400"
    SYSTEM_CONSTANT "PRP_RENG_MAP_X" "16"
    SYSTEM_CONSTANT "PRP_RENG_MAP_Y" "16"
    SYSTEM_CONSTANT "PRP_RPRP_MAP_X" "16"
    SYSTEM_CONSTANT "PRP_RPRP_MAP_Y" "16"
    SYSTEM_CONSTANT "PRP_TRQTHRESENG_CUR_X" "25"
    SYSTEM_CONSTANT "PRP_TRQTHRESPRP_CUR_X" "25"
    SYSTEM_CONSTANT "PRV_NMINPRESINC_CUR_X" "8"
    SYSTEM_CONSTANT "PSC_COEOM_EGT_NUMINP" "4"
    SYSTEM_CONSTANT "PSC_COEOM_RMP_MAX" "16384000"
    SYSTEM_CONSTANT "PSC_FACT_REC_RES" "3.05185094759972e-005"
    SYSTEM_CONSTANT "PSC_FACT_REC_RES_REV" "32767"
    SYSTEM_CONSTANT "PSC_LSIGIDXMAX_SY" "8"
    SYSTEM_CONSTANT "PSC_LSIG_IDX_MAX" "14"
    SYSTEM_CONSTANT "PSC_NRMPHCSPDIDXMAX_SY" "8"
    SYSTEM_CONSTANT "PSC_NRMPHC_SPD_IDX_MAX" "13"
    SYSTEM_CONSTANT "PSC_NUMCYLMAX_SY" "5"
    SYSTEM_CONSTANT "PSC_WARNTHRES_FACT" "10000"
    SYSTEM_CONSTANT "PS_NUMSENS_SY" "0"
    SYSTEM_CONSTANT "PT1INIT_ZERO_SY" "0"
    SYSTEM_CONSTANT "PTHSET_DTRQRMPDWN_CUR_X" "6"
    SYSTEM_CONSTANT "PTHSET_TIRMPSTRT_CUR_X" "6"
    SYSTEM_CONSTANT "PTHSET_TISWTOFF_CUR_X" "6"
    SYSTEM_CONSTANT "PTPRTOVRDSSPDGOV_SY" "0"
    SYSTEM_CONSTANT "PTPRT_OVRDS_SPDGOV" "1"
    SYSTEM_CONSTANT "PT_GRIP_BP" "0"
    SYSTEM_CONSTANT "PWR1_ZERO" "0"
    SYSTEM_CONSTANT "PWR2_RES" "18.84955592154"
    SYSTEM_CONSTANT "PWRSQ_TEMPSQQ0P01_RES" "0.01"
    SYSTEM_CONSTANT "PWRSQ_TEMPSQQ0P01_RES_REV" "100"
    SYSTEM_CONSTANT "PWR_HIGH_RES" "0.1"
    SYSTEM_CONSTANT "PWR_HIGH_RES_REV" "10"
    SYSTEM_CONSTANT "PWR_KW_RES" "0.01"
    SYSTEM_CONSTANT "PWR_PA_MAX" "32000"
    SYSTEM_CONSTANT "PWR_PA_RES" "5"
    SYSTEM_CONSTANT "PWR_PA_ZERO" "0"
    SYSTEM_CONSTANT "PWR_Q1_RES" "1"
    SYSTEM_CONSTANT "PWR_Q1_RES_REV" "1"
    SYSTEM_CONSTANT "PWR_Q50_RES" "50"
    SYSTEM_CONSTANT "PWR_Q50_RES_REV" "0"
    SYSTEM_CONSTANT "PWR_RES" "9.42477796077"
    SYSTEM_CONSTANT "PWR_TEMPQ0P001_RES" "0.01"
    SYSTEM_CONSTANT "PWR_TEMPQ0P001_RES_REV" "100"
    SYSTEM_CONSTANT "PWR_TEMPQ0P1_RES" "0.1"
    SYSTEM_CONSTANT "PWR_TEMPQ0P1_RES_REV" "10"
    SYSTEM_CONSTANT "PWR_ZERO" "0"
    SYSTEM_CONSTANT "P_ENGPRT_MAX" "1500"
    SYSTEM_CONSTANT "P_ENGPRT_MIN" "0"
    SYSTEM_CONSTANT "QLAMBDARESREV_SY" "1000"
    SYSTEM_CONSTANT "QNTR_EXP" "10"
    SYSTEM_CONSTANT "QNTR_MAX" "24"
    SYSTEM_CONSTANT "QNTR_MIN" "0.0009765625"
    SYSTEM_CONSTANT "QNTR_RES" "0.0009765625"
    SYSTEM_CONSTANT "QNTR_RES_REV" "1024"
    SYSTEM_CONSTANT "QNTSEL_SY" "0"
    SYSTEM_CONSTANT "Qp_RES" "10"
    SYSTEM_CONSTANT "QWC_FACCOR1_MAPX" "12"
    SYSTEM_CONSTANT "QWC_FACCOR1_MAPY" "10"
    SYSTEM_CONSTANT "QWC_FACCOR2_MAPX" "8"
    SYSTEM_CONSTANT "QWC_FACCOR2_MAPY" "16"
    SYSTEM_CONSTANT "QWC_FACFTS_MAPX" "16"
    SYSTEM_CONSTANT "QWC_FACFTS_MAPY" "8"
    SYSTEM_CONSTANT "QWC_QCOR1_MAPX" "80"
    SYSTEM_CONSTANT "QWC_QCOR1_MAPY" "16"
    SYSTEM_CONSTANT "QWC_QCOR2_MAPX" "80"
    SYSTEM_CONSTANT "QWC_QCOR2_MAPY" "16"
    SYSTEM_CONSTANT "QWC_QNORM_CURX" "20"
    SYSTEM_CONSTANT "QWC_TCOR_MAPX" "16"
    SYSTEM_CONSTANT "QWC_TCOR_MAPY" "16"
    SYSTEM_CONSTANT "QWC_TIDIFFHYD_MAPX" "16"
    SYSTEM_CONSTANT "QWC_TIDIFFHYD_MAPY" "16"
    SYSTEM_CONSTANT "RAILP_NUMDPMAXUPLIM_SY" "1000"
    SYSTEM_CONSTANT "RAILP_PFLTWINNEG_CURX" "10"
    SYSTEM_CONSTANT "RAILP_PLIN_CURX" "4"
    SYSTEM_CONSTANT "RAILP_PSUBSCTLDLVMEUN_MAP_X" "8"
    SYSTEM_CONSTANT "RAILP_PSUBSCTLDLVMEUN_MAP_Y" "8"
    SYSTEM_CONSTANT "RAILP_PSUBSMAXDLVMEUN_MAP_X" "8"
    SYSTEM_CONSTANT "RAILP_PSUBSMAXDLVMEUN_MAP_Y" "8"
    SYSTEM_CONSTANT "RAILP_SSPMON1_SY" "1"
    SYSTEM_CONSTANT "RAILP_SSPMON2_SY" "2"
    SYSTEM_CONSTANT "RAILP_SSPMON3_SY" "3"
    SYSTEM_CONSTANT "RAILP_TIOFSTSTDEL_CURX" "6"
    SYSTEM_CONSTANT "RAIL_CALCBACK_I" "1"
    SYSTEM_CONSTANT "RAIL_CNT_NHPTST" "4"
    SYSTEM_CONSTANT "RAIL_CNT_NHPTST_PLUS_ONE" "5"
    SYSTEM_CONSTANT "RAIL_CNT_NHPTST_PLUS_THREE" "7"
    SYSTEM_CONSTANT "RAIL_CNT_TDROP5STPHPTST_SY" "16"
    SYSTEM_CONSTANT "RAIL_CPC" "1"
    SYSTEM_CONSTANT "RAIL_DPDECMONMAX_CUR_X" "8"
    SYSTEM_CONSTANT "RAIL_DPSETPOINTDEC_CURX" "8"
    SYSTEM_CONSTANT "RAIL_DPSETPOINTINCLIM_MAPX" "5"
    SYSTEM_CONSTANT "RAIL_DPSETPOINTINCLIM_MAPY" "4"
    SYSTEM_CONSTANT "RAIL_DPSETPOINTINC_MAPX" "12"
    SYSTEM_CONSTANT "RAIL_DPSETPOINTINC_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_DP_MAX" "13000000"
    SYSTEM_CONSTANT "RAIL_DP_ZERO" "0"
    SYSTEM_CONSTANT "RAIL_DVOLLEAKAGED_MAP_X" "10"
    SYSTEM_CONSTANT "RAIL_DVOLLEAKAGED_MAP_Y" "10"
    SYSTEM_CONSTANT "RAIL_DVOLLEAK_MAPX" "10"
    SYSTEM_CONSTANT "RAIL_DVOLLEAK_MAPY" "10"
    SYSTEM_CONSTANT "RAIL_DVOLLIMP_MAP_X" "16"
    SYSTEM_CONSTANT "RAIL_DVOLLIMP_MAP_Y" "16"
    SYSTEM_CONSTANT "RAIL_DVOLMEUNCLOSE_CURX" "12"
    SYSTEM_CONSTANT "RAIL_DVOLMEUNCTLINITI_CURX" "6"
    SYSTEM_CONSTANT "RAIL_DVOLMEUNCTLTYPE_CURX" "6"
    SYSTEM_CONSTANT "RAIL_DVOLMEUNCTLUPLIM_CURX" "16"
    SYSTEM_CONSTANT "RAIL_DVOLMEUNLIMFST_CURX" "16"
    SYSTEM_CONSTANT "RAIL_DVOLMEUNOPN_CURX" "12"
    SYSTEM_CONSTANT "RAIL_DVOLMEUNOVRRUN_CURX" "8"
    SYSTEM_CONSTANT "RAIL_DVOLPCVCLOSE_CURX" "12"
    SYSTEM_CONSTANT "RAIL_DVOLPCVOPN_CURX" "12"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLBAS_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLBAS_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLOFS_MAPX" "8"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLOFS_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLPOI1_MAPX" "4"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLPOI1_MAPY" "4"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLPOI2_MAPX" "4"
    SYSTEM_CONSTANT "RAIL_DVOLPRECTLPOI2_MAPY" "4"
    SYSTEM_CONSTANT "RAIL_DVOLSTRT_MAP_X" "8"
    SYSTEM_CONSTANT "RAIL_DVOLSTRT_MAP_Y" "8"
    SYSTEM_CONSTANT "RAIL_FACFLPLIMFTSCOR_CURX" "4"
    SYSTEM_CONSTANT "RAIL_FACMEUNCTLDCOR_CURX" "4"
    SYSTEM_CONSTANT "RAIL_FACMEUNCTLICOR_CURX" "4"
    SYSTEM_CONSTANT "RAIL_FACMEUNCTLPCOR_CURX" "4"
    SYSTEM_CONSTANT "RAIL_FACMEUNDVT_CURX" "12"
    SYSTEM_CONSTANT "RAIL_FACMEUNSETPOINT_CUR_X" "12"
    SYSTEM_CONSTANT "RAIL_FACMEUNSETPOINT_MAPX" "12"
    SYSTEM_CONSTANT "RAIL_FACMEUNSETPOINT_MAPY" "12"
    SYSTEM_CONSTANT "RAIL_FACPCVDVT_CURX" "12"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM1_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM2_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM3_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM4_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM5_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM6_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTAPSCOREOM7_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM1_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM2_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM3_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM4_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM5_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM6_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTATSCOREOM7_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM0_CURX" "8"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM1_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM2_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM3_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM4_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM5_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM6_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTETSCOREOM7_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTFTSCOR_CURX" "8"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM0_CURX" "12"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM1_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM2_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM3_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM4_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM5_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM6_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPRMPEOM7_CURX" "16"
    SYSTEM_CONSTANT "RAIL_FACSETPOINTRMPVAL_CUR_X" "12"
    SYSTEM_CONSTANT "RAIL_FREEZE_I" "0"
    SYSTEM_CONSTANT "RAIL_MAX_TIME_PRAMP_HPTST" "5000"
    SYSTEM_CONSTANT "RAIL_MEUNCTLDKD_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLIKIHPTST_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLIKINEG_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLIKIPOS_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLIKI_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLPKPHPTST_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLPKPNEG_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLPKPPOS_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUNCTLPKP_CURX" "16"
    SYSTEM_CONSTANT "RAIL_MEUN_PCV" "0"
    SYSTEM_CONSTANT "RAIL_PCPCFLTMIN_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PCPCSETMAX_CURX" "4"
    SYSTEM_CONSTANT "RAIL_PCVCTLDKD_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PCVCTLIKINEG_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PCVCTLIKIPOS_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PCVCTLIKI_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PCVCTLPKPNEG_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PCVCTLPKPPOS_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PCVCTLPKP_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PMAXSETSUBST_CURX" "5"
    SYSTEM_CONSTANT "RAIL_PMEUNDVTFST_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PMEUNDVTMAX_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PMEUNDVTMIN2_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PMEUNDVTMIN_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PMEUNFLTMIN_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PNIPCVMAX_MAP_X" "6"
    SYSTEM_CONSTANT "RAIL_PNIPCVMAX_MAP_Y" "12"
    SYSTEM_CONSTANT "RAIL_PNIPCVMIN_MAP_X" "6"
    SYSTEM_CONSTANT "RAIL_PNIPCVMIN_MAP_Y" "12"
    SYSTEM_CONSTANT "RAIL_PPCVCLOSEOFS_CURX" "4"
    SYSTEM_CONSTANT "RAIL_PPCVDVTMAX_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PPCVFLTMIN_CURX" "16"
    SYSTEM_CONSTANT "RAIL_PPCVINITI_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PPCVINITI_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PPCVREDOFS_CURX" "4"
    SYSTEM_CONSTANT "RAIL_PPCVSETMAX_CURX" "4"
    SYSTEM_CONSTANT "RAIL_PPRECTL_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PPRECTL_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PRESS_ABS" "0"
    SYSTEM_CONSTANT "RAIL_PRESS_DIF" "1"
    SYSTEM_CONSTANT "RAIL_PSETMIN_CURX" "4"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM0_MAPX" "12"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTAPSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM0_MAPX" "12"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTATSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM0_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM0_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM1_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM1_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM2_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM2_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM3_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM3_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM4_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM4_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM5_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM5_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM6_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM6_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM7_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBASEOM7_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTBATTMIN_CURX" "4"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM0_MAPX" "12"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM0_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM1_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM1_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM2_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM2_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM3_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM3_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM4_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM4_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM5_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM5_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM6_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM6_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM7_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTETSCOREOM7_MAPY" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTFTSCOR_MAPX" "12"
    SYSTEM_CONSTANT "RAIL_PSETPOINTFTSCOR_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_PSETPOINTLIMNFLTEMP_MAPX" "8"
    SYSTEM_CONSTANT "RAIL_PSETPOINTLIMNFLTEMP_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_PSETPOINTMAX_MAPX" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTMAX_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_PSETPOINTMIN_MAPX" "2"
    SYSTEM_CONSTANT "RAIL_PSETPOINTMIN_MAPY" "2"
    SYSTEM_CONSTANT "RAIL_PSETPOINTTEMPCORRGNX_AXIS" "16"
    SYSTEM_CONSTANT "RAIL_PSETPOINTTEMPCORRGNY_AXIS" "16"
    SYSTEM_CONSTANT "RAIL_P_MAX" "1800000"
    SYSTEM_CONSTANT "RAIL_P_ZERO" "0"
    SYSTEM_CONSTANT "RAIL_QCPCTLTYPERGN_CURX" "8"
    SYSTEM_CONSTANT "RAIL_QCPCTLTYPE_CURX" "8"
    SYSTEM_CONSTANT "RAIL_QFLPLIM_MAPX" "10"
    SYSTEM_CONSTANT "RAIL_QFLPLIM_MAPY" "5"
    SYSTEM_CONSTANT "RAIL_QFLTEMPLIM_MAPX" "12"
    SYSTEM_CONSTANT "RAIL_QFLTEMPLIM_MAPY" "8"
    SYSTEM_CONSTANT "RAIL_QMEUNCTLTYPE_CURX" "8"
    SYSTEM_CONSTANT "RAIL_QPCVCTLTYPE_CUR_X" "8"
    SYSTEM_CONSTANT "RAIL_RZFCINITDWN_CURX" "6"
    SYSTEM_CONSTANT "RAIL_RZFCINITUP_CURX" "6"
    SYSTEM_CONSTANT "RAIL_SPEED_CNT" "4"
    SYSTEM_CONSTANT "RAIL_SWTCTLSEL_TYPE" "2"
    SYSTEM_CONSTANT "RAIL_SWTCTLSEL_VAL" "0"
    SYSTEM_CONSTANT "RAIL_SWTPRECTL_TYPE" "2"
    SYSTEM_CONSTANT "RAIL_SWTPRECTL_VAL" "0"
    SYSTEM_CONSTANT "RAIL_SWTPRESS_TYPE" "2"
