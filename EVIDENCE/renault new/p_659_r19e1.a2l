	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_owe_toil_off */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_owe_toil_off */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_owe_toil_off */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_owe_toil_off */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_owe_toil_off */
	/begin AXIS_DESCR
			COM_AXIS
			ClLubWea_NVM.Vxx_owe_toil_eng_off_prev_NVM
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_owe_toil_off 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_owe_toil_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_owe_toil_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_owe_toil_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_owe_toil_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_owe_toil_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_owe_toil_sta
			RB_CONV_DegC
			8
			-40
			200
        AXIS_PTS_REF Ctb_owe_toil_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_dp_err
		"Table of minimum pressure difference for broken detection depending on air flow and CSF efficiency"
		MAP
		0x80045e74
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_diag_dp_err 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_egaf_fil2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_egaf_fil2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_egaf_fil2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_egaf_fil2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_egaf_fil2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_diag_egaf_fil
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			10
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_diag_egaf_fil2 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_efy */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			9
			0.
			200.
        AXIS_PTS_REF Ctb_pft_diag_efy 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_dp_ovl
		"Table of maximum pressure difference for overload detection depending on air flow and CSF efficiency"
		MAP
		0x80046500
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_diag_dp_ovl 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_egaf_fil2_lkg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_egaf_fil2_lkg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_egaf_fil2_lkg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_egaf_fil2_lkg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_egaf_fil2_lkg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_diag_egaf_fil_lkg
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			10
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_diag_egaf_fil2_lkg 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_efy_lkg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			9
			0.
			200.
        AXIS_PTS_REF Ctb_pft_diag_efy_lkg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_fms_max_zon_1
		"Table of maximal fuel quantity depending on engine speed and gear engaged for Zone 1 diagnosis"
		MAP
		0x800462e2
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_pft_diag_fms_max_zon_1 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_pft_diag_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_pft_diag_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_fms_max_zon_2
		"Table of maximal fuel quantity depending on engine speed and gear engaged for Zone 2 diagnosis"
		MAP
		0x800461e2
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_pft_diag_fms_max_zon_2 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_pft_diag_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_pft_diag_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_fms_max_zon_3
		"Table of maximal fuel quantity depending on engine speed and gear engaged for Zone 3 diagnosis"
		MAP
		0x800460e2
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_pft_diag_fms_max_zon_3 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_pft_diag_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_pft_diag_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_fms_max_zon_4
		"Table of maximal fuel quantity depending on engine speed and gear engaged for Zone 4 diagnosis"
		MAP
		0x80045fe2
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_pft_diag_fms_max_zon_4 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_pft_diag_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_pft_diag_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_rat_err_max
		"Maximum ratio to detect possible broken filter"
		MAP
		0x80045dc0
		RSA_RecordLayout_MAP_UWORD
		2
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_pft_diag_rat_err_max 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_egaf_fil3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_diag_egaf_fil3
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			10
			0.
			255.
        AXIS_PTS_REF Ctb_pft_diag_egaf_fil3 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_efy */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_efy */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			9
			0.
			200.
        AXIS_PTS_REF Ctb_pft_diag_efy 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_diag_rat_ovl_max
		"Table of maximum ratio to detect possible overload filter depending on air flow and CSF efficiency"
		MAP
		0x8004644c
		RSA_RecordLayout_MAP_UWORD
		2
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_pft_diag_rat_ovl_max 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_ind_lkg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_ind_lkg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_egaf_ind_lkg
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			10
			0.
			10.
        AXIS_PTS_REF Ctb_pft_egaf_ind_lkg 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_diag_efy_lkg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_diag_efy_lkg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_efy_prct
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			9
			0.
			200.
        AXIS_PTS_REF Ctb_pft_diag_efy_lkg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_dp_egaf_0
		"1st table of diff pressure=f(soot,Qvol)"
		MAP
		0x8004683a
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_dp_egaf_0 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ms_test */
	/begin AXIS_DESCR
			COM_AXIS
			Vtx_pft_ms_test[0]
			arAgssb_cAzswia_pjzaDlc_gA_020a
			5
			-255.
			255.
        AXIS_PTS_REF Ctb_pft_ms_test 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_egaf_mv_zon 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_dp_egaf_1
		"2nd table of diff pressure=f(soot,Qvol)"
		MAP
		0x800467ea
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_dp_egaf_1 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ms_test */
	/begin AXIS_DESCR
			COM_AXIS
			Vtx_pft_ms_test[0]
			arAgssb_cAzswia_pjzaDlc_gA_020a
			5
			-255.
			255.
        AXIS_PTS_REF Ctb_pft_ms_test 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_egaf_mv_zon 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_dp_egaf_2
		"3rd table of diff pressure=f(soot,Qvol)"
		MAP
		0x8004679a
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_dp_egaf_2 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ms_test */
	/begin AXIS_DESCR
			COM_AXIS
			Vtx_pft_ms_test[0]
			arAgssb_cAzswia_pjzaDlc_gA_020a
			5
			-255.
			255.
        AXIS_PTS_REF Ctb_pft_ms_test 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_egaf_mv_zon 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_dp_egaf_3
		"4th table of diff pressure=f(soot,Qvol)"
		MAP
		0x8004674a
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_dp_egaf_3 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ms_test */
	/begin AXIS_DESCR
			COM_AXIS
			Vtx_pft_ms_test[0]
			arAgssb_cAzswia_pjzaDlc_gA_020a
			5
			-255.
			255.
        AXIS_PTS_REF Ctb_pft_ms_test 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_egaf_mv_zon 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_dp_egaf_4
		"5th table of diff pressure=f(soot,Qvol)"
		MAP
		0x800466fa
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_dp_egaf_4 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ms_test */
	/begin AXIS_DESCR
			COM_AXIS
			Vtx_pft_ms_test[0]
			arAgssb_cAzswia_pjzaDlc_gA_020a
			5
			-255.
			255.
        AXIS_PTS_REF Ctb_pft_ms_test 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_egaf_mv_zon 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_dp_egaf_5
		"6th table of diff pressure=f(soot,Qvol)"
		MAP
		0x800466aa
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_pft_dp_egaf_5 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_ms_test */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_ms_test */
	/begin AXIS_DESCR
			COM_AXIS
			Vtx_pft_ms_test[0]
			arAgssb_cAzswia_pjzaDlc_gA_020a
			5
			-255.
			255.
        AXIS_PTS_REF Ctb_pft_ms_test 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf_mv_zon */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_egaf_mv_zon 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_egaf_sot_esti
		"Table of combustion speed"
		MAP
		0x800468d6
		RSA_RecordLayout_MAP_UWORD
		0.65535
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		0.
		0.65535
    DISPLAY_IDENTIFIER Cmp_pft_egaf_sot_esti 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_temp_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_temp_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_temp_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_temp_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_temp_fac_sot_esti */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_temp_fac_sot_esti
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			1200.
        AXIS_PTS_REF Ctb_pft_temp_fac_sot_esti 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_o2_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_o2_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_o2_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_o2_fac_sot_esti */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_o2_fac_sot_esti */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_o2_fac_sot_esti
			gBspFma_crfhuEa_yctdhoa_f_Ra0oa
			4
			0.
			200.
        AXIS_PTS_REF Ctb_pft_o2_fac_sot_esti 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_egaf_tt_t
		"Interpolation map of sampling time depending on exhaust gas air flow and temperature before turbine"
		MAP
		0x80058e06
		RSA_RecordLayout_MAP_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Cmp_pft_egaf_tt_t 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_egaf */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_egaf */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_egaf */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_egaf */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_egaf */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_egaf
			ppmBusd_Dwihbha_vDEsrCc_mhA_10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_pft_egaf 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tt */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tt */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tt */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tt */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tt */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tt
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			1200.
        AXIS_PTS_REF Ctb_tt 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_flp_pr_bas_oil_dil
		"Late post calibration of dilution measuring point"
		MAP
		0x800559b2
		RSA_RecordLayout_MAP_UWORD
		100
		RB_CONV_mgperstrk
		0.0
		100.0
    DISPLAY_IDENTIFIER Cmp_pft_flp_pr_bas_oil_dil 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_n_oil_flp_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			RB_CONV_rpm
			16
			0
			16383.75
        AXIS_PTS_REF Ctb_pft_n_oil_flp_bas 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			RB_CONV_Nm
			16
			0.0
			2047.96875
        AXIS_PTS_REF Ctb_pft_tqi_sp_flp_bas 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_flp_pr_fac_cor_dil
		"Correction factor of dilution rate  as function of late post quantity deviation"
		MAP
		0x800557b2
		RSA_RecordLayout_MAP_UWORD
		6.5535
		RB_CONV_0001_FACT
		0.0
		6.5535
    DISPLAY_IDENTIFIER Cmp_pft_flp_pr_fac_cor_dil 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_n_oil_flp_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_n_oil_flp_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			RB_CONV_rpm
			16
			0
			16383.75
        AXIS_PTS_REF Ctb_pft_n_oil_flp_bas 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tqi_sp_flp_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			RB_CONV_Nm
			16
			0.0
			2047.96875
        AXIS_PTS_REF Ctb_pft_tqi_sp_flp_bas 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_ms_vnt_ctl_ofs
		"as_bst_ctl_bpolcri/PWM offset for VNT depending on catalytic soot filter charge in RIJ and PP modes"
		MAP
		0x8005e7c6
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_pft_ms_vnt_ctl_ofs 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_pft_vnt_ctl_ofs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_cyl_comb
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_pft_vnt_ctl_ofs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_pft_vnt_ctl_ofs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_pft_vnt_ctl_ofs */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			10
			0.
			100.
        AXIS_PTS_REF Ctb_y_pft_vnt_ctl_ofs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_ms_vnt_ctl_ofs_pr
		"PWM offset for VNT depending on catalytic soot filter charge in PR and NPU modes"
		MAP
		0x8005de20
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_pft_ms_vnt_ctl_ofs_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_pft_vnt_ctl_ofs_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm_cyl_comb
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_pft_vnt_ctl_ofs_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_pft_vnt_ctl_ofs_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_pft_vnt_ctl_ofs_pr */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			10
			0.
			100.
        AXIS_PTS_REF Ctb_y_pft_vnt_ctl_ofs_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_n_spg_sp_max_pr
		"Bap setpoint limitation from   pft soot mass  pressure in regeneration mode"
		MAP
		0x8005f670
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_pft_n_spg_sp_max_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_pft_spg_sp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_pft_spg_sp_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_pft_spg_sp_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_pft_spg_sp_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_y_pft_spg_sp_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_n_spg_sp_max_rij
		"B.a.p setpoint limitation from before  particule filter  pressure in regular injection mode"
		MAP
		0x8005fe70
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_pft_n_spg_sp_max_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_pft_sp_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_pft_sp_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_pft_sp_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_pft_sp_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_y_pft_sp_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_n_tqi_sp_oil_dil
		"table of oil dilution for regeneration allowance"
		MAP
		0x800555b2
		RSA_RecordLayout_MAP_UWORD
		10
		RB_CONV_001_Prc
		0.0
		10.0
    DISPLAY_IDENTIFIER Cmp_pft_n_tqi_sp_oil_dil 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_n_oil_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_n_oil_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_n_oil_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_n_oil_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_n_oil_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			RB_CONV_rpm
			16
			0
			16383.75
        AXIS_PTS_REF Ctb_pft_n_oil_1 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tqi_sp_oil_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tqi_sp_oil_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tqi_sp_oil_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tqi_sp_oil_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tqi_sp_oil_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			RB_CONV_Nm
			16
			0.0
			2047.96875
        AXIS_PTS_REF Ctb_pft_tqi_sp_oil_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_n_tqi_sp_oil_rij
		"dilution measuring point in normal mode"
		MAP
		0x80055494
		RSA_RecordLayout_MAP_UWORD
		1
		RB_CONV_1_65535_Prc
		0.0
		1.0
    DISPLAY_IDENTIFIER Cmp_pft_n_tqi_sp_oil_rij 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_n_oil_rij_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_n_oil_rij_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_n_oil_rij_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_n_oil_rij_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_n_oil_rij_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			RB_CONV_rpm
			13
			0
			16383.75
        AXIS_PTS_REF Ctb_pft_n_oil_rij_bas 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tqi_sp_rij_bas */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tqi_sp_rij_bas */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tqi_sp_rij_bas */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tqi_sp_rij_bas */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tqi_sp_rij_bas */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			RB_CONV_Nm
			11
			0.0
			2047.96875
        AXIS_PTS_REF Ctb_pft_tqi_sp_rij_bas 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_oil_csm
		"Map of engine oil consumption dependent on hte fuel injection quantity and the engine speed"
		MAP
		0x80058450
		RSA_RecordLayout_MAP_UWORD
		0.65535
		qdgunob_kBlEwyb_bgBrBgd_k__00a0
		0.
		0.65535
    DISPLAY_IDENTIFIER Cmp_pft_oil_csm 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_n_oil_csm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_n_oil_csm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_n_oil_csm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_n_oil_csm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_n_oil_csm */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_pft_n_oil_csm 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tqi_oil_csm */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tqi_oil_csm */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tqi_oil_csm */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tqi_oil_csm */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tqi_oil_csm */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			hcbCBdc_eypFcyc_nbBriqd_mt__1a0
			8
			0.
			100.
        AXIS_PTS_REF Ctb_pft_tqi_oil_csm 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_temp_min_rgn
		"Map giving the authorization for the regeneration"
		MAP
		0x80068078
		RSA_RecordLayout_MAP_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cmp_pft_temp_min_rgn 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco_ena
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_rgn 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_rgn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_rgn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_rgn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_rgn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_rgn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_ena
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_rgn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_pft_temp_min_rgn_ena
		"Map that allows transition to regeneration"
		MAP
		0x80068054
		RSA_RecordLayout_MAP_UBYTE
		2.55
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Cmp_pft_temp_min_rgn_ena 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_rgn_ena */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_rgn_ena */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_rgn_ena */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_rgn_ena */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_rgn_ena */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco_ena
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_rgn_ena 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_rgn_ena */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_rgn_ena */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_rgn_ena */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_rgn_ena */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_rgn_ena */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_ena
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_rgn_ena 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_puls_maf_cor
		"Pulsation correction map"
		MAP
		0x80057412
		RSA_RecordLayout_MAP_UWORD
		2
		dzejcha_hlcsspd_Bqhaoqb_n__200a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_puls_maf_cor 
    FORMAT "%7.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_maf_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_maf_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_maf_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_maf_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_maf_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			18
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_maf_cor 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_maf_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_amp_cor_pr
		"Atmospheric pressure correction for rail pressure during pr"
		MAP
		0x8004d8e8
		RSA_RecordLayout_MAP_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		-2000.
		2000.
    DISPLAY_IDENTIFIER Cmp_rps_amp_cor_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_amp_tco_cor_rij
		"Atmospheric pressure correction for rail pressure"
		MAP
		0x8004e7ca
		RSA_RecordLayout_MAP_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		-2000.
		2000.
    DISPLAY_IDENTIFIER Cmp_rps_amp_tco_cor_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_amp_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_amp_tco_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_amp_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_amp_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_amp_tco_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_amp_tco_fac_rij
		"Factor of atmospheric pressure correction for rail pressure"
		MAP
		0x8004e79a
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_rps_amp_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_rps_amp_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_rps_amp_tco_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_rps_amp_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_rps_amp_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_rps_amp_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_bas_0p_pr
		"Basic rail pressure without pre-injection during pr"
		MAP
		0x8004d7e8
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_bas_0p_pr 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_0p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_0p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_0p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_0p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_0p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_bas_0p_rij
		"Basic rail pressure set point without pre-injection"
		MAP
		0x8004e69a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_bas_0p_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_0p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_0p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_bas_1p_pr
		"Basic rail pressure with 1 pre-injection during pr"
		MAP
		0x8004d5e8
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_bas_1p_pr 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_1p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_1p_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_1p_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_1p_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_1p_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_bas_1p_rij
		"Basic rail pressure set point with 1 pre-injection"
		MAP
		0x8004e49a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_bas_1p_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_1p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_1p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_cold_tco_0p_rij
		"Rail pressure for cold coolant temperature without pre injection"
		MAP
		0x8004e39a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_cold_tco_0p_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_0p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_0p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_cold_tco_1p_rij
		"Rail pressure for cold coolant temperature with 1 pre injection"
		MAP
		0x8004e19a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_cold_tco_1p_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_1p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_1p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_grd_prs_inc_prs
		""
		MAP
		0x80069008
		RSA_RecordLayout_MAP_UWORD
		4500
		ahqcwla_mcvrhmc_acrzCga_bp__a0a
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_grd_prs_inc_prs 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_grd_prs_inc_prs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_grd_prs_inc_prs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_grd_prs_inc_prs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_grd_prs_inc_prs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_grd_prs_inc_prs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_max_pr
		"Maximun rail pressure set point during pr"
		MAP
		0x8004d520
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_max_pr 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_max_rij
		"Maximun rail pressure set point"
		MAP
		0x8004e0d2
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_max_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_max_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_max_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_max_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_max_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_min_pr
		"Minimun rail pressure set point during pr"
		MAP
		0x8004d458
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_min_pr 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_min_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_min_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_min_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_min_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_min_rij
		"Minimum rail pressure set point"
		MAP
		0x8004e00a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_min_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_min_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_min_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_min_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_min_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_mv_tco_0p_rij
		"Rail pressure for medium coolant temperature without pre injection"
		MAP
		0x8004df0a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_mv_tco_0p_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_0p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_0p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_0p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_0p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_mv_tco_1p_rij
		"Rail pressure for medium coolant temperature with 1 pre injection"
		MAP
		0x8004dd0a
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_mv_tco_1p_rij 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_1p_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_1p_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_1p_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_1p_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_sp_amp_cor_sta
		"Rail pressure correction table during Starting Combustion Mode"
		MAP
		0x80068e22
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_sp_amp_cor_sta 
    FORMAT "%4.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_sp_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_sp_amp_cor_sta 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_rps_sp_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_rps_sp_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_rps_sp_amp_cor_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_sp_dec
		"Matrix for rail pressure setpoint decrease by fuel temperature"
		MAP
		0x80068f88
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_sp_dec 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_sp_dec */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_sp_dec 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_sp_dec */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_sp_dec */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_sp_dec 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_sp_lim_abs
		"Matrix for rail pressure setpoint limitation absolute"
		MAP
		0x80068f08
		RSA_RecordLayout_MAP_UWORD
		4500
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		0.
		4500.
    DISPLAY_IDENTIFIER Cmp_rps_sp_lim_abs 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_sp_lim_abs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_sp_lim_abs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fuel_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fuel_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fuel_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fuel_rps_sp_lim_abs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fuel_rps_sp_lim_abs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fuel_temp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fuel_rps_sp_lim_abs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_tco_cor_pr
		"Coolant temperature correction for rail pressure during pr"
		MAP
		0x8004d338
		RSA_RecordLayout_MAP_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		-2000.
		2000.
    DISPLAY_IDENTIFIER Cmp_rps_tco_cor_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_tco_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_tco_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_tco_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_tco_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_tia_cor_pr
		"Intake air temperature correction for rail pressure during pr"
		MAP
		0x8004d218
		RSA_RecordLayout_MAP_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		-2000.
		2000.
    DISPLAY_IDENTIFIER Cmp_rps_tia_cor_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_tia_tco_cor_rij
		"Intake air temperature correction for rail pressure"
		MAP
		0x8004dbea
		RSA_RecordLayout_MAP_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		-2000.
		2000.
    DISPLAY_IDENTIFIER Cmp_rps_tia_tco_cor_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_rps_tia_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_rps_tia_tco_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_rps_tia_tco_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_rps_tia_tco_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_tgt
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_rps_tia_tco_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_rps_tia_tco_fac_rij
		"Factor of intake air temperature correction for rail pressure"
		MAP
		0x8004dbba
		RSA_RecordLayout_MAP_UWORD
		10
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		-5.
		5.
    DISPLAY_IDENTIFIER Cmp_rps_tia_tco_fac_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_rps_tia_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_rps_tia_tco_fac_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_rps_tia_tco_fac_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_rps_tia_tco_fac_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			3
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_rps_tia_tco_fac_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkppxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_cor_pp_1
		"Smoke richness correction depending on coolant temperature in pp mode"
		MAP
		0x80041d98
		RSA_RecordLayout_MAP_UWORD
		8
		EufABca_arlgeCc_grheqod_BCRao0a
		-4.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_cor_pp_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_tco 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_n_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkppxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_cor_pp_2
		"Smoke richness correction depending on rail pressure error in pp mode"
		MAP
		0x80041b98
		RSA_RecordLayout_MAP_UWORD
		8
		EufABca_arlgeCc_grheqod_BCRao0a
		-4.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_cor_pp_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_rps_rail_prs_dif
			AhCDoja_prbvulb_dammzgc_b__0a0a
			16
			-2000.
			2000.
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_rail_prs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_n_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_cor_rij_1
		"Smoke richness correction depending on coolant temperature in RIJ mode"
		MAP
		0x80042daa
		RSA_RecordLayout_MAP_UWORD
		8
		EufABca_arlgeCc_grheqod_BCRao0a
		-4.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_cor_rij_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_tco 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_n_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_n_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_cor_rij_2
		"Smoke richness correction depending on rail pressure error in RIJ mode"
		MAP
		0x80042baa
		RSA_RecordLayout_MAP_UWORD
		8
		EufABca_arlgeCc_grheqod_BCRao0a
		-4.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_cor_rij_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_rail_prs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_rps_rail_prs_dif
			AhCDoja_prbvulb_dammzgc_b__0a0a
			16
			-2000.
			2000.
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_rail_prs 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_cor_n_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_cor_n_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkppxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_n_maf_pp
		"Smoke richness limitation in pp mode"
		MAP
		0x80041998
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_n_maf_pp 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_maf_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_maf_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_maf_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_maf_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_maf_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_rich_lim_maf_pp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_n_pp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_n_pp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_n_pp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_n_pp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_n_pp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_n_pp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_n_maf_pr
		"Smoke richness limitation in pr mode"
		MAP
		0x8004206c
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_n_maf_pr 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_maf_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_maf_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_maf_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_maf_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_maf_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_rich_lim_maf_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_n_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_n_maf_rij_1
		"Smoke richness limitation in RIJ mode depending on gear"
		MAP
		0x800429aa
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_n_maf_rij_1 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_maf_rij_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_maf_rij_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_maf_rij_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_rich_lim_maf_rij_1 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_n_rij_1 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_n_rij_1 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_n_rij_1 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_n_rij_1 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_n_rij_1 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_n_rij_1 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_n_maf_rij_2
		"Smoke richness limitation in RIJ mode depending on gear"
		MAP
		0x800427aa
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_n_maf_rij_2 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_maf_rij_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_maf_rij_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_maf_rij_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_rich_lim_maf_rij_2 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_n_rij_2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_n_rij_2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_n_rij_2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_n_rij_2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_n_rij_2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_n_rij_2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_n_maf_rij_3
		"Smoke richness limitation in RIJ mode depending on gear"
		MAP
		0x800425aa
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_n_maf_rij_3 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_maf_rij_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_maf_rij_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_maf_rij_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_rich_lim_maf_rij_3 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_n_rij_3 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_n_rij_3 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_n_rij_3 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_n_rij_3 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_n_rij_3 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_n_rij_3 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_rich_lim_n_maf_rij_amp
		"Smoke richness correction depending on atmospheric pressure in RIJ mode"
		MAP
		0x800423aa
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_rich_lim_n_maf_rij_amp 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_maf_rij_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_maf_rij_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_maf_rij_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_maf_rij_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			16
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_rich_lim_maf_rij_amp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_rich_lim_n_rij_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_rich_lim_n_rij_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_rich_lim_n_rij_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_rich_lim_n_rij_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_rich_lim_n_rij_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_rich_lim_n_rij_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_tkof_ofs_pr
		"Smoke richness offset for takeoff in PR mode"
		MAP
		0x80041fec
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_tkof_ofs_pr 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_rich_maf_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_rich_maf_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_rich_maf_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_rich_maf_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_rich_maf_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			8
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_tkof_rich_maf_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_rich_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_rich_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_rich_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_rich_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_rich_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_tkof_rich_n_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_smk_tkof_ofs_rij
		"Smoke richness offset for takeoff in RIJ mode"
		MAP
		0x8004232a
		RSA_RecordLayout_MAP_UWORD
		4
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		0.
		4.
    DISPLAY_IDENTIFIER Cmp_smk_tkof_ofs_rij 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_rich_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_rich_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_rich_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_rich_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_rich_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_smk_tkof_rich_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_smk_tkof_rich_maf_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_smk_tkof_rich_maf_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_smk_tkof_rich_maf_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_smk_tkof_rich_maf_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_smk_tkof_rich_maf_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_maf_dyn
			jkAkzAa_urBxnEd_ptjsFeb_mt__10a
			8
			0.
			5000.
        AXIS_PTS_REF Ctb_smk_tkof_rich_maf_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_spg_fail_val
		"Boost pressure default value calculation map"
		MAP
		0x80057806
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_spg_fail_val 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_spg_fail_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_spg_fail_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_spg_fail_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_spg_fail_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_spg_fail_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_spg_fail_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_spg_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_spg_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_spg_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_spg_fail_fim_tot */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_spg_fail_fim_tot */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fms_fim_tot
			hcbCBdc_eypFcyc_nbBriqd_mt__1a0
			8
			0.
			100.
        AXIS_PTS_REF Ctb_spg_fail_fim_tot 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_spg_sp_ex_df_cor_pr
		"Basic intake air temperature correction of boost pressure setpoint in case of exhaust pressure sensor limphome in particule filter"
		MAP
		0x8005f530
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_spg_sp_ex_df_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_ex_df_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_ex_df_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_ex_df_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_ex_df_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_ex_df_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_spg_sp_ex_df_cor_rij
		"Basic intake air temperature correction of boost pressure setpoint in case of exhaust pressure sensor limphome in regular injection"
		MAP
		0x8005fd30
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_spg_sp_ex_df_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_ex_df_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_ex_df_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_ex_df_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_ex_df_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_ex_df_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_t_ms_sta_asd_var_utp_sp
		"Interpolation table of CSF up temp setpoint depending on time and soot mass requested by after-sale regeneration"
		MAP
		0x8004599a
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_t_ms_sta_asd_var_utp_sp 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_t_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_t_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_t_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_t_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_t_asd_var_utp_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_asd_rgn_var_utp_ctr
			isbAByd_airlCCb_devbarc_s_R0ooa
			8
			0.
			6553.5
        AXIS_PTS_REF Ctb_t_asd_var_utp_sp 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ms_sta_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ms_sta_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ms_sta_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ms_sta_asd_var_utp_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ms_sta_asd_var_utp_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_ms_sta_asd
			CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
			8
			0.
			100.
        AXIS_PTS_REF Ctb_ms_sta_asd_var_utp_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_act_amp_rij
		"Atmospheric pressure correction map for activation regulator in RIJ mode"
		MAP
		0x80049582
		RSA_RecordLayout_MAP_UWORD
		200
		gretyea_ujEhBid_tCpaEic_n__1a0a
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_act_amp_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_act_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_act_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_act_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_act_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_act_amp_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_act_amp_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_act_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_act_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_act_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_act_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_act_amp_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_act_amp_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_act_reg_pr
		"Map for activation regulator in PR mode"
		MAP
		0x800487b6
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_act_reg_pr 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_act_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_act_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_act_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_act_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_act_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_act_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_act_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_act_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_act_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_act_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_act_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_act_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_act_reg_rij
		"Map for activation regulator in RIJ mode"
		MAP
		0x80049462
		RSA_RecordLayout_MAP_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_act_reg_rij 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_act_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_act_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_act_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_act_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_act_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_act_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_act_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_act_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_act_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_act_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_act_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_act_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_adv_max_amp_cor_pr
		"Map for maximal advance correction in PR mode"
		MAP
		0x80048736
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_tbt_adv_max_amp_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_adv_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_adv_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_adv_max_cor_pr
		"Map for maximal advance correction in PR mode"
		MAP
		0x80048536
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_tbt_adv_max_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_adv_cor_bas_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_adv_cor_bas_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_adv_max_tia_cor_pr
		"Basic Map of the maximal advance correction function of the air temperature in PR mode"
		MAP
		0x800484b6
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_tbt_adv_max_tia_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_adv_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_adv_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_adv_min_amp_cor_pr
		"Basic Map of the minimal advance correction function of the atmospheric pressure in PR mode"
		MAP
		0x80048436
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_tbt_adv_min_amp_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_adv_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_adv_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_adv_min_cor_pr
		"Map for minimal advance correction in PR mode"
		MAP
		0x80048236
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_tbt_adv_min_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_bas_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_adv_cor_bas_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_bas_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_adv_cor_bas_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_adv_min_tia_cor_pr
		"Basic Map of the minimal advance correction function of the air temperature in PR mode"
		MAP
		0x800481b6
		RSA_RecordLayout_MAP_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		-360.
		360.
    DISPLAY_IDENTIFIER Cmp_tbt_adv_min_tia_cor_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_adv_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_adv_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_adv_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_dg_fac_pr
		"Curve of D part gain in PR mode"
		MAP
		0x80048096
		RSA_RecordLayout_MAP_UWORD
		3
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		0.
		3.
    DISPLAY_IDENTIFIER Cmp_tbt_dg_fac_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_pid_fac_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_tqi */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_pid_fac_tqi 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fim_main_max_pr
		"Map for maximal fuel main quantity correction in PR mode"
		MAP
		0x80047f76
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fim_main_max_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fim_main_max_rij
		"Map for maximal fuel main quantity correction in RIJ mode"
		MAP
		0x80049342
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fim_main_max_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fim_main_min_pr
		"Map for minimal fuel main quantity correction in PR mode"
		MAP
		0x80047e56
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fim_main_min_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fim_main_min_rij
		"Map for minimal fuel main quantity correction in RIJ mode"
		MAP
		0x80049222
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fim_main_min_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fim_main_ovt_pr
		"Map for maximal fuel main quantity correction if OVT is active in pr mode"
		MAP
		0x80047d36
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fim_main_ovt_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fim_main_ovt_rij
		"Map for maximal fuel main quantity correction if OVT is active in RIJ mode"
		MAP
		0x80049102
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fim_main_ovt_rij 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fim_main_cor_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fim_main_cor_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fpo_max_amp_cor_pr
		"Basic Map of the maximal fuel post correction function of the atmospheric pressure in PR mode"
		MAP
		0x80047cb6
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fpo_max_amp_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fpo_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fpo_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fpo_max_cor_pr
		"Map for maximal fuel quantity correction of the post injection in PR mode"
		MAP
		0x80047b96
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fpo_max_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fpo_cor_bas_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fpo_cor_bas_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fpo_max_tia_cor_pr
		"Basic Map of the maximal fuel post correction function of the air temperature in PR mode"
		MAP
		0x80047b16
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fpo_max_tia_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fpo_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fpo_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fpo_min_amp_cor_pr
		"Basic Map of the minimal fuel post correction function of the atmospheric pressure in PR mode"
		MAP
		0x80047a96
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fpo_min_amp_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fpo_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fpo_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fpo_min_cor_pr
		"Map for minimal fuel quantity correction of the post injection in PR mode"
		MAP
		0x80047976
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fpo_min_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_bas_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fpo_cor_bas_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_bas_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fpo_cor_bas_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_fpo_min_tia_cor_pr
		"Basic Map of the minimal fuel post correction function of the air temperature in PR mode"
		MAP
		0x800478f6
		RSA_RecordLayout_MAP_UWORD
		200
		fmmmApb_sBgvABb_isuEced_mtA0000
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_fpo_min_tia_cor_pr 
    FORMAT "%5.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_fpo_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_fpo_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_fpo_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_ig_fac_pr
		"Curve of I part gain in PR mode"
		MAP
		0x800477d6
		RSA_RecordLayout_MAP_UWORD
		3
		rEBznhd_Dkorjta_Aqgesjb_1CC_1o0
		0.
		3.
    DISPLAY_IDENTIFIER Cmp_tbt_ig_fac_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_pid_fac_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_tqi */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_pid_fac_tqi 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_max_tqi_min_cor_pr
		"Map for minimal correction of the max inner torque in regular PR mode"
		MAP
		0x80047716
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cmp_tbt_max_tqi_min_cor_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_max_tqi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_max_tqi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_max_tqi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_max_tqi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_max_tqi_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_max_tqi_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_max_tqi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_max_tqi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_max_tqi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_max_tqi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_max_tqi_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_max_tqi_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_max_tqi_min_cor_rij
		"Map for minimal correction of the max inner torque in RIJ mode"
		MAP
		0x80049042
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cmp_tbt_max_tqi_min_cor_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_max_tqi_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_max_tqi_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_max_tqi_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_max_tqi_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_max_tqi_cor_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_max_tqi_cor_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_max_tqi_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_max_tqi_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_max_tqi_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_max_tqi_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_max_tqi_cor_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_max_tqi_cor_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_pg_fac_pr
		"Curve for P part gain in PR mode"
		MAP
		0x800475f6
		RSA_RecordLayout_MAP_UWORD
		3
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		0.
		3.
    DISPLAY_IDENTIFIER Cmp_tbt_pg_fac_pr 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_pid_fac_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_pid_fac_tqi */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_pid_fac_tqi */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_pid_fac_tqi 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_amp_pr
		"MAP for correction of tbt target f(atmo pressure) in PR mode"
		MAP
		0x80047576
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_amp_pr 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_amp_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_amp_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_amp_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_amp_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_amp_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_amp_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_amp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_amp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_amp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_amp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_amp_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_sp_amp_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_ms_amp_fac_rij
		"Map for temp tbt setpoint correction f(soot mass, atmospheric pressure) in RIJ mode"
		MAP
		0x80048fc2
		RSA_RecordLayout_MAP_UWORD
		200
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		-100.
		100.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_ms_amp_fac_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_ms */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_ms */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_ms */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_ms */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_ms */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			8
			0.
			100.
        AXIS_PTS_REF Ctb_tbt_sp_ms 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_tbt_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_ms_amp_rij
		"Correction map of TBT setpoint in RIJ mode"
		MAP
		0x80048f42
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_ms_amp_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_ms_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_ms_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_ms_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_ms_amp_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_ms_amp_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_ms_amp_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_ms_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_ms_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_ms_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_ms_amp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_ms_amp_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_sp_ms_amp_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_ms_pr
		"MAP for correction of tbt target f(soot mass) in PR mode"
		MAP
		0x800474f6
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_ms_pr 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_ms_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_ms_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_ms_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_ms_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_ms_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_ms_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_ms_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_ms_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_ms_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_ms_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_ms_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_sp_ms_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_pr
		"Map for target temperature before turbine in PR mode"
		MAP
		0x800472f6
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_pr 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_sp_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_rij
		"Map for temperature before turbine setpoint in RIJ mode"
		MAP
		0x80048d42
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_sp_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_tia_pr
		"MAP for correction of tbt target in PR mode"
		MAP
		0x80047276
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_tia_pr 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tia_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tia_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tia_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tia_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tia_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_tia_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tia_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tia_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tia_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tia_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tia_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_sp_tia_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tbt_sp_tia_rij
		"MAP for correction of tbt setpoint in RIJ mode"
		MAP
		0x80048cc2
		RSA_RecordLayout_MAP_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		-40.
		1200.
    DISPLAY_IDENTIFIER Cmp_tbt_sp_tia_rij 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tia_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tia_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tia_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tia_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tia_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tbt_sp_tia_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tbt_sp_tia_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tbt_sp_tia_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tbt_sp_tia_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tbt_sp_tia_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tbt_sp_tia_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tbt_sp_tia_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tco_amp_comb_efy_sta_fac
		"Atmospheric pressure and coolant temperature dependant correection on the comb efficiency during start"
		MAP
		0x8004324e
		RSA_RecordLayout_MAP_UWORD
		1.9921875
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		0.0078125
		2.
    DISPLAY_IDENTIFIER Cmp_tco_amp_comb_efy_sta_fac 
    FORMAT "%7.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_sta_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_sta_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_sta_tco 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_comb_efy_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_comb_efy_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_comb_efy_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_comb_efy_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_comb_efy_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			5
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_comb_efy_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_tco_amp_min_is_n
		"Idle speed setpoint according to the engine coolant temperature and atmospheric pressure"
		MAP
		0x8004143e
		RSA_RecordLayout_MAP_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Cmp_tco_amp_min_is_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_tco 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_eng_amp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_eng_amp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			6
			0.
			20000.
        AXIS_PTS_REF Ctb_eng_amp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_tco_ini_i
		"Initial Power value of Idle Speed regulator integral correction table"
		MAP
		0x8005ab7c
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Cmp_tco_ini_i 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_is_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tia_amp_pft_spc_max_env
		"Interpolation table of environmental correction of maximum injected fuel mass flow correction"
		MAP
		0x80044e60
		RSA_RecordLayout_MAP_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_tia_amp_pft_spc_max_env 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_reg
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_pft_fms_cor 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp_reg
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_pft_fms_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tia_amp_pft_spc_min_env
		"Interpolation table of environmental cor of minimum injected fuel mass flow correction"
		MAP
		0x80044de0
		RSA_RecordLayout_MAP_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_tia_amp_pft_spc_min_env 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_reg
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_pft_fms_cor 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_pft_fms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_pft_fms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp_reg
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_pft_fms_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tia_amp_pft_utp_sp_cor
		"Interpolation table of upstream temperature setpoint environmental correction."
		MAP
		0x8004591a
		RSA_RecordLayout_MAP_UWORD
		6.5535
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_tia_amp_pft_utp_sp_cor 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tia_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tia_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tia_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tia_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tia_pft_utp_sp_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tia_reg
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_tia_pft_utp_sp_cor 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_amp_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_amp_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_amp_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_amp_pft_utp_sp_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_amp_pft_utp_sp_cor */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_amp_reg
			fikncub_fAjCpia_Evxyxob_h_A_1oa
			8
			0.
			20000.
        AXIS_PTS_REF Ctb_amp_pft_utp_sp_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_adv_cor_pr
		"Factor f(advance) for fuel quantity correction to apply to maintain torque realisation in pr mode"
		MAP
		0x8005c1fc
		RSA_RecordLayout_MAP_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_tqi_adv_cor_pr 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_adv_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_adv_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_adv_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_adv_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_adv_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_adv_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_adv_cor_rij
		"Factor f(advance) for fuel quantity correction to apply to maintain torque realisation in rij mode"
		MAP
		0x8005c970
		RSA_RecordLayout_MAP_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_tqi_adv_cor_rij 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_adv_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_adv_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_adv_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_adv_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_adv_cor_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_adv_cor_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_adv_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_adv_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_adv_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_adv_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_adv_cor_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_adv_cor_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_bas_fim_tot_inv_pr
		"Inverse table to calculate efficiency correction based on start of injection and fresh air mass"
		MAP
		0x8005bf74
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_tqi_bas_fim_tot_inv_pr 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			18
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_inv_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_inv_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_inv_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_inv_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_inv_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_smk_fim
			hcbCBdc_eypFcyc_nbBriqd_mt__1a0
			18
			0.
			100.
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_inv_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_bas_fim_tot_inv_rij
		"Map of main torque model inverse (quantity to torque conversion) in RIJ mode"
		MAP
		0x8005c6e8
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_tqi_bas_fim_tot_inv_rij 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			18
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_inv_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_inv_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_inv_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_inv_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_inv_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_smk_fim
			hcbCBdc_eypFcyc_nbBriqd_mt__1a0
			18
			0.
			100.
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_inv_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_bas_fim_tot_pr
		"Main torque model in pr mode"
		MAP
		0x8005bcec
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_tqi_bas_fim_tot_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			18
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			18
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_bas_fim_tot_rij
		"Main torque model during regular combustion mode"
		MAP
		0x8005c460
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_tqi_bas_fim_tot_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			18
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_fim_tot_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_fim_tot_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_fim_tot_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_fim_tot_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_fim_tot_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			18
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_bas_fim_tot_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_bas_lp_ocd
		"torque compensation map in ocd mode"
		MAP
		0x8005bb46
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_tqi_bas_lp_ocd 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_lp_n_ocd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_lp_n_ocd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_lp_n_ocd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_lp_n_ocd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_lp_n_ocd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_bas_lp_n_ocd 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_lp_tqi_ocd */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_lp_tqi_ocd */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_lp_tqi_ocd */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_lp_tqi_ocd */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_lp_tqi_ocd */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_bas_lp_tqi_ocd 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_bas_post_efy_pr
		"Post injection torque model in pr mode"
		MAP
		0x8005cbae
		RSA_RecordLayout_MAP_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_tqi_bas_post_efy_pr 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_post_efy_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_post_efy_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_post_efy_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_post_efy_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_post_efy_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_bas_post_efy_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_bas_post_efy_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_bas_post_efy_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_bas_post_efy_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_bas_post_efy_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_bas_post_efy_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_bas_post_efy_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_maf_cor_pr
		"Factor f(air mass) for fuel quantity correction to apply to maintain torque realisation in pr mode"
		MAP
		0x8005bc5c
		RSA_RecordLayout_MAP_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_tqi_maf_cor_pr 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_maf_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_maf_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_maf_cor_rij
		"Factor f(air mass) for fuel quantity correction to apply to maintain torque realisation in rij mode"
		MAP
		0x8005c3d0
		RSA_RecordLayout_MAP_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_tqi_maf_cor_rij 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_cor_n_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_cor_n_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			12
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_maf_cor_n_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_maf_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_maf_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_maf_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_maf_cor_tqi_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_maf_cor_tqi_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			12
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_maf_cor_tqi_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protqxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_max_fuel_temp_n
		"Protection torque for the hydraulic system in function of the fuel temperature and engine speed"
		MAP
		0x8005ba84
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_tqi_max_fuel_temp_n 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_n2 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_max_fuel_temp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_max_fuel_temp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_max_fuel_temp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_max_fuel_temp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_max_fuel_temp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_fuel_temp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			5
			-40.
			200.
        AXIS_PTS_REF Ctb_tqi_max_fuel_temp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_spg_sp_amp_cor_pr
		"Basic atmospheric pressure correction of boost air pressure setpoint in regeneration mode"
		MAP
		0x8005f3f0
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_tqi_n_spg_sp_amp_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_amp_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_amp_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_amp_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_amp_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_spg_sp_amp_cor_rij
		"Basic atmospheric pressure correction of b.a.p setpoint in regular injection mode"
		MAP
		0x8005fbf0
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_tqi_n_spg_sp_amp_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_amp_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_amp_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_amp_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_amp_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_spg_sp_bas_pr
		"Basic boost air pressure setpoint for regeneration mode"
		MAP
		0x8005f1f0
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_tqi_n_spg_sp_bas_pr 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_bas_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_bas_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_spg_sp_bas_rij
		"Basic boost air pressure setpoint in regular injection mode"
		MAP
		0x8005f9f0
		RSA_RecordLayout_MAP_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Cmp_tqi_n_spg_sp_bas_rij 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_bas_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_bas_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsprxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_spg_sp_tia_cor_pr
		"Air temperature correction of boost air pressure setpoint in regeneration mode"
		MAP
		0x8005f0b0
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_tqi_n_spg_sp_tia_cor_pr 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_tia_cor_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_tia_cor_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_tia_cor_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_tia_cor_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpsrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_spg_sp_tia_cor_rij
		"Basic atmospheric pressure correction of m.a.p setpoint in regular injection mode"
		MAP
		0x8005f8b0
		RSA_RecordLayout_MAP_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		-10000.
		10000.
    DISPLAY_IDENTIFIER Cmp_tqi_n_spg_sp_tia_cor_rij 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_spg_sp_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_spg_sp_tia_cor_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_spg_sp_tia_cor_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_spg_sp_tia_cor_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_spg_sp_tia_cor_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_amp_pr
		"Atmospheric pressure correction for vnt control value  for regeneration"
		MAP
		0x8005dce0
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_amp_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_amp_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_amp_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_amp_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_amp_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_amp_rij
		"Atmospheric pressure correction for vnt control value in case of regular injection mode"
		MAP
		0x8005e686
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_amp_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_amp_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_amp_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_amp_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_amp_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_bas_pr
		"Basic control value for vnt in regeneration mode"
		MAP
		0x8005dae0
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_bas_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_bas_rij
		"Basic control value for vnt"
		MAP
		0x8005e486
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_bas_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			16
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_tco_rij
		"Engine coolant temperature correction for vnt control value"
		MAP
		0x8005e346
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_tco_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_tco_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_tco_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_tco_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_tco_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_tia_pr
		"Intake air temperature correction for vnt control value in regeneration mode"
		MAP
		0x8005d9a0
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_tia_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_tia_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_tia_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_tia_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_tia_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_tia_rij
		"Intake temperature correction for vnt control value in regular injection mode"
		MAP
		0x8005e206
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_tia_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_tia_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_tia_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_tia_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_tia_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_tkof_pr
		"Take off assistance basic correction for vnt control value in case of pr comb. mode"
		MAP
		0x8005d958
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_tkof_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_tkof_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_tkof_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_tkof_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_tkof_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			6
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_tkof_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_n_vnt_ctl_tkof_rij
		"Take off assistance basic correction for vnt control value in case of regular injection mode"
		MAP
		0x8005e1be
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_tqi_n_vnt_ctl_tkof_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_bas_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_bas_tkof_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_bas_tkof_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_bas_tkof_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			6
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_bas_tkof_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_post_efy_phi_cor_pr
		"Post efficiency correction map f(difference between current and basic post timing) in pr mode"
		MAP
		0x8005cb6e
		RSA_RecordLayout_MAP_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_tqi_post_efy_phi_cor_pr 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_post_efy_phi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_post_efy_phi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_post_efy_phi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_post_efy_phi_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_post_efy_phi_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_post_efy_phi_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_post_efy_phi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_post_efy_phi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_post_efy_phi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_post_efy_phi_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_post_efy_phi_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_post_efy_phi_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tqi_post_efy_ti_dif_cor_pr
		"Post efficiency correction map f(diff between post and last injection timing) in pr mode"
		MAP
		0x8005cb2e
		RSA_RecordLayout_MAP_UBYTE
		2
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		0.
		2.
    DISPLAY_IDENTIFIER Cmp_tqi_post_efy_ti_dif_cor_pr 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_post_efy_ti_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_post_efy_ti_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_post_efy_ti_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_post_efy_ti_cor_n_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_post_efy_ti_cor_n_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			8
			0.
			16383.75
        AXIS_PTS_REF Ctb_tqi_post_efy_ti_cor_n_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_post_efy_ti_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_post_efy_ti_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_post_efy_ti_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_post_efy_ti_cor_tqi_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_post_efy_ti_cor_tqi_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_sp
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			8
			0.
			2047.96875
        AXIS_PTS_REF Ctb_tqi_post_efy_ti_cor_tqi_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_rubtqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Cmp_tql_eng_frn
		"Engine rubbing torque losses map dependent on engine speed and temperature"
		MAP
		0x8004160a
		RSA_RecordLayout_MAP_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Cmp_tql_eng_frn 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			20
			0.
			16383.75
        AXIS_PTS_REF Ctb_n 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tsp_tp1_amp_cor_sta
		"Table for separation of pre-injection 1 during Starting Combustion Mode"
		MAP
		0x8006aed0
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_tsp_tp1_amp_cor_sta 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tsp_tp1_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tsp_tp1_amp_cor_sta 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_tsp_tp1_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_tsp_tp1_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_tsp_tp1_amp_cor_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tsp_tp2_amp_cor_sta
		"Table for separation of pre-injection 2 during Starting Combustion Mode"
		MAP
		0x8006afb2
		RSA_RecordLayout_MAP_UWORD
		65535
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		-32768.
		32767.
    DISPLAY_IDENTIFIER Cmp_tsp_tp2_amp_cor_sta 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n_tsp_tp2_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			6
			0.
			16383.75
        AXIS_PTS_REF Ctb_n_tsp_tp2_amp_cor_sta 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_tsp_tp2_amp_cor_sta */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_tsp_tp2_amp_cor_sta */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_tsp_tp2_amp_cor_sta 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tt_egaf_fms_efi_max_pr
		"Interpolation table of maximum exhaust injection mass flow depending on turbine temperature and exhaust gas flow"
		MAP
		0x80043dd0
		RSA_RecordLayout_MAP_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		0.
		100.
    DISPLAY_IDENTIFIER Cmp_tt_egaf_fms_efi_max_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tt_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tt_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tt_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tt_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tt_fms_efi_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tt
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			1200.
        AXIS_PTS_REF Ctb_tt_fms_efi_max_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_egaf_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_egaf_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_egaf_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_egaf_fms_efi_max_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_egaf_fms_efi_max_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_egaf
			movAqed_DtteCgd_cloonha_Bh__10a
			8
			0.
			2000.
        AXIS_PTS_REF Ctb_egaf_fms_efi_max_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_tt_tco_fwe_fac
		"Interpolation map of ponderation factor for fuel wear estimation"
		MAP
		0x80058f4e
		RSA_RecordLayout_MAP_UWORD
		6.5535
		minmsna_wwxggtb_BagawBb_s__100a
		0.
		6.5535
    DISPLAY_IDENTIFIER Cmp_tt_tco_fwe_fac 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fwe_tt */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fwe_tt */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fwe_tt */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fwe_tt */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fwe_tt */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tt_clc
			vwfEuxd_nycakvb_dhzaarc_qC_00oa
			8
			0.
			1200.
        AXIS_PTS_REF Ctb_fwe_tt 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fwe_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fwe_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fwe_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fwe_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fwe_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco_clc
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_fwe_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcpr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_vnt_ctl_ex_df_pr
		"Specific control value correction in case of exhaust pressure sensor limphome in pr mode."
		MAP
		0x8005d818
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_vnt_ctl_ex_df_pr 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_ex_df_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_ex_df_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_ex_df_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_ex_df_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_ex_df_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_vnt_ctl_ex_df_rij
		"Specific control value correction in case of exhaust pressure sensor limphome in rij mode."
		MAP
		0x8005e07e
		RSA_RecordLayout_MAP_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Cmp_vnt_ctl_ex_df_rij 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_ctl_ex_df_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_ctl_ex_df_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_ctl_ex_df_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_ctl_ex_df_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_ctl_ex_df_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_vnt_pwm_i_rst
		"Maximum specific vnt final pwm to reset the I term of governor"
		MAP
		0x8005edd8
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_vnt_pwm_i_rst 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_pwm_i_rst */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n_mv
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			10
			0.
			16383.75
        AXIS_PTS_REF Ctb_x_vnt_pwm_i_rst 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_pwm_i_rst */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_pwm_i_rst */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_raw
			zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
			10
			0.
			2047.96875
        AXIS_PTS_REF Ctb_y_vnt_pwm_i_rst 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpprx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_vnt_tran_pwm_pr
		"Saturation rco signal value for transient strategy in regeneration mode"
		MAP
		0x8005d2d0
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_vnt_tran_pwm_pr 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_tran_pwm_pr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_tran_pwm_pr 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_tran_pwm_pr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_tran_pwm_pr */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			10
			0.
			100.
        AXIS_PTS_REF Ctb_y_vnt_tran_pwm_pr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcprij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Cmp_vnt_tran_pwm_rij
		"Saturation rco signal value for transient strategy in regular injection mode"
		MAP
		0x8005d58e
		RSA_RecordLayout_MAP_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Cmp_vnt_tran_pwm_rij 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_tran_pwm_rij */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_csm
			uztFExb_owBhqra_ykamwda_l__000a
			10
			0.
			100.
        AXIS_PTS_REF Ctb_x_vnt_tran_pwm_rij 
	/end AXIS_DESCR
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_y_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_y_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_y_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_y_vnt_tran_pwm_rij */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_y_vnt_tran_pwm_rij */
	/begin AXIS_DESCR
			COM_AXIS
			InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
			xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
			10
			0.
			100.
        AXIS_PTS_REF Ctb_y_vnt_tran_pwm_rij 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_comb_mod_dft_tr
		"Default transition on transition of combustion mode"
		VALUE
		0x8004ea71
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Csx_comb_mod_dft_tr 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_comb_mod_req_bch_val
		"Bench mode activation for combustion mode"
		VALUE
		0x8004ea70
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Csx_comb_mod_req_bch_val 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_comb_mod_spu_rich
		"Value of combustion mod during pft regeneration"
		VALUE
		0x80067f7f
		RSA_RecordLayout_VALUE_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		15.
    DISPLAY_IDENTIFIER Csx_comb_mod_spu_rich 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_dlin_conf
		"Calibration which specifies the type of the transmission (transmission configuration)"
		VALUE
		0x8005883c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_dlin_conf 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_egt_comb_mod_mnl
		"Manuel active combustion mode"
		VALUE
		0x80047123
		RSA_RecordLayout_VALUE_UBYTE
		14
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		15.
    DISPLAY_IDENTIFIER Csx_egt_comb_mod_mnl 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_schxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_it_cfm
		"Calibration for inlet throttle configuration (embedded config.)"
		VALUE
		0x800400dc
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2.
    DISPLAY_IDENTIFIER Csx_it_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_it_ena_pp
		"Calibration used to choose the Thottle Saturation Mode if EGR control is shut-off in rgn_prmt mod"
		VALUE
		0x800618c7
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Csx_it_ena_pp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_it_ena_pr
		"Calibration used to choose the Thottle Saturation Mode if EGR control is shut-off in rgn mode"
		VALUE
		0x80061bb7
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Csx_it_ena_pr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_it_ena_rij
		"Calibration used to choose the Thottle Saturation Mode if EGR control is shut-off in rij mode"
		VALUE
		0x80061ea7
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Csx_it_ena_rij 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_it_sat_pp
		"Calibration for choosing the value of Vsx_thr_sat in case of Vbx_clos_thr_ena = true"
		VALUE
		0x800618c6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Csx_it_sat_pp 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_it_sat_pr
		"Calibration for choosing the value of Vsx_thr_sat in combustion mode = 3"
		VALUE
		0x80061bb6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Csx_it_sat_pr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_it_sat_rij
		"Calibration for choosing the value of Vsx_thr_sat in combustion mode = 1"
		VALUE
		0x80061ea6
		RSA_RecordLayout_VALUE_UBYTE
		1
		utCpcna_olpdfvb_iFvAkza_nC___01
		0.
		1.
    DISPLAY_IDENTIFIER Csx_it_sat_rij 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_lih_egb_gear
		"Calibration value for the gear engaged when egb is in safety mode"
		VALUE
		0x80058854
		RSA_RecordLayout_VALUE_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		-1.
		6.
    DISPLAY_IDENTIFIER Csx_lih_egb_gear 
    FORMAT "%2.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_cat_heat_ini_swi
		"Calibration to initialize combustion model in catalyst heating state"
		VALUE
		0x80046b63
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_cat_heat_ini_swi 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_egaf_clc_cfm
		"Tunable state to choose the upstream temperature used to calculate the exhaust gas flow, 1 for Particle filter upstream temperatue, 2 for Doc1 upstream temperature, 3 for Doc2 upstream temperature"
		VALUE
		0x80057dd8
		RSA_RecordLayout_VALUE_UBYTE
		2
		FgevDdd_qBlgAwd_zDfgqra_n_R0aoa
		1.
		3.
    DISPLAY_IDENTIFIER Csx_pft_egaf_clc_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_eng_sp_max
		"Maximum engine operating point to activate the automatic gearbox request for regeneration help"
		VALUE
		0x80047122
		RSA_RecordLayout_VALUE_UBYTE
		4
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		4.
    DISPLAY_IDENTIFIER Csx_pft_eng_sp_max 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_oil_dil_nt
		"Calibration to activate oil dilution computation during nt combustion mode"
		VALUE
		0x80055272
		RSA_RecordLayout_VALUE_UBYTE
		14
		RB_CONV_OneToOne
		1
		15
    DISPLAY_IDENTIFIER Csx_pft_oil_dil_nt 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_oil_dil_pft_cat_heat
		"Combustion mode value to compute dilution during particle filter heating"
		VALUE
		0x80055271
		RSA_RecordLayout_VALUE_UBYTE
		14
		RB_CONV_OneToOne
		1
		15
    DISPLAY_IDENTIFIER Csx_pft_oil_dil_pft_cat_heat 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_oil_dil_pft_rgn
		"Combustion mode value to compute dilution during particle filter regeneration"
		VALUE
		0x80055270
		RSA_RecordLayout_VALUE_UBYTE
		14
		RB_CONV_OneToOne
		1
		15
    DISPLAY_IDENTIFIER Csx_pft_oil_dil_pft_rgn 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_rgn_err_t_ctr_mask
		"State mask for time since last regeneration failure counter initalization."
		VALUE
		0x80068044
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Csx_pft_rgn_err_t_ctr_mask 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_rgn_err_t_ctr_mask_2
		"Second state mask for time since last regeneration failure counter initalization."
		VALUE
		0x80068042
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Csx_pft_rgn_err_t_ctr_mask_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_rgn_err_vh_dist_mask
		"State mask for distance since last regeneration failure counter initalization."
		VALUE
		0x80068040
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Csx_pft_rgn_err_vh_dist_mask 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_rgn_err_vh_dist_mask_2
		"Second state mask for distance since last regeneration failure counter initalization."
		VALUE
		0x8006803e
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Csx_pft_rgn_err_vh_dist_mask_2 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_rgn_req_ini_swi
		"Calibration to initialize combustion model in regeneration request state"
		VALUE
		0x80046b62
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_rgn_req_ini_swi 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_stt_agb_msk
		"Mask for regeneration start detection to activate the automatic gearbox request"
		VALUE
		0x80047120
		RSA_RecordLayout_VALUE_UWORD
		65535
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		65535.
    DISPLAY_IDENTIFIER Csx_pft_stt_agb_msk 
    FORMAT "%5.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_stt_mask_0
		"Mask to allow combustion request when charging state is set."
		VALUE
		0x8004711e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_stt_mask_0 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_stt_mask_16
		"Mask to allow combustion request when check temperature state is set."
		VALUE
		0x8004711d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_stt_mask_16 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_stt_mask_24
		"Mask to allow combustion request when csf heating state is set."
		VALUE
		0x8004711c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_stt_mask_24 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_stt_mask_32
		"Mask to allow combustion request when regeneration request state is set."
		VALUE
		0x8004711b
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_stt_mask_32 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_stt_mask_8
		"Mask to allow combustion request when speed request state is set."
		VALUE
		0x8004711a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_stt_mask_8 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Csx_pft_stt_rgn_mnl
		"Manual CSF statemachine state selector and manual value [=255:state machine / !=255:manual]"
		VALUE
		0x80067f7e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_pft_stt_rgn_mnl 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_spv_tq_rat_drv_cfm
		"Boolean calibration to choose the driver torque factor calculation"
		VALUE
		0x8005a71a
		RSA_RecordLayout_VALUE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		2.
    DISPLAY_IDENTIFIER Csx_spv_tq_rat_drv_cfm 
    FORMAT "%1.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_03
		"Allowed tests for FAN1 and its relay"
		VALUE
		0x80056f52
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_03 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_04
		"Allowed tests for FAN2 and its relay"
		VALUE
		0x80056f3a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_04 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_05
		"Allowed tests for electronic water pump for turbocharger cooling"
		VALUE
		0x80056f22
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_05 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_11
		"Allowed tests for glow plug and its relay"
		VALUE
		0x80056f0a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_11 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_12
		"Allowed tests for EGR flap"
		VALUE
		0x80056ef2
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_12 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_13
		"Allowed tests for diesel intake air throttle"
		VALUE
		0x80056eda
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_13 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_14
		"Allowed tests for EGR bypass cooling solenoid"
		VALUE
		0x80056ec2
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_14 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_17
		"Allowed tests for 5th injector dosing valve and its gavage pump"
		VALUE
		0x80056eaa
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_17 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_18
		"Allowed tests for 5th injector"
		VALUE
		0x80056e92
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_18 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_22
		"Allowed test for flow actuator"
		VALUE
		0x80056e2f
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_22 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_23
		"Allowed test for rail pressure regulator"
		VALUE
		0x80056e2e
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_23 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_24
		"Allowed test for O2 upper sensor heater"
		VALUE
		0x80056e2d
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_24 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_25
		"Allowed test for O2 lower sensor heater"
		VALUE
		0x80056e2c
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_25 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_26
		"Allowed tests for diesel turbocharger command valve"
		VALUE
		0x80056e7a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_26 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_29
		"Allowed test for spark plug 1"
		VALUE
		0x80056e2b
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_29 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_30
		"Allowed test for spark plug 2"
		VALUE
		0x80056e2a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_30 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_31
		"Allowed test for spark plug 3"
		VALUE
		0x80056e29
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_31 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_32
		"Allowed test for spark plug 4"
		VALUE
		0x80056e28
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_32 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_35
		"Allowed test for fuel injector 1"
		VALUE
		0x80056e27
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_35 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_36
		"Allowed test for fuel injector 2"
		VALUE
		0x80056e26
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_36 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_37
		"Allowed test for fuel injector 3"
		VALUE
		0x80056e25
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_37 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_38
		"Allowed test for fuel injector 4"
		VALUE
		0x80056e24
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_38 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_41
		"Allowed tests for thermoplunger relay 1"
		VALUE
		0x80056e62
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_41 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_42
		"Allowed tests for thermoplunger relay 2"
		VALUE
		0x80056e4a
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_42 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Csx_tac_43
		"Allowed tests for thermoplunger relay 3"
		VALUE
		0x80056e32
		RSA_RecordLayout_VALUE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Csx_tac_43 
    FORMAT "%3.0" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_coup_grip_rat
		"Cartography that converts transmission coupler state into coupler torque grip ratio"
		CURVE
		0x8005b02c
		RSA_RecordLayout_CURVE_UBYTE
		1
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		1.
    DISPLAY_IDENTIFIER Ctd_coup_grip_rat 
    FORMAT "%4.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_coup */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ant_coup
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			3
			0.
			255.
        AXIS_PTS_REF Ctb_coup 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_dri_vnt_reg_i_fac_neg
		"Curve of factor of I part in the negative window"
		CURVE
		0x8005d0fc
		RSA_RecordLayout_CURVE_UWORD
		1.25
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		0.
		1.25
    DISPLAY_IDENTIFIER Ctd_dri_vnt_reg_i_fac_neg 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_i_fac_neg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_i_fac_neg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_i_fac_neg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_i_fac_neg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_i_fac_neg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_vnt_reg_i_fac_neg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_dri_vnt_reg_i_fac_pos
		"Curve of factor of I part in the positive window"
		CURVE
		0x8005d0ee
		RSA_RecordLayout_CURVE_UWORD
		1.25
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		0.
		1.25
    DISPLAY_IDENTIFIER Ctd_dri_vnt_reg_i_fac_pos 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_i_fac_pos */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_i_fac_pos */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_i_fac_pos */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_i_fac_pos */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_i_fac_pos */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_vnt_reg_i_fac_pos 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_dri_vnt_reg_i_fac_sig
		"Curve of factor of I part in the window"
		CURVE
		0x8005d0e0
		RSA_RecordLayout_CURVE_UWORD
		1.25
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		0.
		1.25
    DISPLAY_IDENTIFIER Ctd_dri_vnt_reg_i_fac_sig 
    FORMAT "%6.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_i_fac_sig */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_i_fac_sig */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_i_fac_sig */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_i_fac_sig */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_i_fac_sig */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_vnt_reg_i_fac_sig 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_dri_vnt_reg_i_win_neg
		"Curve of negative window values for i part"
		CURVE
		0x8005d0d2
		RSA_RecordLayout_CURVE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Ctd_dri_vnt_reg_i_win_neg 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_i_win_neg */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_i_win_neg */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_i_win_neg */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_i_win_neg */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_i_win_neg */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_vnt_reg_i_win_neg 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_dri_vnt_reg_i_win_pos
		"Curve of positive window values for i part"
		CURVE
		0x8005d0c4
		RSA_RecordLayout_CURVE_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		0.
		20000.
    DISPLAY_IDENTIFIER Ctd_dri_vnt_reg_i_win_pos 
    FORMAT "%5.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_reg_i_win_pos */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_reg_i_win_pos */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_reg_i_win_pos */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_reg_i_win_pos */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_reg_i_win_pos */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			7
			-1.
			6.
        AXIS_PTS_REF Ctb_x_vnt_reg_i_win_pos 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_ex_prs_sp_tkof_gear
		"Table of boolean which enable specific exhaust pressure setpoint for each gearbox ratio"
		CURVE
		0x80060c1c
		RSA_RecordLayout_CURVE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    DISPLAY_IDENTIFIER Ctd_ex_prs_sp_tkof_gear 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ex_prs_sp_tkof_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ex_prs_sp_tkof_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ex_prs_sp_tkof_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ex_prs_sp_tkof_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ex_prs_sp_tkof_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_ex_prs_sp_tkof_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_fzy_gear_typ
		"Breakpoints of gear type definition for fuzzification rules"
		CURVE
		0x8005edd0
		RSA_RecordLayout_CURVE_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		3.
    DISPLAY_IDENTIFIER Ctd_fzy_gear_typ 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_fzy_gear_typ */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_fzy_gear_typ */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_fzy_gear_typ */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_fzy_gear_typ */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_fzy_gear_typ */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear_fzy
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_fzy_gear_typ 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_gear_cge_max_n_ofs
		"Offset on nominal engine speed limitation (for gear change indicator light)"
		CURVE
		0x8005afb6
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctd_gear_cge_max_n_ofs 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_gear_min_driv_tqe_ftc
		"Filtering time constant for minimum driver engine torque"
		CURVE
		0x8005b024
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Ctd_gear_min_driv_tqe_ftc 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_gear_run_vh_min_is_n
		"Running vehicule index table based on the gear engaged"
		CURVE
		0x8004142e
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctd_gear_run_vh_min_is_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_gear_smk
		"Gearbox ratio breakpoint for table selection"
		CURVE
		0x80042322
		RSA_RecordLayout_CURVE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Ctd_gear_smk 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_gear_tq_rat
		"Cartography that converts vehicle_speed / rotary_engine_speed ratio into driveline torque ratio"
		CURVE
		0x8005b014
		RSA_RecordLayout_CURVE_UWORD
		210
		vtyvFka_akFtnud_rnCproc_n__1a0a
		-10.
		200.
    DISPLAY_IDENTIFIER Ctd_gear_tq_rat 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_is_in_ofs_drv
		"Breakpoint calibration of thresholds of entry to ISR"
		CURVE
		0x8005aae6
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctd_is_in_ofs_drv 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_is_in_ofs_drv */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_is_in_ofs_drv */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_is_in_ofs_drv */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_is_in_ofs_drv */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_is_in_ofs_drv */
	/begin AXIS_DESCR
			COM_AXIS
			NO_INPUT_QUANTITY
			ErwgDnb_wudaCDa_gAzibEd_rsA_o90
			6
			-8192.
			8191.
        AXIS_PTS_REF Ctb_is_in_ofs_drv 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafspt_mafsrix_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_maf_sp_gear
		"as_maf_spt_mafsri/ Adaptative curve for the current gear value"
		CURVE
		0x80066714
		RSA_RecordLayout_CURVE_UBYTE
		5
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		5.
    DISPLAY_IDENTIFIER Ctd_maf_sp_gear 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_maf_sp_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_maf_sp_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_maf_sp_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_maf_sp_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_maf_sp_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ctb_x_maf_sp_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_mon_efy_agb_req
		"Minimum regeneration efficiency to activate the automatic gearbox request"
		CURVE
		0x80047142
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctd_mon_efy_agb_req 
    FORMAT "%2.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_eng_sp_agb_req */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_pft_eng_sp
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			4
			0.
			3.
        AXIS_PTS_REF Ctb_pft_eng_sp_agb_req 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_mon_t_agb_req
		"Maximum time to compare the regeneration efficiency to activate the automatic gearbox request"
		CURVE
		0x8004713a
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctd_mon_t_agb_req 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_eng_sp_agb_req */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_pft_eng_sp
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			4
			0.
			3.
        AXIS_PTS_REF Ctb_pft_eng_sp_agb_req 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_ms_lft_agb_min
		"Minimum regeneration efficiency to reset the automatic gearbox request"
		CURVE
		0x80047132
		RSA_RecordLayout_CURVE_UWORD
		2
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		0.
		2.
    DISPLAY_IDENTIFIER Ctd_ms_lft_agb_min 
    FORMAT "%2.4" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_eng_sp_agb_req */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_eng_sp_agb_req */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_pft_eng_sp
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			4
			0.
			3.
        AXIS_PTS_REF Ctb_pft_eng_sp_agb_req 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_n_prop_thd
		"offset of proportional activation"
		CURVE
		0x8005af1c
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctd_n_prop_thd 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_ovn_tq_int_k
		"Gain for the Integrator"
		CURVE
		0x8005af0c
		RSA_RecordLayout_CURVE_UWORD
		255
		EezxAwa_ABizfEa_ybCxwud_Nrj_0o0
		0.
		255.
    DISPLAY_IDENTIFIER Ctd_ovn_tq_int_k 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntqcxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_ovn_tq_prop_k
		"Gain for proportional"
		CURVE
		0x8005aefc
		RSA_RecordLayout_CURVE_UWORD
		255
		EezxAwa_ABizfEa_ybCxwud_Nrj_0o0
		0.
		255.
    DISPLAY_IDENTIFIER Ctd_ovn_tq_prop_k 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_eng_sp_dist_fac
		"Table of correction factor on minimum distance after last regeneration"
		CURVE
		0x80046c54
		RSA_RecordLayout_CURVE_UWORD
		100
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Ctd_pft_eng_sp_dist_fac 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_eng_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_pft_eng_sp
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			4
			0.
			3.
        AXIS_PTS_REF Ctb_pft_eng_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_eng_sp_t_fac
		"Table of correction factor on minimum time after last regeneration"
		CURVE
		0x80046c4c
		RSA_RecordLayout_CURVE_UWORD
		100
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Ctd_pft_eng_sp_t_fac 
    FORMAT "%5.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_eng_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_eng_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_pft_eng_sp
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			4
			0.
			3.
        AXIS_PTS_REF Ctb_pft_eng_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_iter_step_no_rgn
		"Index map of soot mass steps iteration during the normal injection mode."
		CURVE
		0x800466a8
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Ctd_pft_iter_step_no_rgn 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_nr_driv_cdn
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			2
			0.
			1.
        AXIS_PTS_REF Ctb_pft_nr_driv_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_iter_step_rgn
		"Index map of soot mass steps iteration during regeneration injection mode"
		CURVE
		0x800466a6
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Ctd_pft_iter_step_rgn 
    FORMAT "%3.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_nr_driv_cdn
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			2
			0.
			1.
        AXIS_PTS_REF Ctb_pft_nr_driv_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_max_nr_sp_zon_no_rgn
		"Index map of maximum number of points in each zone during a no regeneration state"
		CURVE
		0x800466a4
		RSA_RecordLayout_CURVE_UBYTE
		100
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Ctd_pft_max_nr_sp_zon_no_rgn 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_nr_driv_cdn
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			2
			0.
			1.
        AXIS_PTS_REF Ctb_pft_nr_driv_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_max_nr_sp_zon_rgn
		"Index map of maximum number of points in each zone during a regeneration"
		CURVE
		0x800466a2
		RSA_RecordLayout_CURVE_UBYTE
		100
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Ctd_pft_max_nr_sp_zon_rgn 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_nr_driv_cdn
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			2
			0.
			1.
        AXIS_PTS_REF Ctb_pft_nr_driv_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_min_mv_ms_no_rgn
		"Index map of minimum number of new average zones for soot mass calculation on no regeneration"
		CURVE
		0x800466a0
		RSA_RecordLayout_CURVE_UBYTE
		100
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Ctd_pft_min_mv_ms_no_rgn 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_nr_driv_cdn
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			2
			0.
			1.
        AXIS_PTS_REF Ctb_pft_nr_driv_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_min_mv_ms_rgn
		"Index map of minimum number of new average zones for soot mass calculation on regeneration"
		CURVE
		0x8004669e
		RSA_RecordLayout_CURVE_UBYTE
		100
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		100.
    DISPLAY_IDENTIFIER Ctd_pft_min_mv_ms_rgn 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_nr_driv_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_nr_driv_cdn
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			2
			0.
			1.
        AXIS_PTS_REF Ctb_pft_nr_driv_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_msswixx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_sot_ms_cor_swi
		"Type of mass include in ms_cor ms_prs=1, ms_sim=2, mixt=3 dependant of driver type"
		CURVE
		0x80046b68
		RSA_RecordLayout_CURVE_UBYTE
		2
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1.
		3.
    DISPLAY_IDENTIFIER Ctd_pft_sot_ms_cor_swi 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_pft_sot_ms_cor */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_pft_sot_ms_cor */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_pft_sot_ms_cor */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_pft_sot_ms_cor */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_pft_sot_ms_cor */
	/begin AXIS_DESCR
			COM_AXIS
			AtPftMng_NVM.Vsx_pft_rgn_cdn_tgt_NVM
			ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf
			3
			0.
			2.
        AXIS_PTS_REF Ntb_pft_sot_ms_cor 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_tair_rgn_err_cold_cnd
		"Programmable table of maximum rgn failure to forbid regeneration mode in cold conditions."
		CURVE
		0x8004704a
		RSA_RecordLayout_CURVE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctd_pft_tair_rgn_err_cold_cnd 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_err_ctr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_pft_tair_rgn_err_wait_mod
		"Programmable table of maximum rgn failure to forbid regeneration mode for waiting mode."
		CURVE
		0x80047042
		RSA_RecordLayout_CURVE_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		255.
    DISPLAY_IDENTIFIER Ctd_pft_tair_rgn_err_wait_mod 
    FORMAT "%3.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_pft_tia_mv_err_ctr */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_pft_tia_mv_thd
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			8
			-40.
			200.
        AXIS_PTS_REF Ctb_pft_tia_mv_err_ctr 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin CHARACTERISTIC
		Ctd_rbst_el_csm_dsb_gear
		"Cartography to select gears on which electrical consumers deactivation is requested in engine robustness strategy"
		CURVE
		0x8005ce4a
		RSA_RecordLayout_CURVE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    DISPLAY_IDENTIFIER Ctd_rbst_el_csm_dsb_gear 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_stt_vnt_diag_lih_cdn
		"Condition to apply fixed pwm or pwm as a function of open loop control"
		CURVE
		0x8004340e
		RSA_RecordLayout_CURVE_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		1.
    DISPLAY_IDENTIFIER Ctd_stt_vnt_diag_lih_cdn 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_lih_cdn */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_lih_cdn */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_lih_cdn */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_lih_cdn */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_lih_cdn */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_vnt_diag_stt
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			16
			0.
			18.
        AXIS_PTS_REF Ctb_x_vnt_diag_lih_cdn 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_stt_vnt_diag_lih_fac
		"Multiplication factor for limphome pwm"
		CURVE
		0x800433ee
		RSA_RecordLayout_CURVE_UWORD
		1
		lasreaa_cardnzb_hCDtpsa_n__a00a
		0.
		1.
    DISPLAY_IDENTIFIER Ctd_stt_vnt_diag_lih_fac 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_lih_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_lih_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_lih_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_lih_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_lih_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_vnt_diag_stt
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			16
			0.
			18.
        AXIS_PTS_REF Ctb_x_vnt_diag_lih_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_stt_vnt_diag_lih_ofs
		"Offset for limphome pwm"
		CURVE
		0x800433ce
		RSA_RecordLayout_CURVE_UWORD
		400
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		-200.
		200.
    DISPLAY_IDENTIFIER Ctd_stt_vnt_diag_lih_ofs 
    FORMAT "%7.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_lih_ofs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_lih_ofs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_lih_ofs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_lih_ofs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_lih_ofs */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_vnt_diag_stt
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			16
			0.
			18.
        AXIS_PTS_REF Ctb_x_vnt_diag_lih_ofs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin CHARACTERISTIC
		Ctd_stt_vnt_diag_lih_set
		"Fixed pwm for limphome"
		CURVE
		0x800433ae
		RSA_RecordLayout_CURVE_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		0.
		200.
    DISPLAY_IDENTIFIER Ctd_stt_vnt_diag_lih_set 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_x_vnt_diag_lih_set */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_x_vnt_diag_lih_set */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_x_vnt_diag_lih_set */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_x_vnt_diag_lih_set */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_x_vnt_diag_lih_set */
	/begin AXIS_DESCR
			COM_AXIS
			Vsx_vnt_diag_stt
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			16
			0.
			18.
        AXIS_PTS_REF Ctb_x_vnt_diag_lih_set 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_tceauxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_tco_7
		"Water temperature set point indicator."
		CURVE
		0x80040136
		RSA_RecordLayout_CURVE_UBYTE
		6
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		6.
    DISPLAY_IDENTIFIER Ctd_tco_7 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco_sp
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			7
			-40.
			200.
        AXIS_PTS_REF Ctb_tco_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctd_thpl_max_nr
		"Maximum number of coolant heater elements for torque demand"
		CURVE
		0x800432ca
		RSA_RecordLayout_CURVE_UBYTE
		7
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		0.
		7.
    DISPLAY_IDENTIFIER Ctd_thpl_max_nr 
    FORMAT "%1.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tqi_thpl_err */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tqi_thpl_err */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tqi_thpl_err */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tqi_thpl_err */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tqi_thpl_err */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tqi_thpl_gov
			lasreaa_cardnzb_hCDtpsa_n__a00a
			8
			0.
			7.
        AXIS_PTS_REF Ctb_tqi_thpl_err 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ac_acel_is_swi_off
		"Breakpoint for switch off the idle speed for AC"
		CURVE
		0x800588c2
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_ac_acel_is_swi_off 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ac_acel_is */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tair_ext
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ac_acel_is 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ac_acel_is_swi_on
		"Breakpoint for switch on the idle speed for AC"
		CURVE
		0x800588b0
		RSA_RecordLayout_CURVE_UWORD
		6553.5
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		0.
		6553.5
    DISPLAY_IDENTIFIER Ctp_ac_acel_is_swi_on 
    FORMAT "%6.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ac_acel_is */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tair_ext
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ac_acel_is 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ac_acel_is_val_off
		"Breakpoint for engine idle speed off value for AC"
		CURVE
		0x8005889e
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_ac_acel_is_val_off 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ac_acel_is */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tair_ext
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ac_acel_is 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ac_acel_is_val_on
		"Breakpoint for engine idle speed on value for AC"
		CURVE
		0x8005888c
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_ac_acel_is_val_on 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ac_acel_is */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ac_acel_is */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tair_ext
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			9
			-40.
			200.
        AXIS_PTS_REF Ctb_ac_acel_is 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ac_forb_is_n
		"Idle speed table used to avoid critical engine speed requested by AC"
		CURVE
		0x8005aeb2
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_ac_forb_is_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ac_forb_is_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ac_forb_is_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ac_forb_is_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ac_forb_is_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ac_forb_is_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ac_acel_is_sp
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			16
			0.
			16383.75
        AXIS_PTS_REF Ctb_ac_forb_is_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ac_pow_dft_val
		"Cartography to compute air conditioning power default value"
		CURVE
		0x8006b25e
		RSA_RecordLayout_CURVE_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		0.
		655350.
    DISPLAY_IDENTIFIER Ctp_ac_pow_dft_val 
    FORMAT "%6.0" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_n2 */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_n2 */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_n2 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_acel_pdl_fmt_1
		"Pedal progressivity map  n°1"
		CURVE
		0x80059c50
		RSA_RecordLayout_CURVE_UWORD
		1
		mmvArna_CeqzsCd_pqnbneb_n__630a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_acel_pdl_fmt_1 
    FORMAT "%11.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_acel_pdl_fmt */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_acel_pdl_rat
			qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
			17
			0.
			1.
        AXIS_PTS_REF Ctb_acel_pdl_fmt 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_acel_pdl_fmt_2
		"Pedal progressivity map  n°2"
		CURVE
		0x80059c2e
		RSA_RecordLayout_CURVE_UWORD
		1
		mmvArna_CeqzsCd_pqnbneb_n__630a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_acel_pdl_fmt_2 
    FORMAT "%11.9" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_acel_pdl_fmt */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_acel_pdl_fmt */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_acel_pdl_rat
			qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
			17
			0.
			1.
        AXIS_PTS_REF Ctb_acel_pdl_fmt 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_acel_pdl_lih_hys_n_h
		"Pedal limp home max admissible engine speed function of gear ratio"
		CURVE
		0x80059d3a
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_acel_pdl_lih_hys_n_h 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_acel_pdl_lih_n_sp
		"Pedal limp home engine speed setpoint function of gear ratio"
		CURVE
		0x80059d2a
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_acel_pdl_lih_n_sp 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ntb_gear */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ntb_gear */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_gear
			rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
			8
			-1.
			6.
        AXIS_PTS_REF Ntb_gear 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_acel_pdl_v_max_dif
		"Interpolated calibration table to detect an inconsistency on accelerator pedal tracks"
		CURVE
		0x800587b8
		RSA_RecordLayout_CURVE_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_acel_pdl_v_max_dif 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_acel_pdl_v_max_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_acel_pdl_v_max_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_acel_pdl_v_max_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_acel_pdl_v_max_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_acel_pdl_v_max_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_acel_pdl_fil_sens_v1
			vemczAb_reFdrlb_hCftnsa_n__a30a
			9
			0.
			1.
        AXIS_PTS_REF Ctb_acel_pdl_v_max_dif 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_ac_min_is_n
		"Cartography to compute a minimum idle speed for engine needs when AC is active (EGB in drive mode)"
		CURVE
		0x8005ae92
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_agb_ac_min_is_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_drag_red_ofs
		"Torque offset to estimate the gearbox losses in the drag reduction mode"
		CURVE
		0x80058716
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_drag_red_ofs 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_dri_ofs
		"Torque offset to estimate the gearbox losses in the drive mode"
		CURVE
		0x800586f6
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_dri_ofs 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_dri_ofs_dft
		"Degraded mode of the coupler torque losses in the drive mode"
		CURVE
		0x800586d6
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_dri_ofs_dft 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_ftc_temp_fast
		"Fast filter factor to coupler torque losses in the neutral position or the drag reduction mode (depending on engine coolant temperature)"
		CURVE
		0x800586c6
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_ftc_temp_fast 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_ftc_temp_slow
		"Slow filter factor to coupler torque losses in the neutral position or the drag reduction mode (depending on engine coolant temperature)"
		CURVE
		0x800586b6
		RSA_RecordLayout_CURVE_UBYTE
		2.55
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		0.
		2.55
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_ftc_temp_slow 
    FORMAT "%4.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_is_n_sp_fac
		"Factor on torque converter losses according to the difference between the nominal engine speed setpoint and the real setpoint"
		CURVE
		0x800586b1
		RSA_RecordLayout_CURVE_UBYTE
		3.984375
		ftmodod_Ffszhha_Fbvahrc_n_R0ooa
		0.
		3.984375
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_is_n_sp_fac 
    FORMAT "%8.6" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_agb_csm_tq_is_n_sp_dif */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_agb_csm_tq_is_n_sp_dif */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_agb_csm_tq_is_n_sp_dif */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_agb_csm_tq_is_n_sp_dif */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_agb_csm_tq_is_n_sp_dif */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_is_n_sp_dif
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			5
			0.
			16383.75
        AXIS_PTS_REF Ctb_agb_csm_tq_is_n_sp_dif 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_n_fac
		"Factor to disable the coupler torque, depending of the engine speed"
		CURVE
		0x800586a8
		RSA_RecordLayout_CURVE_UBYTE
		1
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_n_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_agb_tq_dif_n_is_n_sp */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_agb_tq_dif_n_is_n_sp */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_agb_tq_dif_n_is_n_sp */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_agb_tq_dif_n_is_n_sp */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_agb_tq_dif_n_is_n_sp */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_agb_tq_dif_n_is_n_sp
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_agb_tq_dif_n_is_n_sp 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_neut_ofs
		"Torque offset to estimate the gearbox losses in the neutral position or the park position"
		CURVE
		0x80058688
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_neut_ofs 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_neut_ofs_dft
		"Degraded mode of the coupler torque losses in the neutral position"
		CURVE
		0x80058668
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_neut_ofs_dft 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_toil */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_toil */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_toil
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_toil 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_csm_tq_vs_fac
		"Factor to disable the coupler torque, depending of the vehicle speed"
		CURVE
		0x8005865e
		RSA_RecordLayout_CURVE_UBYTE
		1
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_agb_csm_tq_vs_fac 
    FORMAT "%9.7" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_agb_tq_vs */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_agb_tq_vs */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_agb_tq_vs */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_agb_tq_vs */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_agb_tq_vs */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_vs
			uEardjb_BFoibqb_vkamstb_khA_00a
			9
			0.
			655.35
        AXIS_PTS_REF Ctb_agb_tq_vs 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_agb_tco_min_is_n
		"Idle speed setpoint which depends of the coolant temperature in 'Drive' position"
		CURVE
		0x8005adc6
		RSA_RecordLayout_CURVE_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctp_agb_tco_min_is_n 
    FORMAT "%8.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			16
			-40.
			200.
        AXIS_PTS_REF Ctb_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_dz_tqe
		"AJCOR table for torque thresholds of the dead zone"
		CURVE
		0x80040a66
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_ajs_cor_dz_tqe 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_dz_tqe_spc
		"Specific AJCOR table for torque thresholds of the dead zone"
		CURVE
		0x800410ea
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctp_ajs_cor_dz_tqe_spc 
    FORMAT "%10.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_n */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_n */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_n
			tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
			9
			0.
			16383.75
        AXIS_PTS_REF Ctb_ajs_cor_n 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_fast_cor_dly_fac
		"AJCOR table for the modulation of the maximum time to delay the boosted anti-jerk correction."
		CURVE
		0x80040a56
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_ajs_cor_fast_cor_dly_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_max_cor_dyn_tqe
		"AJCOR table for the selection of the maximum dynamique torque correction"
		CURVE
		0x80040a4a
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_ajs_cor_max_cor_dyn_tqe 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_cor_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_max_dyn_tqe_spc
		"Specific AJCOR table for the selection of the maximum dynamique torque correction"
		CURVE
		0x800410de
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_ajs_cor_max_dyn_tqe_spc 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_cor_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_min_cor_dyn_tqe
		"AJCOR table for the selection of the minimum dynamique torque correction"
		CURVE
		0x80040a3e
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_ajs_cor_min_cor_dyn_tqe 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_cor_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_spcpaxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_min_dyn_tqe_spc
		"Specific AJCOR table for the selection of the minimum dynamique torque correction"
		CURVE
		0x800410d2
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		zbhcjic_qmhpFyc_chelcsd_N__338a
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Ctp_ajs_cor_min_dyn_tqe_spc 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_cor_tco */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_cor_tco */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_tco
			vbwtgvc_iBjqEia_piCzsea_qCRao0a
			6
			-40.
			200.
        AXIS_PTS_REF Ctb_ajs_cor_tco 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_t1_fast_cor_fac
		"AJCOR table for the modulation of the time constant used during the boost of the curative anti-jerk function."
		CURVE
		0x80040a2e
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_ajs_cor_t1_fast_cor_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_cor_td_fast_cor_fac
		"AJCOR table for the modulation of the gain used during the boost of the curative anti-jerk function."
		CURVE
		0x80040a1e
		RSA_RecordLayout_CURVE_UWORD
		100
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		0.
		100.
    DISPLAY_IDENTIFIER Ctp_ajs_cor_td_fast_cor_fac 
    FORMAT "%6.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_dt_tq_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_dt_tq_rat
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_dt_tq_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_coup_grip_rat
		"Cartography that converts transmission coupler state into coupler torque grip ratio"
		CURVE
		0x8005a7a8
		RSA_RecordLayout_CURVE_UBYTE
		1
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		0.
		1.
    DISPLAY_IDENTIFIER Ctp_ajs_coup_grip_rat 
    FORMAT "%3.1" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_coup */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_coup */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ant_coup
			pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
			3
			0.
			255.
        AXIS_PTS_REF Ctb_coup 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_drag_acel_tq_diff_thd
		"Torque threshold to activate the drag error correction during acceleration."
		CURVE
		0x8005a79a
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_drag_acel_tq_diff_thd 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_spv_drag_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_drag_decl_tq_diff_thd
		"Torque threshold to activate the drag error correction during deceleration."
		CURVE
		0x8005a78c
		RSA_RecordLayout_CURVE_UWORD
		2047.96875
		uyoDvwa_FycErrc_bzelawd_N__310a
		-400.
		1647.96875
    DISPLAY_IDENTIFIER Ctp_ajs_drag_decl_tq_diff_thd 
    FORMAT "%11.5" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_spv_drag_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_spv_drag_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_drag_t1_dly
		"Drag error correction delay for time constant modulation."
		CURVE
		0x80059dbe
		RSA_RecordLayout_CURVE_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		0.
		65.535
    DISPLAY_IDENTIFIER Ctp_ajs_drag_t1_dly 
    FORMAT "%5.3" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_drag_tq_fac */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_drag_tq_fac */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_spv_driv_tq_fac
			yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
			7
			0.
			1.
        AXIS_PTS_REF Ctb_ajs_drag_tq_fac 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_dt_gear_tq_rat
		"Cartography that converts vehicle_speed / rotary_engine_speed ratio into driveline torque ratio"
		CURVE
		0x8005a77c
		RSA_RecordLayout_CURVE_UWORD
		210
		vtyvFka_akFtnud_rnCproc_n__1a0a
		-10.
		200.
    DISPLAY_IDENTIFIER Ctp_ajs_dt_gear_tq_rat 
    FORMAT "%6.2" 
	/* ASAP2::Database : Set the parameter 'InputQuantity' from the referenced item Ctb_ajs_gear_rat */
	/* ASAP2::Database : Set the parameter 'Conversion' from the referenced item Ctb_ajs_gear_rat */
	/* ASAP2::Database : Set the parameter 'MaxAxisPoints' from the referenced item Ctb_ajs_gear_rat */
	/* ASAP2::Database : Set the parameter 'LowerLimit' from the referenced item Ctb_ajs_gear_rat */
	/* ASAP2::Database : Set the parameter 'UpperLimit' from the referenced item Ctb_ajs_gear_rat */
	/begin AXIS_DESCR
			COM_AXIS
			Vxx_ajs_gear_rat_n
			vtyvFka_akFtnud_rnCproc_n__1a0a
			8
			-10.
			200.
        AXIS_PTS_REF Ctb_ajs_gear_rat 
	/end AXIS_DESCR
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		Ctp_ajs_gear_rat
		"Cartography that converts gear into vehicle_speed/rotary_engine_speed ratio for manual transmissions"
		CURVE
		0x8005a76c
		RSA_RecordLayout_CURVE_UWORD
		210
		vtyvFka_akFtnud_rnCproc_n__1a0a
		-10.
		200.
    DISPLAY_IDENTIFIER Ctp_ajs_gear_rat 
    FORMAT "%6.2" 
