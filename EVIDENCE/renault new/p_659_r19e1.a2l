		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_heat_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055cb2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_heat_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055cb6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_heat_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055cb4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_heat_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055cb4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_heat_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_heat_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055cb4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_heat_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_lamb_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ce5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_lamb_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_lamb_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055ce2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_lamb_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_lamb_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ce6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_lamb_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_lamb_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ce4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_lamb_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_lamb_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ce4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_lamb_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_lamb_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ce4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_lamb_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_pump_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055cf1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_pump_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_pump_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055cee
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_pump_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_pump_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055cf2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_pump_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_pump_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055cf0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_pump_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_pump_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055cf0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_pump_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_pump_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055cf0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_pump_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_virt_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055cfd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_virt_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_virt_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055cfa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_virt_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_virt_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055cfe
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_virt_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_virt_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055cfc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_virt_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_virt_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055cfc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_virt_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_virt_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055cfc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_virt_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ca9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_wire_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055ca6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_wire_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055caa
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_wire_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ca8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_wire_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ca8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_wire_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ca8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_wire_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d09
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_ups_wire_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d06
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_ups_wire_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d0a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_ups_wire_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d08
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_ups_wire_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d08
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_ups_wire_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_ups_wire_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d08
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_ups_wire_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_wfl_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560a5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sens_wfl_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_wfl_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800560a2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sens_wfl_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_wfl_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800560a6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sens_wfl_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_wfl_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800560a4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sens_wfl_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_wfl_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800560a4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sens_wfl_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sens_wfl_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560a4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sens_wfl_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056039
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sfty_tq_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056036
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sfty_tq_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005603a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sfty_tq_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056038
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sfty_tq_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056038
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sfty_tq_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056038
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sfty_tq_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_clc_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005602d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sfty_tq_clc_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_clc_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005602a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sfty_tq_clc_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_clc_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005602e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sfty_tq_clc_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_clc_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005602c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sfty_tq_clc_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_clc_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005602c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sfty_tq_clc_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_clc_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005602c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sfty_tq_clc_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_fail.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c85
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sfty_tq_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_fail.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c84
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sfty_tq_fail 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_supl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d45
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_sfty_tq_supl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_supl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d42
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_sfty_tq_supl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_supl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d46
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_sfty_tq_supl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_supl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d44
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_sfty_tq_supl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_supl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d44
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_sfty_tq_supl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_sfty_tq_supl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d44
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_sfty_tq_supl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_cmd_blk_clos.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c79
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_spg_cmd_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_cmd_blk_clos.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055c76
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_spg_cmd_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_cmd_blk_clos.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055c7a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_spg_cmd_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_cmd_blk_clos.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055c78
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_spg_cmd_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_cmd_blk_clos.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055c78
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_spg_cmd_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_cmd_blk_clos.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c78
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_spg_cmd_blk_clos 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_down.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056429
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_spg_reg_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_down.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056426
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_spg_reg_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_down.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005642a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_spg_reg_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_down.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056428
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_spg_reg_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_down.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056428
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_spg_reg_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056428
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_spg_reg_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_up.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005641d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_spg_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_up.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005641a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_spg_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_up.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005641e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_spg_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005641c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_spg_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_up.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005641c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_spg_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_spg_reg_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005641c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_spg_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbf_fct_apl_down.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e95
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tbf_fct_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbf_fct_apl_down.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e94
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tbf_fct_apl_down 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbf_fct_apl_up.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e89
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tbf_fct_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbf_fct_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e88
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tbf_fct_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056411
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tbt_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005640e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_tbt_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056412
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_tbt_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056410
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_tbt_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056410
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_tbt_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056410
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tbt_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056405
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tbt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056402
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_tbt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056406
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_tbt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056404
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_tbt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056404
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_tbt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056404
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tbt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563f9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tbt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563f6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_tbt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563fa
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_tbt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563f8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_tbt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563f8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_tbt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563f8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tbt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_apl_up.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055ffd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tbt_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_apl_up.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055ffa
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_tbt_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_apl_up.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055ffe
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_tbt_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_apl_up.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055ffc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_tbt_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_apl_up.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055ffc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_tbt_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_apl_up.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055ffc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tbt_reg_apl_up 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_neg_err.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563ed
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tbt_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_neg_err.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563ea
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_tbt_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_neg_err.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563ee
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_tbt_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_neg_err.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563ec
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_tbt_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_neg_err.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563ec
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_tbt_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tbt_reg_neg_err.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563ec
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tbt_reg_neg_err 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563e1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563de
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563e2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563e0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563e0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563e0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd1_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563d5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd1_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563d2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd1_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563d6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd1_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563d4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd1_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563d4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd1_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563d4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd1_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563c9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd1_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563c6
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd1_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563ca
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd1_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563c8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd1_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563c8
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd1_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd1_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563c8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd1_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563bd
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563ba
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563be
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563bc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563bc
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563bc
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd2_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563b1
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd2_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563ae
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd2_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563b2
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd2_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563b0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd2_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563b0
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd2_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563b0
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd2_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800563a5
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd2_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x800563a2
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd2_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x800563a6
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd2_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x800563a4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd2_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x800563a4
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd2_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd2_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800563a4
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd2_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056399
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_oc.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056396
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_oc.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005639a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_oc.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056398
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_oc.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056398
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056398
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd3_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005638d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd3_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005638a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd3_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005638e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd3_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005638c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd3_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005638c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd3_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005638c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd3_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056381
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_thpl_cmd3_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005637e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_thpl_cmd3_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056382
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_thpl_cmd3_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056380
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_thpl_cmd3_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056380
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_thpl_cmd3_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_thpl_cmd3_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056380
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_thpl_cmd3_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tqi_cor_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055e05
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_tqi_cor_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tqi_cor_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055e02
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_tqi_cor_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tqi_cor_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055e06
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_tqi_cor_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tqi_cor_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055e04
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_tqi_cor_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tqi_cor_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055e04
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_tqi_cor_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_tqi_cor_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055e04
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_tqi_cor_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl1_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056135
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_unk_thpl1_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl1_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056132
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_unk_thpl1_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl1_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056136
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_unk_thpl1_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl1_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056134
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_unk_thpl1_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl1_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056134
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_unk_thpl1_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl1_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056134
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_unk_thpl1_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl2_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056129
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_unk_thpl2_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl2_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056126
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_unk_thpl2_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl2_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005612a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_unk_thpl2_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl2_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056128
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_unk_thpl2_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl2_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056128
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_unk_thpl2_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl2_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056128
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_unk_thpl2_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl3_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005611d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_unk_thpl3_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl3_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005611a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_unk_thpl3_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl3_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005611e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_unk_thpl3_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl3_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005611c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_unk_thpl3_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl3_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005611c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_unk_thpl3_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl3_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005611c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_unk_thpl3_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl4_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056111
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_unk_thpl4_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl4_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005610e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_unk_thpl4_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl4_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056112
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_unk_thpl4_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl4_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056110
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_unk_thpl4_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl4_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056110
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_unk_thpl4_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl4_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056110
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_unk_thpl4_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056141
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_unk_thpl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005613e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_unk_thpl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056142
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_unk_thpl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056140
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_unk_thpl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056140
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_unk_thpl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_unk_thpl_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056140
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_unk_thpl_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_chr.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d15
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ups_ecu_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_chr.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d12
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ups_ecu_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_chr.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d16
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ups_ecu_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_chr.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d14
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ups_ecu_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_chr.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d14
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ups_ecu_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_chr.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d14
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ups_ecu_chr 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_itl.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d21
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ups_ecu_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_itl.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d1e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ups_ecu_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_itl.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d22
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ups_ecu_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_itl.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d20
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ups_ecu_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_itl.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d20
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ups_ecu_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_itl.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d20
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ups_ecu_itl 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_oor.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d2d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ups_ecu_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_oor.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d2a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ups_ecu_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_oor.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d2e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ups_ecu_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_oor.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d2c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ups_ecu_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_oor.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d2c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ups_ecu_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ecu_oor.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d2c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ups_ecu_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_oor.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d99
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ups_ro2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_oor.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d96
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ups_ro2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_oor.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d9a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ups_ro2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_oor.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d98
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ups_ro2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_oor.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d98
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ups_ro2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_oor.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d98
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ups_ro2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_slow_trs.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d8d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ups_ro2_slow_trs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_slow_trs.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d8a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ups_ro2_slow_trs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_slow_trs.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d8e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ups_ro2_slow_trs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_slow_trs.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d8c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ups_ro2_slow_trs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_slow_trs.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d8c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ups_ro2_slow_trs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_ro2_slow_trs.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d8c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ups_ro2_slow_trs 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_tip_oor.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d81
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ups_tip_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_tip_oor.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d7e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ups_tip_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_tip_oor.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d82
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ups_tip_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_tip_oor.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d80
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ups_tip_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_tip_oor.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d80
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ups_tip_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_tip_oor.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d80
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ups_tip_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_uo2_oor.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055d39
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_ups_uo2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_uo2_oor.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80055d36
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_ups_uo2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_uo2_oor.Cxx_obd_dc_xxx
		""
		VALUE
		0x80055d3a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_ups_uo2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_uo2_oor.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80055d38
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_ups_uo2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_uo2_oor.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80055d38
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_ups_uo2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_ups_uo2_oor.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055d38
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_ups_uo2_oor 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056375
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_vb_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056372
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_vb_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056376
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_vb_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056374
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_vb_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056374
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_vb_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056374
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_vb_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056369
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_vb_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056366
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_vb_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005636a
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_vb_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056368
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_vb_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056368
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_vb_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056368
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_vb_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_oc_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x8005635d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_vb_rly_oc_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_oc_scg.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005635a
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_vb_rly_oc_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_oc_scg.Cxx_obd_dc_xxx
		""
		VALUE
		0x8005635e
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_vb_rly_oc_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_oc_scg.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x8005635c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_vb_rly_oc_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_oc_scg.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x8005635c
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_vb_rly_oc_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_oc_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x8005635c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_vb_rly_oc_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056351
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_vb_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_scw.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005634e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_vb_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_scw.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056352
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_vb_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_scw.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056350
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_vb_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_scw.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056350
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_vb_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vb_rly_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056350
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_vb_rly_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_h.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056081
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_vnt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_h.Cxx_dtc_obd_xxx
		""
		VALUE
		0x8005607e
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_vnt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_h.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056082
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_vnt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_h.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056080
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_vnt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_h.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056080
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_vnt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_h.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056080
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_vnt_h 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_l.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056075
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_vnt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_l.Cxx_dtc_obd_xxx
		""
		VALUE
		0x80056072
		RSA_RecordLayout_VALUE_UWORD
		65535
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		65535.
    DISPLAY_IDENTIFIER Cxx_dtc_obd_vnt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_l.Cxx_obd_dc_xxx
		""
		VALUE
		0x80056076
		RSA_RecordLayout_VALUE_UBYTE
		9
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1.
		10.
    DISPLAY_IDENTIFIER Cxx_obd_dc_vnt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_l.fm_static_bitfield.Cbx_obd_mena_xxx
		""
		VALUE
		0x80056074
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Cbx_obd_mena_vnt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_l.fm_static_bitfield.Cbx_obd_xxx
		""
		VALUE
		0x80056074
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    BIT_MASK 0x04 
    DISPLAY_IDENTIFIER Cbx_obd_vnt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_vnt_l.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056074
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_vnt_l 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_blk.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80055c9d
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_wpmp_tcr_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_blk.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80055c9c
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_wpmp_tcr_blk 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_oc.Cxx_dtc_lb_xxx
		""
		VALUE
		0x80056105
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_wpmp_tcr_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_oc.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x80056104
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_wpmp_tcr_oc 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_scg.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560f9
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_wpmp_tcr_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_scg.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560f8
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_wpmp_tcr_scg 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_scw.Cxx_dtc_lb_xxx
		""
		VALUE
		0x800560ed
		RSA_RecordLayout_VALUE_UBYTE
		255
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		255.
    DISPLAY_IDENTIFIER Cxx_dtc_lb_wpmp_tcr_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin CHARACTERISTIC
		fm_cal_wpmp_tcr_scw.fm_static_bitfield.Cxx_conf_wal_xxx
		""
		VALUE
		0x800560ec
		RSA_RecordLayout_VALUE_UBYTE
		3
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		0.
		3.
    BIT_MASK 0x03 
    DISPLAY_IDENTIFIER Cxx_conf_wal_wpmp_tcr_scw 
    FORMAT "%6.3" 
/end CHARACTERISTIC
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		AcCkFqb_jidcAkd_FfFoarc_O___20a
		"LINEAR     [0.000000, 0H] [7.9687500, FFH]"
		RAT_FUNC
		"%6.3"
		"Ohm"
    COEFFS 0 32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		AdDehAb_CvnCEyd_wAFgpib_Jp__10a
		"LINEAR     [0.000000, 0H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/Kg/K"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin COMPU_METHOD
		AhCDoja_prbvulb_dammzgc_b__0a0a
		"LINEAR     [-2000.000000, 0H] [2000.000000, FA0H]"
		RAT_FUNC
		"%6.3"
		"bar"
    COEFFS 0 1 2000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		AkEtvpa_Fpuekuc_Bagaoqb_n__100a
		"LINEAR     [0.000000, 0H] [3.200000, 7D00H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		AmckCEa_rzqllkb_aAvivha_hp__a0a
		"LINEAR     [-32768.000000, 8000H] [32767.000000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"hPa/s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		Amrmhjb_saoiymc_dComzyc_NsA_30a
		"LINEAR     [0.000000, 0H] [2047.968750, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		Aooymna_oCAdEfc_aACyxka_f_A_2oa
		"LINEAR [0.500000, 1H] [32767.000000, FFFEH]"
		RAT_FUNC
		"%6.3"
		"%/s"
    COEFFS 0 2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		BAEcsta_ghvaACd_foyhjAa_1_0o00a
		"LINEAR     [0.000000, 0H] [124.998092, FFFFH]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 524.28800000000081 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : From 'atpftmng.xml' */
/begin COMPU_METHOD
		BBkhydb_BopFqDa_zoqBvwc___s2ewx
		"STATUS_PFT_WAIT_REQ"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF BBkhydb_BopFqDa_zoqBvwc___s2ewx_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		BDbaydc_ejoxiEd_lqghvcb_n_ao00a
		"LINEAR     [0.000000, 0H] ]25.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 2621.4400000000041 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		BDmecsd_EFtxusb_cEuCuea_dtA_10a
		"LINEAR     [0.000000, 0H] [255.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"dent"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin COMPU_METHOD
		BFEumua_fgyxxpd_AuvxBuc_rC_3e20
		"LINEAR______0._00000__0H___8160._00000__FFH_"
		RAT_FUNC
		"%6.3"
		"rpm"
    COEFFS 0 0.03125 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		BaetBhc_pDhrFcd_vCpmeDc_BpCRaa0
		"LINEAR     [-50000.000000, 9E58H] [50000.000000, 61A8H]"
		RAT_FUNC
		"%6.3"
		"[hPa/s]"
    COEFFS 0 0.5 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		Bchijab_hrievac_jkutjFc_JgCRa0a
		"LINEAR     [0.000000, 0H] [65535.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/Kg/K"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin COMPU_METHOD
		Bejmpoa_ynzmvdb_ymxlAud_W__000a
		"LINEAR     [-2550.000000, FFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"W/s"
    COEFFS 0 -0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		"LINEAR     [-10000.000000, 0H] [10000.000000, 4E20H]"
		RAT_FUNC
		"%6.3"
		"hPa"
    COEFFS 0 1 10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : From 'inasiiat.xml' */
/begin COMPU_METHOD
		Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd
		"STATUS_OK_NOK"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin COMPU_METHOD
		Bnlvuab_ejuenvc_iFEorkc_n__2a8a
		"LINEAR     [0.500000, 0H] [1.49609375, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 256 -128 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"g/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : From 'cmmuxser.xml' */
/begin COMPU_METHOD
		Brgjoob_bBymenb_rozDxfc_n1n2dax
		"STATUS_ANTICIPATED_TRANSMISSION"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF Brgjoob_bBymenb_rozDxfc_n1n2dax_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		BsxxCDd_fyuafxb_rkxlsta_NsA_00a
		"LINEAR     [0.000000, 0H] [-10235.000000, 7FFH]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 -0.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin COMPU_METHOD
		BtFhkBa_DFkireb_EeDBpgd_1__000a
		"LINEAR______0_000000__0H___0_500000__3E8H_"
		RAT_FUNC
		"%6.3"
		"1/ %"
    COEFFS 0 2000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : From 'tqsetacs.xml' */
/begin COMPU_METHOD
		Btazhnd_dbwbdEa_sBBrftd_n_l__bt
		"RANGE_STATE_STAL"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF Btazhnd_dbwbdEa_sBBrftd_n_l__bt_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		BuakiDc_orEyyfa_Bzwlpda_B__o20a
		"LINEAR     [0.000000, 0H] [1953.095197,FFFFH]"
		RAT_FUNC
		"%6.3"
		"[1/s²]"
    COEFFS 0 33.554432000000041 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		Bxlfbkc_gFDqwbc_BCeisnc_n_a967a
		"LINEAR     [0, 0H] [95999.999978, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 44739.242666502738 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/begin COMPU_METHOD
		BzcDpDc_nDAfApa_arzCqqa_BsA005a
		"LINEAR_______3276750_000000__0H___0_000000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"[hPa/s]"
    COEFFS 0 0.02 65535 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		Ccmteoc_hyddAAc_pcqbDlc_fA_020a
		"LINEAR     [-200.000000, 0H] [200.000000, 9C40H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 100 20000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin COMPU_METHOD
		Ccvzaia_zoDDBea_miabCpc_nA_038a
		"LINEAR     [-327.680000, 0000H] [327.670000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin COMPU_METHOD
		Cmmusla_wseoqyd_epxpmBd_ksA_00a
		"LINEAR     [0.000000, 0H] [2.550000, FFH]"
		RAT_FUNC
		"%6.3"
		"kg*m²"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/begin COMPU_METHOD
		Cngqitd_gujrlBa_yApdhoa_V_Ra0oa
		"LINEAR     [0.000000, 0H] [60.000000, 1770H]"
		RAT_FUNC
		"%6.3"
		"V"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		Cnqgazb_fqFBleb_mEzjcxc_kA49o40
		"LINEAR     [-62.5, 8000H] [62.49809,7FFFH]"
		RAT_FUNC
		"%6.3"
		"km/h/s"
    COEFFS 0 524.2879999999999 -7.2759576141834259E-12 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		"LINEAR______0_000000__0H___100_000000__2710H_"
		RAT_FUNC
		"%6.3"
		"g"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		CpAjotd_qajwitb_dexwBid_W2CR1a0
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/m^2/K"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		CrotiCd_FAysnkb_hfbjdrc_h___00a
		"LINEAR     [-3276.8000000, FFFF8000H] [3276.7000000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"hPa"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin COMPU_METHOD
		CsFwmpa_Allydta_yexwCka_vCR020a
		"LINEAR     [-512.000000, 80H] [508.000000, 7FH]"
		RAT_FUNC
		"%6.3"
		"µs"
    COEFFS 0 0.25 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin COMPU_METHOD
		CtFwfod_leeccbc_rBvivld_BaCRa0a
		"LINEAR     [-32768.000000, 8000H] [32767.000000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"[hPa2]"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		Czkjnqd_nosBBxb_uAyCyyd_Ns_a0o0
		"LINEAR     [0.000000, 0H] [0.00065535, FFFFH]"
		RAT_FUNC
		"%6.3"
		"N.s/m²"
    COEFFS 0 100000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		DFotjDa_nlDlFCb_kaockea_mqk_ao0
		"LINEAR______0_000000__0H___65_535000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"mg*s/°C/stk"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : From 'inasiiap.xml' */
/begin COMPU_METHOD
		DbqmAvc_FCazhwd_yFuDCFc_B3x__2l
		"STATUS_OK_NOK_FAIL"
		TAB_VERB
		"%6.3"
		"[-]"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF DbqmAvc_FCazhwd_yFuDCFc_B3x__2l_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		Ddbkgla_gwagdrc_gFhapic_kCRa10a
		"LINEAR     [-10000.000000, 0H] [16767215.000000, FFFFFFH]"
		RAT_FUNC
		"%6.3"
		"km"
    COEFFS 0 1 10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		DdkEsEc_fccourc_ysgmkaa_s__000a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"s/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		DgucdCc_iavwbAc_acFyxka_J_A_1oa
		"LINEAR     [0.000000, 0H] [65535.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin COMPU_METHOD
		DjimBpc_DyzDjma_Dkpqeyb_1mA_1a0
		"LINEAR     [0.000000, 0H] [7.999878, FFFFH]"
		RAT_FUNC
		"%6.3"
		"1/rpm"
    COEFFS 0 8192 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/begin COMPU_METHOD
		Dkodjkb_csClkBa_ikdmeDa_ippA01a
		"LINEAR     [-400.000000, 0H] [1647.968750, FFFFH]"
		RAT_FUNC
		"%6.3"
		"(Nm/rpm)^(1/2)"
    COEFFS 0 32 12800 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin COMPU_METHOD
		DmCFBja_Dhbdrld_ykkccca__A_aooa
		"LINEAR     [0.000000, 0H] [1.000000, 100H]"
		RAT_FUNC
		"%6.3"
		""
    COEFFS 0 256 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : From 'dgdgtmon.xml' */
/begin COMPU_METHOD
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		"ACTUATOR_TEST_STATUS"
		TAB_VERB
		"%6.3"
		"[-]"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF DpjnsAb_Ehtwufc_xFpuivb_B3xi_1__VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		Dweusab_Abjlppc_wagagja_kCRa00a
		"LINEAR______0_000000__0H___1_000000__2710H_"
		RAT_FUNC
		"%6.3"
		"kg"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		Dyoqqta_Efxijld_twheqqb_n__1o0a
		"LINEAR_______5_000000__0H___5_000000__3E8H_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100 500 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin COMPU_METHOD
		EFEjrvc_tBcpaDb_vDEnarc_l___00a
		"LINEAR     [0.000000, 0H] [100.000000, 7D0H]"
		RAT_FUNC
		"%6.3"
		"l/h"
    COEFFS 0 20 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/begin COMPU_METHOD
		Ecehxrc_vrBnskb_uBnyxka_vC__ooa
		"LINEAR_______32768_000000__8000H___32767_000000__7FFFH_"
		RAT_FUNC
		"%6.3"
		"µs"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		"LINEAR     [0.000000, 0H] [100.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 655.35 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/begin COMPU_METHOD
		EezxAwa_ABizfEa_ybCxwud_Nrj_0o0
		"LINEAR______0_000000__0H___255_000000__639CH_"
		RAT_FUNC
		"%6.3"
		"Nm/(rpm.s)"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		"LINEAR     [0.000000, 0H] [2.550000, FFH]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		Egtxmlc_gaqadlc_lumDsea_B2__0a0
		"LINEAR     [0.000000, 0H] [4294967.295000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"[hPa2]"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin COMPU_METHOD
		EjEjeBc_Fwbsxha_yuBglkb_ro__1o0
		"LINEAR_______65_535000__FFFFH___0__0H_"
		RAT_FUNC
		"%6.3"
		"ratio/s"
    COEFFS 0 -1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin COMPU_METHOD
		Enocvxb_jcbhbrd_pbvbdrc_f_R0ooa
		"LINEAR     [0.000000, 0H] [100.000000, 7D0H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 20 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin COMPU_METHOD
		ErjifAd_avCpgCa_wuzpvkc_hsA0ea0
		"LINEAR______0_000000__0H___3276750_000000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"hPa/s"
    COEFFS 0 0.02 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		ErwgDnb_wudaCDa_gAzibEd_rsA_o90
		"LINEAR     [-8192.000000, 0H] [8191.000000, 3FFFH]"
		RAT_FUNC
		"%6.3"
		"rpm/s"
    COEFFS 0 1 8192 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin COMPU_METHOD
		EufABca_arlgeCc_grheqod_BCRao0a
		"LINEAR     [-4.000000, 0H] [4.000000, 640H]"
		RAT_FUNC
		"%6.3"
		"[-]"
    COEFFS 0 200 800 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : From 'inpcibki.xml' */
/begin COMPU_METHOD
		EvAetkc_wufdhja_gbEzBsd______4p
		"STATUS_BRK_PDL_OFF_ON_VLDON"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF EvAetkc_wufdhja_gbEzBsd______4p_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		ExDjphc_wolDnoa_tzxooqb_fk_R1o0
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"%(strk/mg)"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		Eyamixb_yerjCqa_owzAdmc_WKA_0a0
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/m/K"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin COMPU_METHOD
		EzjkbBb_gknmBEa_juFvjsa_n_a599a
		"LINEAR     [0.000000, 0H] [0.999985, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 65535.999999999964 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		"LINEAR     [0.000000, 0H] [255.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"km/h"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		FgevDdd_qBlgAwd_zDfgqra_n_R0aoa
		"LINEAR     [1.000000, 0H] [256.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1 -1 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/begin COMPU_METHOD
		FgyAFgc_tigarid_FoAniEa_ro__ao0
		"LINEAR______0_000000__0H___1_000000__FFH_"
		RAT_FUNC
		"%6.3"
		"ratio/min"
    COEFFS 0 255 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		FhAkxid_mcktvDd_ysgmcea_1__000a
		"LINEAR     [0.000000, 0H] [327.675000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 200 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		FhjEdpd_murFlfd_zlheCCb_Np__0a0
		"LINEAR     [0.000000, 0H] [2.000000, 800H]"
		RAT_FUNC
		"%6.3"
		"Nm/rpm"
    COEFFS 0 1024 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		FlqkuDc_ublzpob_Cisqkrb_mtA_0o0
		"LINEAR_______21474_836480___80000000H___21474_836470___7FFFFFFFH_"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		FmBxzbd_ruyxyta_ordrkkc_mm__0o0
		"LINEAR     [0.000000, 0H] [0.65535, FFFFH]"
		RAT_FUNC
		"%6.3"
		"mol/mol"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		Fpkwtwc_lyuBfga_Bhcleqc_fgkAa0a
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"%/s(mg/strk)"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/begin COMPU_METHOD
		FrDdxAd_gBlBhnd_wuyyxkd_T_A_1oa
		"LINEAR     [0.000000, 0H] [3.000000, 3H]"
		RAT_FUNC
		"%6.3"
		"TDC"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin COMPU_METHOD
		FvuyuAd_lwkEihc_wlsckqb_n_o6o33
		"LINEAR     [-25.000000, 8000H] ]25.000000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1310.6999996948191 0.49999237047086348 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		"LINEAR     [0.000000, 0H] [65535.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"km"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin COMPU_METHOD
		Fyedevd_rnBqacd_ulakuub_roA_00a
		"LINEAR______0_000000__0H___81_918750__FFFFH_"
		RAT_FUNC
		"%6.3"
		"ratio"
    COEFFS 0 800 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_00000001_Prc
		""
		RAT_FUNC
		"%10.10"
		"%"
    COEFFS 0 100000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_00000001_PrcperSec
		""
		RAT_FUNC
		"%10.10"
		"%/s"
    COEFFS 0 100000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin COMPU_METHOD
		RB_CONV_0000001_Fac
		""
		RAT_FUNC
		"%6.8"
		"1/km"
    COEFFS 0 1 0 0 0 0.0000001 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_0000001_Prc
		""
		RAT_FUNC
		"%10.10"
		"%"
    COEFFS 0 10000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_0000001_PrcperSec
		""
		RAT_FUNC
		"%10.10"
		"%/s"
    COEFFS 0 10000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_000001_Prc
		""
		RAT_FUNC
		"%10.10"
		"%"
    COEFFS 0 1000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_000001_PrcperSec
		""
		RAT_FUNC
		"%10.10"
		"%/s"
    COEFFS 0 1000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_00001_PerSec
		""
		RAT_FUNC
		"%6.6"
		"/s"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin COMPU_METHOD
		RB_CONV_0001_65535_prc
		""
		RAT_FUNC
		"%6.10"
		"1/km"
    COEFFS 0 65535 0 0 0 0.0001 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_0001_FACT
		""
		RAT_FUNC
		"%6.4"
		"wu"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_001_FACT
		""
		RAT_FUNC
		"%6.4"
		"wu"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_001_Prc
		""
		RAT_FUNC
		"%6.4"
		"%"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_001_trs
		""
		RAT_FUNC
		"%8.3"
		"trs"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin COMPU_METHOD
		RB_CONV_003_Fac
		""
		RAT_FUNC
		"%6.3"
		"km/km"
    COEFFS 0 1000 0 0 0 3 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_100_255_Prc
		""
		RAT_FUNC
		"%6.4"
		"%"
    COEFFS 0 255 0 0 0 100 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_100_65535_Prc
		""
		RAT_FUNC
		"%6.6"
		"%"
    COEFFS 0 65535 0 0 0 100 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_100_SecPerHr
		""
		RAT_FUNC
		"%8.4"
		"s/h"
    COEFFS 0 1 0 0 0 100 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_10_trs
		""
		RAT_FUNC
		"%8.3"
		"trs"
    COEFFS 0 1 0 0 0 10 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_1Trs
		""
		RAT_FUNC
		"%12.2"
		"trs"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_1_65535_Prc
		""
		RAT_FUNC
		"%6.6"
		"%"
    COEFFS 0 65535 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin COMPU_METHOD
		RB_CONV_1_65535_wu
		""
		RAT_FUNC
		"%6.6"
		"wu"
    COEFFS 0 65535 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_1_DegC
		""
		RAT_FUNC
		"%8.2"
		"deg C"
    COEFFS 0 1 40 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_002_deg_Crk
		""
		RAT_FUNC
		"%6.2"
		"deg Crk"
    COEFFS 0 50 18000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_1_100_mg_strk
		""
		RAT_FUNC
		"%6.2"
		"mg/strk"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_32_Nm_0
		""
		RAT_FUNC
		"%6.5"
		"N.m"
    COEFFS 0 32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_8388608
		""
		RAT_FUNC
		"%12.4"
		"wu"
    COEFFS 0 100 8388608 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_DegC
		""
		RAT_FUNC
		"%8.2"
		"deg C"
    COEFFS 0 10 400 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_DegC_1200
		""
		RAT_FUNC
		"%8.2"
		"deg C"
    COEFFS 0 10 12000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_Gear
		""
		RAT_FUNC
		"%6.2"
		"-"
    COEFFS 0 1 1 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_Kg_s_00001
		""
		RAT_FUNC
		"%6.7"
		"kg/s"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : From 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_OBD_Status
		""
		TAB_VERB
		"%6.0"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF RB_CONV_AtCatDgn_OBD_Status_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_OneToOne
		""
		RAT_FUNC
		"%6.2"
		"-"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_OneToOne_wu
		""
		RAT_FUNC
		"%6.2"
		"wu"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_Time_01s
		""
		RAT_FUNC
		"%8.2"
		"s"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_Time_1s
		""
		RAT_FUNC
		"%8.2"
		"s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : From 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_Vld_Status_2
		""
		TAB_VERB
		"%6.0"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF RB_CONV_AtCatDgn_Vld_Status_2_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : From 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_bool
		""
		TAB_VERB
		"%6.0"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF RB_CONV_AtCatDgn_bool_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_km_1
		""
		RAT_FUNC
		"%12.2"
		"km"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/begin COMPU_METHOD
		RB_CONV_AtCatDgn_rpm
		""
		RAT_FUNC
		"%6.2"
		"rpm"
    COEFFS 0 4 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_DegC
		""
		RAT_FUNC
		"%8.2"
		"deg C"
    COEFFS 0 10 400 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin COMPU_METHOD
		RB_CONV_DgC
		""
		RAT_FUNC
		"%8.2"
		"deg C"
    COEFFS 0 10 400 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Distance_1km
		""
		RAT_FUNC
		"%12.2"
		"km"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_FACT
		""
		RAT_FUNC
		"%6.4"
		"_"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Liter
		""
		RAT_FUNC
		"%6.4"
		"l"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Lper1000Km
		""
		RAT_FUNC
		"%6.4"
		"l/1000km"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_Mass_g
		""
		RAT_FUNC
		"%6.2"
		"g"
    COEFFS 0 10 0 0 0 8 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Nm
		""
		RAT_FUNC
		"%6.5"
		"Nm"
    COEFFS 0 32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_OneToOne
		""
		RAT_FUNC
		"%6.2"
		"-"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/begin COMPU_METHOD
		RB_CONV_OuCboUeg_OneToOne_wu
		""
		RAT_FUNC
		"%6.0"
		"wu"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : From 'oucboueg.xml' */
/begin COMPU_METHOD
		RB_CONV_OuCboUeg_Vld_Status
		""
		TAB_VERB
		"%6.0"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF RB_CONV_OuCboUeg_Vld_Status_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : From 'oucboueg.xml' */
/begin COMPU_METHOD
		RB_CONV_OuCboUeg_bool
		""
		TAB_VERB
		"%6.0"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF RB_CONV_OuCboUeg_bool_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Prc
		""
		RAT_FUNC
		"%6.4"
		"%"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_Pres_hpa
		""
		RAT_FUNC
		"%6.0"
		"hpa"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Res_0001
		""
		RAT_FUNC
		"%6.6"
		"-"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Res_001
		""
		RAT_FUNC
		"%6.4"
		"-"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_SecPerHr
		""
		RAT_FUNC
		"%6.4"
		"s/h"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Time1_s
		""
		RAT_FUNC
		"%8.2"
		"s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_Time_s
		""
		RAT_FUNC
		"%8.2"
		"s"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_Trs
		""
		RAT_FUNC
		"%8.3"
		"trs"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_VehSpd
		""
		RAT_FUNC
		"%6.2"
		"kmph"
    COEFFS 0 1 0 0 0 4 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_Vol
		""
		RAT_FUNC
		"%6.1"
		"m3/h"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin COMPU_METHOD
		RB_CONV_distance_1m
		""
		RAT_FUNC
		"%12.2"
		"m"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/begin COMPU_METHOD
		RB_CONV_distance_3m
		""
		RAT_FUNC
		"%12.2"
		"m"
    COEFFS 0 1 0 0 0 3 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_flconsum
		""
		RAT_FUNC
		"%6.2"
		"l/h"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_flconsum_1
		""
		RAT_FUNC
		"%6.2"
		"l/h"
    COEFFS 0 100 0 0 0 5 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_length_km
		""
		RAT_FUNC
		"%8.2"
		"km"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/begin COMPU_METHOD
		RB_CONV_mgperstrk
		""
		RAT_FUNC
		"%6.4"
		"mg/strk"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/begin COMPU_METHOD
		RB_CONV_rpm
		""
		RAT_FUNC
		"%6.2"
		"rpm"
    COEFFS 0 4 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : From 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_Bool_ON_OFF
		""
		TAB_VERB
		"%8.4"
		"."
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF VA_Bool_ON_OFF_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v0004_p0_1
		""
		RAT_FUNC
		"%9.4"
		"m/s2"
    COEFFS 0 1 0 0 0 0.0004 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v0004_p0_10
		""
		RAT_FUNC
		"%9.4"
		"m/s2"
    COEFFS 0 1 0 0 0 0.0004 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v0004_p0_15
		""
		RAT_FUNC
		"%9.4"
		"m/s²"
    COEFFS 0 1 0 0 0 0.0004 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v001_p0v2_8
		""
		RAT_FUNC
		"%9.3"
		"m"
    COEFFS 0 1 -0.2 0 0 0.001 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v004_p0_4
		""
		RAT_FUNC
		"%9.3"
		"-"
    COEFFS 0 1 0 0 0 0.004 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v01_p0_10
		""
		RAT_FUNC
		"%9.2"
		"km/h"
    COEFFS 0 1 0 0 0 0.01 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v01_p0_11
		""
		RAT_FUNC
		"%9.2"
		"(km/h)/krpm"
    COEFFS 0 1 0 0 0 0.01 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v01_p0_25
		""
		RAT_FUNC
		"%9.2"
		"ratio"
    COEFFS 0 1 0 0 0 0.01 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v01_p0_3
		""
		RAT_FUNC
		"%9.2"
		"km/h"
    COEFFS 0 1 0 0 0 0.01 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v02_p0_4
		""
		RAT_FUNC
		"%9.2"
		"s"
    COEFFS 0 1 0 0 0 0.02 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v03125_m400_13
		""
		RAT_FUNC
		"%9.2"
		"N.m"
    COEFFS 0 1 400 0 0 0.03125 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v04_p0_7
		""
		RAT_FUNC
		"%9.2"
		"s"
    COEFFS 0 1 0 0 0 0.04 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v125_m2000_5
		""
		RAT_FUNC
		"%9.2"
		"ratio/s"
    COEFFS 0 1 2000 0 0 0.125 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v125_p0_14
		""
		RAT_FUNC
		"%9.2"
		"%"
    COEFFS 0 1 0 0 0 0.125 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v125_p0_20
		""
		RAT_FUNC
		"%9.2"
		"ratio/s"
    COEFFS 0 1 0 0 0 0.125 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v125_p0_6
		""
		RAT_FUNC
		"%9.2"
		"ratio"
    COEFFS 0 1 0 0 0 0.125 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v1_m40_12
		""
		RAT_FUNC
		"%9.2"
		"°C"
    COEFFS 0 1 40 0 0 0.1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_0v1_m40_2
		""
		RAT_FUNC
		"%9.2"
		"C"
    COEFFS 0 1 40 0 0 0.1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v1_m40_21
		""
		RAT_FUNC
		"%9.2"
		"°C"
    COEFFS 0 1 40 0 0 0.1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v1_p0_9
		""
		RAT_FUNC
		"%9.2"
		"s"
    COEFFS 0 1 0 0 0 0.1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v25_p0_3
		""
		RAT_FUNC
		"%9.2"
		"RPM"
    COEFFS 0 1 0 0 0 0.25 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_0v25_p0_7
		""
		RAT_FUNC
		"%9.2"
		"rpm"
    COEFFS 0 1 0 0 0 0.25 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_10_m327680_8
		""
		RAT_FUNC
		"%9.2"
		"W"
    COEFFS 0 1 327680 0 0 10 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_10_p0_11
		""
		RAT_FUNC
		"%9.2"
		"W"
    COEFFS 0 1 0 0 0 10 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_10_p0_17
		""
		RAT_FUNC
		"%9.2"
		"W"
    COEFFS 0 1 0 0 0 10 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_1_m1_24
		""
		RAT_FUNC
		"%9.2"
		"-"
    COEFFS 0 1 1 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_1_p0_12
		""
		RAT_FUNC
		"%9.2"
		"-"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_1_p0_13
		""
		RAT_FUNC
		"%9.2"
		"N.m"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_1_p0_18
		""
		RAT_FUNC
		"%9.2"
		"s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_1_p0_19
		""
		RAT_FUNC
		"%9.2"
		"rpm"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_1_p0_5
		""
		RAT_FUNC
		"%9.2"
		"N.m"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_1_p0_6
		""
		RAT_FUNC
		"%9.2"
		"kg"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_F_1_p1_1
		""
		RAT_FUNC
		"%9.2"
		"-"
    COEFFS 0 1 -1 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_1_p1_2
		""
		RAT_FUNC
		"%9.2"
		"-"
    COEFFS 0 1 -1 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_F_1_p2_23
		""
		RAT_FUNC
		"%9.2"
		"-"
    COEFFS 0 1 -2 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_I_16
		""
		RAT_FUNC
		"%9.2"
		"-"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_I_22
		""
		RAT_FUNC
		"%9.2"
		"0"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/begin COMPU_METHOD
		VA_I_9
		""
		RAT_FUNC
		"%9.2"
		"-"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/begin COMPU_METHOD
		VA_Id_0x00
		""
		RAT_FUNC
		"%9.2"
		"."
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		aEbBibb_eAtEfyc_nerkgtd_kp__1a0
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"km/h/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		aEkiAhc_txCxevc_gDuupfc_JR09917
		"LINEAR     [-214748364.800000, 80000000H] [214748364.700000, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"J"
    COEFFS 0 10 1.192092895507813E-07 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		aFiroeb_qrguaya_rFDnrda_1__000a
		"LINEAR     [-655.350000, FFFFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 -100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		aainjEc_jgzdbtd_deplAyc_NsA_00a
		"LINEAR     [0.000000, 0H] [10235.000000, 7FFH]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 0.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		afehFbd_BkiipFd_DFrgCuc_Nrj_ao0
		"LINEAR     [0.000000, 0H] [63.999023, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm/(rpm.s)"
    COEFFS 0 1024 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin COMPU_METHOD
		ahawbcc_hzlkqra_yesdzoa_g_Ra2oa
		"LINEAR     [0.000000, 0H] [204.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"g"
    COEFFS 0 1.25 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin COMPU_METHOD
		ahqcwla_mcvrhmc_acrzCga_bp__a0a
		"LINEAR     [0.000000, 0H] [4500, 1194H]"
		RAT_FUNC
		"%6.3"
		"bar/s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		akxoDid_fubczib_zregbrc_N_R05oa
		"LINEAR     [-20000.000000, D8F0H] [111068.000000, D8EEH]"
		RAT_FUNC
		"%6.3"
		"N"
    COEFFS 0 0.5 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		apzCdoc_Baddesb_cgxmbwc_1CRa0a0
		"LINEAR     [0.000000, 0H] [0.655350, FFFFH]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		arAgssb_cAzswia_pjzaDlc_gA_020a
		"LINEAR     [-255.000000, 0H] [255.000000, C738H]"
		RAT_FUNC
		"%6.3"
		"g"
    COEFFS 0 100 25500 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		ardBnwb_nuseFmc_fvuFqsa_J__0a60
		"LINEAR     [-327680.000000, 0H] [327670.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/m3"
    COEFFS 0 0.1 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		arwyBvd_Bjyqsid_ueevtcd_J__0na0
		"LINEAR______0_000000__0H___858993459000_000000__FFFFFFFFH_"
		RAT_FUNC
		"%6.3"
		"J/Kg"
    COEFFS 0 0.005 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		awthFuc_dFDnrqd_ufrCFpb_Js__aa0
		"LINEAR     [0.000000, 0H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/K/s/m²"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin COMPU_METHOD
		bAngAbd_ajxybma_vfjmdrc_m___00a
		"LINEAR     [0.000000, 0H] [25.500000, FFH]"
		RAT_FUNC
		"%6.3"
		"mph"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		bCkDtxb_iBmhrgb_vDEgpCc_khA_10a
		"LINEAR______0_000000__0H___2000_000000__4E20H_"
		RAT_FUNC
		"%6.3"
		"kg/h"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin COMPU_METHOD
		bCvqxab_BrEwowc_wubjDqc_rsA0ea0
		"LINEAR______0_000000__0H___25500_000000__FFH_"
		RAT_FUNC
		"%6.3"
		"rpm/s"
    COEFFS 0 0.01 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		bCyeoab_zijwjxc_htqocrc_h___o0a
		"LINEAR     [2.000000, 1H] [100000.000000, C350H]"
		RAT_FUNC
		"%6.3"
		"hPa"
    COEFFS 0 0.5 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		bEowska_EEdlCia_rswmrta_NsA_30a
		"LINEAR     [-2047.968750, FFFFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 -32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		bFjCisa_ylspjfb_EjFjAea_kp__40a
		"LINEAR     [0.000000, 0H] [6.375, FFH]"
		RAT_FUNC
		"%6.3"
		"km/h/s"
    COEFFS 0 40 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/begin COMPU_METHOD
		bFvxscc_Ayimzfb_CwzqyDc_Ba__a0a
		"LINEAR_______32768_000000__8000H___32767_000000__7FFFH_"
		RAT_FUNC
		"%6.3"
		"[hPa]"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		baCmrya_mltpssd_Aavnptc_N__0o0a
		"LINEAR     [-12799.804687, FFFFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 -5.12 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin COMPU_METHOD
		bauhfwa_Bqxetgb_xFDtpAa_n__a00a
		"LINEAR     [0.000000, 0H] [-4.000000, 320H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 -200 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		bbBdoca_FBdtmBd_tFElbrc_J___00a
		"LINEAR     [0.000000, 0H] [3276.750000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/K"
    COEFFS 0 20 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin COMPU_METHOD
		bbCaFwb_lqiouyd_yswmbyd_1__030a
		"LINEAR     [-2047.968750, FFFFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 -32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin COMPU_METHOD
		bcEalnd_AvmCroa_pdqnwqa_fR06012
		"LINEAR_______327_680000__8000H___327_670000__7FFFH_"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 100 3.637978807091713E-12 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		bhFmknc_wmuuxlc_rndtjud_H_a333a
		"LINEAR     [0.000000, 0H] [0.7470703125, FFH]"
		RAT_FUNC
		"%6.3"
		"H"
    COEFFS 0 341.33333333333331 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin COMPU_METHOD
		braFrkc_srbpgAb_eBozlbc_W__199a
		"LINEAR     [0.000000, 0H] [4.9999237060546875, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/rpm"
    COEFFS 0 13107.19999999999 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		btcrqxb_rwougbd_FkjBqfc_f_00o70
		"LINEAR_______65_536000__8000H___65_534000__7FFFH_"
		RAT_FUNC
		"%6.3"
		"%Vsens"
    COEFFS 0 500.00000000000011 3.637978807091713E-12 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		cBcxaAb_uwygFqb_dmopcrc_N___00a
		"LINEAR     [0.000000, 0H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nms"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		cDliaod_tCvFBmd_ozEgwlc_m__00a0
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"m³/s"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		cDnjuxa_imylsBc_FdEgbrc_kC_0ooa
		"LINEAR     [0.000000, 0H] [300000.000000, 7530H]"
		RAT_FUNC
		"%6.3"
		"km"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		"LINEAR     [0.000000, 0H] [511.992188, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 128 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : From 'atpftmdl.xml' */
/begin COMPU_METHOD
		ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf
		"STATUS_CSF_RGN_NULL_COLD_MED"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		"LINEAR______0_000000__0H___655_350000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"g/min"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		ceahcwa_qAokznd_oCDvqxb_J__000a
		"LINEAR     [0.000000, 0H] [65.5350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/K"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin COMPU_METHOD
		chdCwia_quwmEod_wvDpjfb_k1pA060
		"LINEAR     [0.000000, 0H] ]100.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"km/h/1000rpm"
    COEFFS 0 2.56 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		civwepa_tvdpkEc_oqmzysb_k_46480
		"LINEAR     [-62.5, -80000000H] [62.5,7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"km/h/s"
    COEFFS 0 34359738.367999993 -4.76837158203125E-07 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		ckwCawc_pobjjda_jyzaFic_No_2995
		"LINEAR     [-1.999969, 0H] [0.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm/(rpm.s)"
    COEFFS 0 32767.99999999992 65535 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/begin COMPU_METHOD
		coccfFc_twmCjBc_pgCaqeb_n__6o0a
		"LINEAR______0_000000__0H___100_000000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 655.35 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : From 'atpcbctl.xml' */
/begin COMPU_METHOD
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		"STATUS_OK_NOK_FAIL"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF cqvsmgd_egstFCa_yhphkFc_n_v0v2l_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : From 'atpftdgn.xml' */
/begin COMPU_METHOD
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		"STATUS_OK_NOK_FAIL_2_FAIL_3"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF crcpByb_qtnxvic_rzBrBqc_n0o_2ax_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin COMPU_METHOD
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		"LINEAR     [-8192.000000, 0H] [8191.750000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"rpm"
    COEFFS 0 4 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/begin COMPU_METHOD
		cyoczhd_qiwFCea_wcovmmd_mCR1ea0
		"LINEAR______0_000000__0H___20400_000000__FFH_"
		RAT_FUNC
		"%6.3"
		"mm³"
    COEFFS 0 0.0125 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : From 'inclicoi.xml' */
/begin COMPU_METHOD
		dBCtsuc_hqDqtlb_iowwora_n_1a__x
		"STATUS_TCO_MODEL"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF dBCtsuc_hqDqtlb_iowwora_n_1a__x_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		dCxqAad_vCfEADc_yrvpbwb_f__100a
		"LINEAR     [-21474.836480, 80000000H] [21474.836470, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		"LINEAR_______1200_000000__0H___1200_000000__5DC0H_"
		RAT_FUNC
		"%6.3"
		"°C"
    COEFFS 0 10 12000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin COMPU_METHOD
		dFifxkd_wwDjcjb_dhaphib_hs_0e20
		"LINEAR______0_000000__0H____3276750_000000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"hPa/s"
    COEFFS 0 -0.02 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		dFjxvqb_bnBujga_oeusmlb_K__an3a
		"LINEAR     [233.000000, 0H] [65768.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"K"
    COEFFS 0 1 -233 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin COMPU_METHOD
		dfzFahb_jhnifha_BagaAvb__A_100a
		"LINEAR______0_000000__0H___6_553500__FFFFH_"
		RAT_FUNC
		"%6.3"
		""
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		dijrEgd_jEbzmhc_rkpmmtd_NsA_o0a
		"LINEAR     [0.000000, 0H] [12799.804687, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 5.12 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		"LINEAR     [-360.000000, 0H] [360.000000, 8CA0H]"
		RAT_FUNC
		"%6.3"
		"°CRK"
    COEFFS 0 50 18000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin COMPU_METHOD
		drbdAab_snynrtd_cpBhbcd_W__500a
		"LINEAR______0_000000__0H___500000_000000__FAH_"
		RAT_FUNC
		"%6.3"
		"W"
    COEFFS 0 0.0005 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin COMPU_METHOD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		"LINEAR     [-10.000000, FFFFFC18H] [200.000000, 4E20H]"
		RAT_FUNC
		"%6.3"
		"(km/h)/K*rpm"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		dzejcha_hlcsspd_Bqhaoqb_n__200a
		"LINEAR______0_00000__0H___2_00000__9C40H_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 20000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		eCnFzid_CzrcuBd_rraqewb_nA_0a60
		"LINEAR_______32_768000__0H___32_767000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1000 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : From 'inpcibki.xml' */
/begin COMPU_METHOD
		eDlybpa_szqqFga_puaotid___N_fs_
		"STATUS_BRK_PDL_OFF_ON"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF eDlybpa_szqqFga_puaotid___N_fs__VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin COMPU_METHOD
		ecEhdtc_jlfrdid_stErrwa_N__0a00
		"LINEAR     [-650.000000, 0H] [650.000000, FDE8H]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 50 32500 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin COMPU_METHOD
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		"LINEAR     [0.000000, 0H] [1.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 255 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin COMPU_METHOD
		egzsxdd_khlsmxa_bqjovCc_msA_10a
		"LINEAR     [-12.000000, FF88H] [13.500000, 87H]"
		RAT_FUNC
		"%6.3"
		"m/s²"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		escrhtd_Dlzjwvb_pgqbElc_nA_010a
		"LINEAR     [-100.000000, 0H] [100.000000, 4E20H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100 10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		etFmowc_wzFizua_ewnyxka_mC__ooa
		"LINEAR     [0.000000, 0H] [65535.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"ms"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin COMPU_METHOD
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		"LINEAR     [0.000000, 0H] [655350.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		ezvttmd_fgeufqb_bCDnrha_1__000a
		"LINEAR     [-0.128000, 80H] [0.127000, 7FH]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		fBnckhb_ozrejBa_yFBnwba_n_90540
		"LINEAR     [-50.00000000, 80000000H] ]50.00000000, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 42949672.960000023 9.5367431640625E-07 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin COMPU_METHOD
		fFxvEyc_Farydib_Bvpdzsa_Bp__o20
		"LINEAR______0_000000__0H___3276750_000000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"[hPa/s]"
    COEFFS 0 0.02 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin COMPU_METHOD
		fbhwiwa_ocsanpd_EFwyxCb_m_A_1oa
		"LINEAR     [0.000000, 0H] [255.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"mph"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		fdzoyza_nfCiiDb_dkpidrc_N___o0a
		"LINEAR     [0.000000, 0H] [131070, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"N/s"
    COEFFS 0 0.5 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin COMPU_METHOD
		ffmgnAd_dDtexfb_dlatjta_1mCR1o0
		"LINEAR     [0.000000, 0H] [10.000000, 2710H]"
		RAT_FUNC
		"%6.3"
		"1/(Nm*s)"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		ffvohed_uoEmjkd_dCoeDrc_f___20a
		"LINEAR [-32767.000000, FFFEH] [-0.500000, 1H]"
		RAT_FUNC
		"%6.3"
		"%/s"
    COEFFS 0 -2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin COMPU_METHOD
		fgqiqic_vvinhpa_ErooDea_kp__30a
		"LINEAR     [0.000000, 0H] [79.687500, FFH]"
		RAT_FUNC
		"%6.3"
		"km/h/s"
    COEFFS 0 3.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		"LINEAR     [-10000.000000, D8F0H] [10000.000000, 2710H]"
		RAT_FUNC
		"%6.3"
		"hPa"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		fktwhda_oraezna_gEulmqc_feCRa0a
		"LINEAR______0_000000__0H___65535_000000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"%Vsens"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin COMPU_METHOD
		fkydtnb_xBgCwha_blhnpEd_q__0a00
		"LINEAR     [-40.000000, 0H] [429496.729500, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"°C"
    COEFFS 0 10000 400000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		fmmmApb_sBgvABb_isuEced_mtA0000
		"LINEAR_______100_000000__0H___100_000000__4E20H_"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 100 10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin COMPU_METHOD
		fsjmcda_jujcsFa_ycbccca_n_Ra6oa
		"LINEAR     [0.000000, 0H] [0.996094, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 256 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		ftmodod_Ffszhha_Fbvahrc_n_R0ooa
		"LINEAR     [0.000000, 0H] [3.984375, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 64 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin COMPU_METHOD
		fttjmpc_wyufdBc_FDpbarc_kC_00oa
		"LINEAR     [0.000000, 0H] [16000000.000000, 9896800H]"
		RAT_FUNC
		"%6.3"
		"km"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		ftwcbqd_ctesoad_frxanmc_kCRa38a
		"LINEAR     [-32768.000000, 0H] [32767.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"km"
    COEFFS 0 1 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		fwrsuEb_xbjymjc_ypEDADc_Bs__a0a
		"LINEAR     [0.500000, 1H] [65535.000000, 1FFFEH]"
		RAT_FUNC
		"%6.3"
		"[%/s]"
    COEFFS 0 2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : From 'ouclocoo.xml' */
/begin COMPU_METHOD
		fxDqmCc_ygftyxa_jCwvBkb_n__0m2p
		"STATUS_WPMP_STATE"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF fxDqmCc_ygftyxa_jCwvBkb_n__0m2p_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		fzxjbBd_syBEseb_ysimAia_W__000a
		"LINEAR     [0.000000, 0H] [327.675000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/K"
    COEFFS 0 200 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin COMPU_METHOD
		gAxrkfd_lexibpc_hFwmFyc_NAA_50a
		"LINEAR     [0.000000, 0H] [5.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"Nm/A"
    COEFFS 0 51 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		"LINEAR     [-200.000000, B1E0H] [200.000000, 4E20H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : From 'inpcidls.xml' */
/begin COMPU_METHOD
		gFhcrdc_ukljqcc_zFmtlua__1csc8c
		"RANGE_STATE_COUPLER"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF gFhcrdc_ukljqcc_zFmtlua__1csc8c_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin COMPU_METHOD
		gbkklec_Fwupora_tbolFEa_khA_15a
		"LINEAR     [5.000000, 0H] [260.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"km/h"
    COEFFS 0 1 -5 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin COMPU_METHOD
		gjkApod_wtFxkBb_DmtjdCa_roCRaa0
		"LINEAR______0_000000__0H___5_000000__FFH_"
		RAT_FUNC
		"%6.3"
		"ratio/s"
    COEFFS 0 51 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin COMPU_METHOD
		gkqcqfd_fDxenaa_ypqitmb_BsD_020
		"LINEAR     [0.000000, 0H] [-250000.000000, C350H]"
		RAT_FUNC
		"%6.3"
		"[mg/stk/s]"
    COEFFS 0 -0.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : From 'inpcibki.xml' */
/begin COMPU_METHOD
		gkvtrya_ftnfaCc_Braotid_n2NkfN_
		"STATUS_BRK_PDL_OFF_ON"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF gkvtrya_ftnfaCc_Braotid_n2NkfN__VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		glDzsCb_yhkjvsa_ysimoha_J__000a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/K"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		gretyea_ujEhBid_tCpaEic_n__1a0a
		"LINEAR     [-100.000000, 0H] [100.000000, 7D0H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 10 1000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		gsxEdxb_mgAbFdd_ntalEla_K_a999a
		"LINEAR     [0.000000, 0H] [4294.967295, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"K"
    COEFFS 0 999999.99999999988 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		hBfxgcb_Ettmaca_oahdcDa_1C_144a
		"LINEAR     [0.000000, 0H] [0.031128, FFH]"
		RAT_FUNC
		"%6.3"
		"1/°C"
    COEFFS 0 8191.9814957594454 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/begin COMPU_METHOD
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		"LINEAR______0_000000__0H___25000_000000__61A8H_"
		RAT_FUNC
		"%6.3"
		"mV"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin COMPU_METHOD
		hBghoxa_gdkcCwa_tEheqqb_n__1o0a
		"LINEAR     [-1.000000, 0H] [1.000000, C8H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100 100 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		hBsddec_yactvDc_Fvgbarc_NC_00oa
		"LINEAR     [-3276.80000, 8000H] [3276.70000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"Nm"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		"LINEAR______0_000000__0H___100_000000__2710H_"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		"[VIT_DDS]ArtificialDDSConversion"
		RAT_FUNC
		"%6.3"
		""
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/begin COMPU_METHOD
		hgvwEza_uBFvrdc_bmnddrc_b___00a
		"LINEAR______0_000000__0H___6553_500000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"bar"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin COMPU_METHOD
		hlmzaia_FvatkBa_FEDjhpa_NhR055o
		"LINEAR______0_000000__0H___24_902343__100H_"
		RAT_FUNC
		"%6.3"
		"Nm/km/h"
    COEFFS 0 10.280157172359241 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin COMPU_METHOD
		hmkxuhd_cvwcsja_vaFmhaa_PKEA_o0
		"LINEAR______0_000000__0H___6000_0000__EA60H_"
		RAT_FUNC
		"%6.3"
		"Pa/(Kg/s)^2"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		hpgfbgb_mbrEpjc_gwhakic_mCRa00a
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"mol"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		htcDCta_bFrnkyc_dCEgxCc_msA_10a
		"LINEAR     [0.000000, 0H] [65535.000000, 9FFF6H]"
		RAT_FUNC
		"%6.3"
		"mg/s"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/begin COMPU_METHOD
		htracgc_cxjyghb_frCstAc_hmj_00a
		"LINEAR     [0.000000, 0H] [0.050000, 1F4H]"
		RAT_FUNC
		"%6.3"
		"hPa/(mg/stk)^2"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/begin COMPU_METHOD
		hxvzvxb_eawjegc_pebEkib_1R__0a0
		"LINEAR     [0.000000, 0H] [1.000000, 400H]"
		RAT_FUNC
		"%6.3"
		"1/°CRK"
    COEFFS 0 1024 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		hzphAid_Cwamssa_FDefygd_WC_000a
		"LINEAR     [0.000000, 0H] [0.00000065535, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/K4"
    COEFFS 0 100000000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		iCuEfea_DmeBtvd_oAbwmgc_f_99300
		"LINEAR     [-327.680000, 8000H] [327.670000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 99.999999999999986 -3.637978807091713E-12 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/begin COMPU_METHOD
		iFzvbxb_yFwnaca_FlrjjEb_VrA_0a0
		"LINEAR     [0.000000, 0H] [0.255, FFH]"
		RAT_FUNC
		"%6.3"
		"V/Bar"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin COMPU_METHOD
		iajxBpc_mBoqiud_Eqnyxub_l_R0ooa
		"LINEAR     [0.000000, 0H] [255.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"l"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		idknhma_eEagBsc_Fbvbarc_n_R0ooa
		"LINEAR     [0.000000, 0H] [25.500000, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin COMPU_METHOD
		ieyvrqa_pummcoa_ruhaEzb_hCRa00a
		"LINEAR______0_000000__0H___6_553500__FFFFH_"
		RAT_FUNC
		"%6.3"
		"hPa"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin COMPU_METHOD
		igqhjec_noAABbd_Eqnyxwb_m_R0ooa
		"LINEAR     [0.000000, 0H] [4294967295.000000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"m"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin COMPU_METHOD
		igyxFvd_CwEnvea_dcprdrc_W___o0a
		"LINEAR     [0.000000, 0H] [2550.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"W/s"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin COMPU_METHOD
		ihlElic_Eatfvkd_DxdrElb_n_o7300
		"LINEAR     [-0.45, 8271H] [0.45, 7D8FH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 71428.57142857142 -3.637978807091713E-12 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		ihoBjcc_mwetedb_lefmhic_mC_R1o0
		"LINEAR______0_000000__0H___6_553500__FFFFH_"
		RAT_FUNC
		"%6.3"
		"mg/°C/stk"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin COMPU_METHOD
		ilwggEa_nwEBkfb_flvxFAb_qC_333a
		"LINEAR     [0.000000, 0H] [765.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"°CRK"
    COEFFS 0 0.33333333333333331 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		imCajqb_vnxgbdb_hCDvmsa_K__a00a
		"LINEAR     [0.000000, 0H] [4294967.295000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"K"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		"LINEAR     [0.000000, 0H] [655350, FFFFH]"
		RAT_FUNC
		"%6.3"
		"kPa"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin COMPU_METHOD
		ioDywdb_Admtpyb_jtsmfwc_fA_0a60
		"LINEAR     [-100.000000, 7800H] [100.000000, 8800H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 20.48 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : From 'ouatoefi.xml' */
/begin COMPU_METHOD
		iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni
		"RANGE_ROUTINE_STATUS"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		isbAByd_airlCCb_devbarc_s_R0ooa
		"LINEAR     [0.000000, 0H] [25.500000, FFH]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : From 'cmmuxser.xml' */
/begin COMPU_METHOD
		itzAFCa_walhowa_fCBrBqc___kv_i_
		"STATUS_OK_NOK_FAIL_2_FAIL_3"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF itzAFCa_walhowa_fCBrBqc___kv_i__VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		ivqfwxa_aFFjDud_lqCArsa_f__a40a
		"LINEAR     [-100.000000, -800H] [100.000000, 800H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 20.48 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin COMPU_METHOD
		iyavyEb_EuAdyma_ysgmsda_m__000a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"m/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin COMPU_METHOD
		jBfcoed_dgfcpFd_nsxxcxb_khCRa0a
		"LINEAR______0_000000__0H___255_000000__FFH_"
		RAT_FUNC
		"%6.3"
		"km/h/s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin COMPU_METHOD
		jDCaqEa_tlhhnpa_yuyczca_n_Ra5oa
		"LINEAR     [0.000000, 0H] [100.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 2.55 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		jFzaled_fvrodod_dCEcchc_qsA_10a
		"LINEAR______0_000000__0H___25_000000__FAH_"
		RAT_FUNC
		"%6.3"
		"°C/s"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin COMPU_METHOD
		jdkejcd_tjwodjc_Axqyxka_t_A_1oa
		"LINEAR     [0.000000, 0H] [4294967295.000000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"trs"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		jgsctCa_keuEisb_frxaDlc_kCRa37a
		"LINEAR     [-32767.000000, 0H] [32768.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"km"
    COEFFS 0 1 32767 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		jicvsba_lmvqCic_zrvpbwb_n__100a
		"LINEAR     [0.000000, 0H] [0.655350, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		"LINEAR     [0.000000, 0H] [5000.000000, C350H]"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin COMPU_METHOD
		jkrACBa_BAgsrcb_zlhfntb_n_a824a
		"LINEAR     [0.000000, 0H] [0.450000, 7D8FH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 71428.57142857142 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		jmgwfvb_ryjelzb_rqdjaeb_qC_666a
		"IGRE_LINEAR     [-23.625000, 0H] [72.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"°CRK"
    COEFFS 0 2.666666666666667 63 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		"LINEAR     [0.000000, 0H] [65535.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"mg/s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		jqDnnvd_vaisdFc_Eqnyxka_s_R0ooa
		"LINEAR     [0.000000, 0H] [255.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin COMPU_METHOD
		kCxiFib_vAhfxia_yAaegEa_n_Raooa
		"LINEAR______0_019531__1H___5_000000__100H_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 51.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin COMPU_METHOD
		kDBlDjc_fldogca_dCfnthc_f__020a
		"LINEAR______0._00000__0H___1._00000__3FFH_"
		RAT_FUNC
		"%6.3"
		"%/s"
    COEFFS 0 1023 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin COMPU_METHOD
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		"LINEAR     [0.000000, 0H] [1048560.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"km"
    COEFFS 0 0.0625 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		kEDroFa_Bnfuabd_Eqnyxcc_W_R0ooa
		"LINEAR     [-2147483648.000000, 80000000H] [2147483647.000000, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"W"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/begin COMPU_METHOD
		kFnyEcd_FayFsbb_lCDrlsa_n__a80a
		"LINEAR     [0.000000, 0H] [31.999512, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 2048 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/begin COMPU_METHOD
		kcAgawb_cszkxob_ykbdhoa_l_Ra0oa
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"l"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		kduCaCc_Betpetb_Bxwtdqa_nA_00a0
		"LINEAR     [0.000000, 0H] [0.00065535, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin COMPU_METHOD
		kfEbEnc_fogmuta_Bagagzb_g__100a
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"g"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		kjzsutd_yxyjdkb_ntFiggc_A_a866a
		"LINEAR     [0.000000, 0H] [12.036000, FFH]"
		RAT_FUNC
		"%6.3"
		"A"
    COEFFS 0 21.1864406779661 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		kmtvsEa_tEilDdc_jbmwFrb_n_99870
		"LINEAR     [-2147.483648, 80000000H] [2147.483647, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 999999.99999999825 -2.9802322387695312E-07 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		kremkzb_Burolsd_Ffjrdrc_p___00a
		"LINEAR     [0.000000, 0H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"ppm"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		kscodEd_uiEnjvd_Eqvyxyd_J_R0ooa
		"LINEAR     [0.000000, 0H] [32767.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J"
    COEFFS 0 2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		kujzEba_zFBxDqa_wAFgmib_Jp__20a
		"LINEAR     [0.000000, 0H] [3276.750000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/Kg/K"
    COEFFS 0 20 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin COMPU_METHOD
		kwurkla_ttkCtib_tonninb_1aC_1a0
		"LINEAR______0_000000__0H___1_000000__3E8H_"
		RAT_FUNC
		"%6.3"
		"1/(% s)"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin COMPU_METHOD
		kwzBeob_ebfpBdd_lmndEeb_Wa__10a
		"LINEAR     [0.000000, 0H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/Bar"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		kybEEsb_fcjzqub_saFowBd_n_ao66a
		"LINEAR     [0.000000, 0H] [9.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 7281.666666666667 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		lAFjxCa_eiyjaxb_Eqnyxqd_N_R0ooa
		"LINEAR     [-32768.000000, 8000H] [32767.000000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"N"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/begin COMPU_METHOD
		lDsheqa_jsDlsDa_ABgqofd_mnCRa0a
		"LINEAR______0_000000__0H___6000_0000__1770H_"
		RAT_FUNC
		"%6.3"
		"m^(-4)"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		lFmDDfb_EFFzjta_ysimAea_W__000a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/K"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		lasreaa_cardnzb_hCDtpsa_n__a00a
		"LINEAR     [-32.768000, 8000H] [32.767000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		lcBkDsb_aCkdnbd_Eqnyxyd_J_R0ooa
		"LINEAR     [0.000000, 0H] [4294967295.000000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"J"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : From 'inpcidls.xml' */
/begin COMPU_METHOD
		lfldkha_AFwjwnb_tkAxmyc_n_sfsnx
		"CNT_INDICATORS"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF lfldkha_AFwjwnb_tkAxmyc_n_sfsnx_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		lhizBec_Egvjjka_qDAiwFa_mpk_10a
		"LINEAR______0_000000__0H___0_655350__FFFFH_"
		RAT_FUNC
		"%6.3"
		"mg/°C/s/stk"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		lkejytd_cutavkd_xfybptd_nA_0a0a
		"LINEAR     [-1.000000, 0H] [1.000000, 7D0H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1000 1000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		llaAkia_mlcicDa_bdBfbsd_N__400a
		"LINEAR     [0.000000, 0H] [6375.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"N"
    COEFFS 0 0.04 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/begin COMPU_METHOD
		lnarxkb_nEFqnga_vinBdFa_roCR2a0
		"LINEAR______0_000000__0H___1_000000__FFH_"
		RAT_FUNC
		"%6.3"
		"ratio/s"
    COEFFS 0 255 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/begin COMPU_METHOD
		lthgvjd_avbcmnd_vDEmpCc_khA_10a
		"LINEAR     [0.000000, 0H] [25.500000, FFH]"
		RAT_FUNC
		"%6.3"
		"km/h"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		ltluECa_kDentwc_ulilrCa_roA_50a
		"LINEAR     [0.000000, 0H] [1.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"ratio"
    COEFFS 0 255 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		ltvDhsb_dlbBqsd_CwvACca_n_7a150
		"LINEAR     [-100.00000000, 80000000H] ]100.00000000, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 21474836.48 -2.384185791015625E-07 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin COMPU_METHOD
		lvAAcdc_BCAqbxd_kCDnrhc_m__000a
		"LINEAR     [-32.768, 8000H] [32.767, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"m/s"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		lvbmsEd_FDwmfxd_cgBjbwc_gCRa0a0
		"LINEAR     [0.000000, 0H] [0.655350, FFFFH]"
		RAT_FUNC
		"%6.3"
		"g/s"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		lxAelrc_vppcEuc_udFlEud_Jo__00a
		"LINEAR     [0.000000, 0H] [655350, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/mol"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		"LINEAR     [-32768.000000, 8000H] [32767.000000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"rpm/s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciacc.xml' */
/begin COMPU_METHOD
		mbowslc_inojbha_jnBnagc_N__010a
		"LINEAR_______20000_000000__0H___111068_000000__FFFEH_"
		RAT_FUNC
		"%6.3"
		"N"
    COEFFS 0 0.5 10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/begin COMPU_METHOD
		mdsqBzb_nhvunBc_cgBrBwc_k__00a0
		"LINEAR______0_000000__0H___0_65535__FFFFH_"
		RAT_FUNC
		"%6.3"
		"kg/s"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/begin COMPU_METHOD
		minmsna_wwxggtb_BagawBb_s__100a
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		mjxFltb_kfnvCoc_mCDcAhb_B__020a
		"LINEAR     [0.000000, 0H] [1.000000, 400H]"
		RAT_FUNC
		"%6.3"
		"[-]"
    COEFFS 0 1024 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : From 'dgdftmng.xml' */
/begin COMPU_METHOD
		mlnqhha_zmkpBDa_BftlAdc__db43yt
		"FM_RANGE_DIAG_INST"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF mlnqhha_zmkpBDa_BftlAdc__db43yt_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/begin COMPU_METHOD
		mmvArna_CeqzsCd_pqnbneb_n__630a
		"LINEAR     [0.000000, 0H] [1.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 65535 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		mnixaaa_usxmaed_caprCsd_m__10a0
		"LINEAR______0_000000__0H___0_0065535__FFFFH_"
		RAT_FUNC
		"%6.3"
		"m²"
    COEFFS 0 10000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		movAqed_DtteCgd_cloonha_Bh__10a
		"LINEAR______0_000000__0H___2000_000000__4E20H_"
		RAT_FUNC
		"%6.3"
		"[m3/h]"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin COMPU_METHOD
		mpFohEb_Frujlnd_kyyCsbc_BssA020
		"LINEAR     [0.000000, 0H] [-327675.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"[(mg/stk)/s]"
    COEFFS 0 -0.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		msaFcCa_agEEzEd_bfCiAsb_Jp__1a0
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/Kg/K"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		muDnEvb_EDdacoc_Fqvzxwb_n_R0ooa
		"LINEAR     [0.000000, 0H] [4.000000, 18H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 6 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		nBjwgbd_shAlvca_ldEgbrc_kC_0ooa
		"LINEAR     [450, 2DH] [3000, 12CH]"
		RAT_FUNC
		"%6.3"
		"kg"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		"LINEAR     [0.000000, 0H] [65.5350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin COMPU_METHOD
		nCzokha_cokgekd_myezmBc_hisA_a0
		"LINEAR     [0.000000, 0H] [65535.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"hPa/(kg/s)"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin COMPU_METHOD
		nDnAyEb_bxrhond_dDvivfa_hE__a0a
		"LINEAR     [0.000000, 0H] [4294967295.000000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"hPa^2"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		"LINEAR     [0.000000, 0H] [255.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"kPa"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/begin COMPU_METHOD
		ndajtgd_xAaAgAa_fzzApva_mt__0a0
		"LINEAR______0_000000__0H___429496_729500__FFFFFFFFH_"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin COMPU_METHOD
		ndwztoc_dvutqfb_rggeqyd_m__1o0a
		"LINEAR     [0.500000, 0H] [3.050000, FFH]"
		RAT_FUNC
		"%6.3"
		"m"
    COEFFS 0 100 -50 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : From 'dgdftmng.xml' */
/begin COMPU_METHOD
		nesxhqd_lCemnod_hfytbqc_n__MENM
		"RANGE     [COMPLETE, 0H, 0H] [NO_COMPLETE, 1H, 1H]"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF nesxhqd_lCemnod_hfytbqc_n__MENM_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : From 'atpftmng.xml' */
/begin COMPU_METHOD
		nngBqjb_bunueAa_okABDAa_nft_Nc_
		"STATUS_PFT_LOAD_SPD"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF nngBqjb_bunueAa_okABDAa_nft_Nc__VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : From 'atpftmng.xml' */
/begin COMPU_METHOD
		nqbBDkb_olADjia_huaouid_nd_xpr_
		"RANGE_STATUS_PFT_STT_RGN"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF nqbBDkb_olADjia_huaouid_nd_xpr__VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin COMPU_METHOD
		nqdxfta_EBcDtra_yuqaAka_cCR020a
		"LINEAR     [-60.000000, F1H] [60.000000, FH]"
		RAT_FUNC
		"%6.3"
		"cm"
    COEFFS 0 0.25 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		nrailqb_DCAAqvc_zltBgmb_mt__0a0
		"LINEAR_______2147483_6480___80000000H___2147483_6470___7FFFFFFFH_"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		nsFDDzd_bbvtgna_EqfAxwb_m_R0ooa
		"LINEAR     [0.000000, 0H] [8191.875000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"m"
    COEFFS 0 8 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin COMPU_METHOD
		obckiAc_Dodygqd_swoAikd_1aCR1a0
		"LINEAR______0_000000__0H___10_000000__3E8H_"
		RAT_FUNC
		"%6.3"
		"1/(V s)"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		ocDmywc_qhEsmjc_aAEjCea_rp__a0a
		"LINEAR     [-8192.000000, 8000H] [8191.750000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"rpm/s"
    COEFFS 0 4 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		oiuonjc_ndkeimc_Fgshlla_PCRa0a0
		"LINEAR     [0.000000, 0H] [0.065535, FFFFH]"
		RAT_FUNC
		"%6.3"
		"PaS"
    COEFFS 0 1000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		ojffuka_nfDmsmd_ysgmwha_L__000a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"L/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin COMPU_METHOD
		omqfgpc_fbAwBcc_yctdhkb_f_Ra0oa
		"LINEAR     [0.000000, 0H] [1.250000, 3E8H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 800 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		ophrhBc_punivya_jtmurnb_g__005a
		"LINEAR     [-0.150000, 0H] [0.350000, FAH]"
		RAT_FUNC
		"%6.3"
		"g/km"
    COEFFS 0 500 75 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		oulzEua_dFqvdub_ocphcBc_hp__00a
		"LINEAR     [-327680.000000, FFFF8000H] [327670.000000, FFFF7FFFH]"
		RAT_FUNC
		"%6.3"
		"hPa/s"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		oztfsAd_CwctBpb_rFDnrpa_1__000a
		"LINEAR     [-327.675000, FFFFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 -200 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/begin COMPU_METHOD
		pCFAdab_ECDfnCb_dAegbrc_s_R01oa
		"LINEAR     [0.000000, 0H] [2550.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin COMPU_METHOD
		pEmaegc_clacCDa_mtFteua_roCRa0a
		"LINEAR______0_000000__0H___1_000000__8H_"
		RAT_FUNC
		"%6.3"
		"ratio/s"
    COEFFS 0 8 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		pbxrrcb_uxwdEfd_uEzojfd_Bs__n0a
		"LINEAR     [-65535.000000, 1FFFEH] [-0.500000, 1H]"
		RAT_FUNC
		"%6.3"
		"[%/s]"
    COEFFS 0 -2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin COMPU_METHOD
		phvmFbd_piFuvyc_ADhtvrd_BsDA020
		"LINEAR     [0.000000, 0H] [175000.000000, 88B8H]"
		RAT_FUNC
		"%6.3"
		"[mg/stk/s]"
    COEFFS 0 0.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin COMPU_METHOD
		pikndba_Biezwsc_vivAhda_roCR5a0
		"LINEAR     [-64.000000, 8000H] [63.998047, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"ratio/s"
    COEFFS 0 512 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin COMPU_METHOD
		pirDzDd_ruawDDa_Fqnyxgb_f_R0ooa
		"LINEAR     [0.000000, 0H] [1.000000, 1H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		pkbodxb_tneCdBc_Altqqhc_WKA_0a0
		"LINEAR     [0.000000, 0H] [65.535000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/m/K"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin COMPU_METHOD
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		"LINEAR     [0.000000, 0H] [2000.000000, 4E20H]"
		RAT_FUNC
		"%6.3"
		"m³/h"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		prgtCkd_krawoFb_tmjbqrb_f__no0a
		"LINEAR     [0.000000, 0H] [-100.000000, 800H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 -20.48 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin COMPU_METHOD
		pvnjhxa_sDyoeeb_yAhnhea_1__050a
		"LINEAR     [0.000000, 0H] [1.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"1/V"
    COEFFS 0 255 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		pycplga_CrspAEb_wagastd_mCRa00a
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"m²"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		"ECME_LINEAR     [0.000000, 0H] [4294967295.000000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin COMPU_METHOD
		qAywpeb_ydDurwc_FDrBuAb_1__a0a0
		"LINEAR     [0.000000, 0H] [0.0655, FFDCH]"
		RAT_FUNC
		"%6.3"
		"1/ %"
    COEFFS 0 1000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		qDDtqcc_gayxvEc_qlEivjc_s__200a
		"LINEAR     [0.000000, 0H] [0.127998, FFFFH]"
		RAT_FUNC
		"%6.3"
		"s/rpm"
    COEFFS 0 512000.00000000012 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		qaiFpgc_CavDEdd_guApbcb_n__100a
		"LINEAR     [0.000000, 0H] [52428800.000000, 80000H]"
		RAT_FUNC
		"%6.3"
		"ns"
    COEFFS 0 0.01 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		qdcqsea_afuttza_asCBCea_rp__a0a
		"LINEAR     [0.000000, 0H] [31.875, FFH]"
		RAT_FUNC
		"%6.3"
		"rad/s"
    COEFFS 0 8 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin COMPU_METHOD
		qdgunob_kBlEwyb_bgBrBgd_k__00a0
		"LINEAR______0._00000__0H___0._55350__FFFFH_"
		RAT_FUNC
		"%6.3"
		"kg/h"
    COEFFS 0 100000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin COMPU_METHOD
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		"LINEAR______0_000000__0H___1_250000__3E8H_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 800 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		qkkoDkb_kntECeb_txbcghc_qKA_50a
		"LINEAR     [-655.360000, 8000H] [655.340000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"°CRK"
    COEFFS 0 50 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		qmxjsqc_pfyberd_Fwnmela_mCRa0a0
		"LINEAR______0_000000__0H___0_004000__FA0H_"
		RAT_FUNC
		"%6.3"
		"m^3"
    COEFFS 0 1000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : From 'cmmuxser.xml' */
/begin COMPU_METHOD
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		"STATUS_OK_NOK_FAIL"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF qoqFqhc_FAxzcac_irphkFc__0v1v_l_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		qtjmexb_FBfzDca_xekCpbb_n_79580
		"LINEAR     [-25.000000, 8000H] [24.999237, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1310.7199999999989 -1.455191522836685E-11 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		"LINEAR     [-1.000000, 0H] [6.000000, 7H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1 1 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		rEBznhd_Dkorjta_Aqgesjb_1CC_1o0
		"LINEAR     [0.000000, 0H] [3.000000, 7530H]"
		RAT_FUNC
		"%6.3"
		"1/(°C*s)"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin COMPU_METHOD
		rErCnwa_xcoFdya_Bqeaoqb_n__400a
		"LINEAR     [0.000000, 0H] [1.000000, 9C40H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 40000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		rbbElwb_afouokc_ysgmcia_1__000a
		"LINEAR     [0.000000, 0H] [100.000000, 2710H]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		rblEeyb_zFoAatd_ouFadBc_hk__10a
		"LINEAR     [0.000000, 0H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"hPa*s"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/begin COMPU_METHOD
		rcfmwFb_alBjDuc_nEjjqEb_mPKR10a
		"LINEAR_______0_000000_0H___0_04__9C40H_"
		RAT_FUNC
		"%6.3"
		"m^3*kPa/kgK"
    COEFFS 0 1000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin COMPU_METHOD
		rjeccdd_jblzjsb_kBFllma_B2DA010
		"LINEAR     [-327680.000000, FFFF8000H] [327670.000000, FFFF7FFFH]"
		RAT_FUNC
		"%6.3"
		"[hPa2s/Kg]"
    COEFFS 0 0.1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin COMPU_METHOD
		rkcmmwd_dnCngmd_ycnokbb_B__000a
		"LINEAR     [0.000000, 0H] [1.000000, 320H]"
		RAT_FUNC
		"%6.3"
		"[-]"
    COEFFS 0 800 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin COMPU_METHOD
		rmrnjea_mqkhdia_FFkBoda_Bpp__20
		"LINEAR     [0.000000, 0H] [250000.000000, C350H]"
		RAT_FUNC
		"%6.3"
		"[(mg/stk)/s]"
    COEFFS 0 0.2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin COMPU_METHOD
		ryhzxDd_bDsnzFa_Ehryxwb_r_A_1oa
		"LINEAR______0._00000__0H___8160._00000__1FE0H_"
		RAT_FUNC
		"%6.3"
		"rpm"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		rzcztbb_Agrdkud_Abvlbcc_s__300a
		"LINEAR     [0.000000, 0H] [1.000000, 4C4B4H]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 312500 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : From 'inpcidls.xml' */
/begin COMPU_METHOD
		rzlnwjb_BlbxuAc_tkosmyc___xfxnx
		"CNT_INDICATORS"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF rzlnwjb_BlbxuAc_tkosmyc___xfxnx_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		rztfjja_pbzmqrc_mjoCkta_qC_666a
		"LINEAR     [0.000000, 0H] [1535.625000, FFFH]"
		RAT_FUNC
		"%6.3"
		"°CRK"
    COEFFS 0 2.666666666666667 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		"LINEAR     [-8192.000000, 8000H] [8191.750000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"Pa"
    COEFFS 0 4 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin COMPU_METHOD
		sBxEEjc_FDsdgfc_lunhtFd_WCRana0
		"LINEAR     [0.000000, 0H] [10200.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"W/s"
    COEFFS 0 0.025 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/begin COMPU_METHOD
		sDwtuec_riAActa_vnpvdDd_ri__50a
		"LINEAR______0_000000__0H___5_100000__FFH_"
		RAT_FUNC
		"%6.3"
		"ratio"
    COEFFS 0 50 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin COMPU_METHOD
		sEbiphc_khwCxaa_dCoqdrc_1___20a
		"LINEAR     [0.000000, 0H] [2047.968750, FFFFH]"
		RAT_FUNC
		"%6.3"
		"1/s"
    COEFFS 0 32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin COMPU_METHOD
		sFdchsc_zykwhra_iCEAEDa_q_16012
		"LINEAR     [-3276.80000, 8000H] [3276.70000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"°C"
    COEFFS 0 10 3.637978807091713E-12 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/begin COMPU_METHOD
		saAcdba_dmCvrqc_nuuwjCd_Np__2a0
		"LINEAR______0_000000__0H___1_000000__FFH_"
		RAT_FUNC
		"%6.3"
		"Nm/rpm"
    COEFFS 0 255 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/begin COMPU_METHOD
		sdFCuzd_Bbcpwsd_kxphmtc_n_99o55
		"LINEAR     [-25.00000000, 80000000H] ]25.00000000, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 85899345.899999946 0.49999856948852539 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : From 'cmmuxser.xml' */
/begin COMPU_METHOD
		sdjirsa_kAEhhma_hlsAEfc_n_q_ors
		"STATUS_TQ_REQ_ASR_MSR"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF sdjirsa_kAEhhma_hlsAEfc_n_q_ors_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/begin COMPU_METHOD
		sdzrpaa_EjytFlb_Fqnyxxb_n_R0ooa
		"LINEAR     [-2.000000, 0H] [253.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1 2 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin COMPU_METHOD
		sfFnwyd_yegllwb_EkCmhyd_m__000a
		"LINEAR     [-12.000000, FFFF8AD0H] [13.500000, 83D6H]"
		RAT_FUNC
		"%6.3"
		"m/s²"
    COEFFS 0 2500 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin COMPU_METHOD
		skzzggb_gryEsta_lpfamqd_n__420a
		"LINEAR     [-5000.000000, 0H] [5000.000000, 9C40H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 4 20000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		ssmsCyb_aqdraka_rwvlbwb_N__300a
		"LINEAR     [-6710.888640, 80000000H] [6710.886397, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm"
    COEFFS 0 320000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		"ENSD_LINEAR     [0.000000, 0H] [16383.750000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"rpm"
    COEFFS 0 4 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin COMPU_METHOD
		tClffab_hirDflc_mxtqjrd_mtA_o00
		"LINEAR_______3000_0__0H___3000_0__EA60H_"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 10 30000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		tdkuuvc_hyypuEb_FBkqozb_JpA_o00
		"LINEAR     [600.000000, 0H] [1200.000000, 1770H]"
		RAT_FUNC
		"%6.3"
		"J/Kg/K"
    COEFFS 0 10 -6000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/* RSA::SAXHandler : From 'outqotqd.xml' */
/begin COMPU_METHOD
		thpfgAb_auenodc_jygDerb_nNmt_r_
		"RANGE_STATUS_TORQUE_REQ"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF thpfgAb_auenodc_jygDerb_nNmt_r__VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		tiDjFvd_EcbAuFb_jkpfdhc_qvA_00a
		"LINEAR     [0.000000, 0H] [510.00000, FFH]"
		RAT_FUNC
		"%6.3"
		"°C/v"
    COEFFS 0 0.5 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/begin COMPU_METHOD
		tjaueDb_oDycymc_yApmcia_1__000a
		"LINEAR______0_000000__0H___10_000000__3E8H_"
		RAT_FUNC
		"%6.3"
		"1/V"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		"LINEAR     [-100.000000, 0H] [99.218750, FFH]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 1.28 128 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		tlquvwc_clelwCd_hCDzbFa_kCRa00a
		"LINEAR     [0.000000, 0H] [65.5350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"kg"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		tqfnykb_zrjpzpb_cvihkvb_gC_o00a
		"LINEAR     [0.002000, 0H] [0.350000, AEH]"
		RAT_FUNC
		"%6.3"
		"g/km"
    COEFFS 0 500.00000000000011 -1 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		tupwpzd_utsbzzc_twxawbc_g__1a0a
		"LINEAR     [-250.000000, 0H] [250.000000, 1388H]"
		RAT_FUNC
		"%6.3"
		"g"
    COEFFS 0 10 2500 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		tysfkbc_CCoqjod_hCDmFFa_mCRa00a
		"LINEAR     [0.000000, 0H] [65.5350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"m²"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : From 'atpftdgn.xml' */
/begin COMPU_METHOD
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		"STATUS_OK_NOK"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF uADawDa_nypsEha_DoCvmhd_n2_l_Nd_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		uAwArwa_iohEDEc_mwmdljb_BDA0a70
		"LINEAR     [-65535.000000, 0H] [0, 1FFFEH]"
		RAT_FUNC
		"%6.3"
		"[%/s]"
    COEFFS 0 2 131070 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		uBFsuAd_hvfAplb_zlBDusd_NrC_1a0
		"LINEAR     [0.000000, 0H] [7.999023, 1FFFH]"
		RAT_FUNC
		"%6.3"
		"Nms/rpm"
    COEFFS 0 1024 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/begin COMPU_METHOD
		uECeoAd_nhBifyd_rgxnmhd_NsA_o0a
		"LINEAR     [0.000000, 0H] [102398.437500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 0.64 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		uEardjb_BFoibqb_vkamstb_khA_00a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"km/h"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		uEcbCDc_nzlAlac_khropnb_N_99950
		"LINEAR     [-6710.888640, 80000000H] [6710.886397, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm"
    COEFFS 0 319999.99999999988 -5.9604644775390625E-08 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		uaDvdca_kagFetc_ysAczca_f_Ra5oa
		"LINEAR     [0.000000, 0H] [25599.609375, FFFFH]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 2.56 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/begin COMPU_METHOD
		ubEjivd_uBtFlld_DxedwDb_1__00a0
		"LINEAR     [0.000000, 0H] [3.000000, 7530H]"
		RAT_FUNC
		"%6.3"
		"1/°C"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/begin COMPU_METHOD
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		"LINEAR     [-200.000000, 31E0H] [200.000000, CE20H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 100 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		uiCvdna_rwescla_FnrCuAa_NpA_250
		"LINEAR     [-0.100000, 0H] [12.699804, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm/rpm"
    COEFFS 0 5120 512 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		uigFmsb_clgegnc_Dirukid_fP_R1o0
		"LINEAR     [0.000000, 0H] [4.000000, 9C40H]"
		RAT_FUNC
		"%6.3"
		"%/(hPa*s)"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/begin COMPU_METHOD
		ukaFaob_gpvwbEc_yoadzoa_n_Ra2oa
		"LINEAR     [0.000000, 0H] [51199.218750, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1.28 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/begin COMPU_METHOD
		umakcCa_opladyb_qkxtEDd_BC_1o00
		"LINEAR_______1_000000__0H___1_000000__4E20H_"
		RAT_FUNC
		"%6.3"
		"[-]"
    COEFFS 0 10000 10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		umuqzbb_erxywEd_fpyrnod_KA_0n00
		"LINEAR     [233.000000, 0H] [1473.000000, 12EBC0H]"
		RAT_FUNC
		"%6.3"
		"K"
    COEFFS 0 1000 -233000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/begin COMPU_METHOD
		uoEAvgd_fvDEfeb_yuaecca_n_Raooa
		"LINEAR     [0.000000, 0H] [10, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 25.5 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin COMPU_METHOD
		uobbrza_onEavnc_ryxBhwb_Ngj_ao0
		"LINEAR     [0.000000, 0H] [10.000000, 2710H]"
		RAT_FUNC
		"%6.3"
		"Nm/(mg/stk)"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		uqjDtCc_xwFEDpc_okvbgrc_nA_6a90
		"LINEAR     [0.500000, 0H] [4.499939, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 16384 -8192 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		urDAtDb_lBAgnob_yDjBhub_JpA0o00
		"LINEAR     [1000.000000, 0H] [1200.000000, 7D0H]"
		RAT_FUNC
		"%6.3"
		"J/Kg/K"
    COEFFS 0 10 -10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/begin COMPU_METHOD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		"LINEAR     [-65535.000000, FFFFH] [0, 0H]"
		RAT_FUNC
		"%6.3"
		"rpm/s"
    COEFFS 0 -1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : From 'dgdftmng.xml' */
/begin COMPU_METHOD
		utCpcna_olpdfvb_iFvAkza_nC___01
		"RANGE     [0, 0H, 0H] [1, 1H, 1H]"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF utCpcna_olpdfvb_iFvAkza_nC___01_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : From 'cmmuxser.xml' */
/begin COMPU_METHOD
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l
		"STATUS_CAN_MSG"
		TAB_VERB
		"%6.3"
		""
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF uvuyAtd_vhgEiaa_gbFndcd___s1_2l_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		uwmooFc_Fyanpma_qwqkdEc_n_39540
		"LINEAR     [-25.000000, 80000000H] [24.999999, 7FFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 85899345.919999957 -9.5367431640625E-07 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		uxdoaqa_BznFwjc_okphcBc_hp__00a
		"LINEAR     [2.000000, 1H] [100000.000000, C350H]"
		RAT_FUNC
		"%6.3"
		"hPa/s"
    COEFFS 0 0.5 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin COMPU_METHOD
		uyBAbnb_eDphqCd_pzdqjvd_mtA_o70
		"LINEAR     [-3276.800000, 0H] [3276.700000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 10 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/begin COMPU_METHOD
		uyoDvwa_FycErrc_bzelawd_N__310a
		"LINEAR     [-400.000000, 0H] [1647.96875, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm"
    COEFFS 0 32 12800 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		uztFExb_owBhqra_ykamwda_l__000a
		"LINEAR     [0.000000, 0H] [100.000000, 2710H]"
		RAT_FUNC
		"%6.3"
		"l/h"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		"LINEAR     [-40.000000, 0H] [200.000000, 960H]"
		RAT_FUNC
		"%6.3"
		"°C"
    COEFFS 0 10 400 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/begin COMPU_METHOD
		vemczAb_reFdrlb_hCftnsa_n__a30a
		"LINEAR______0._00000__0H___1._00000__3FFH_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1023 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin COMPU_METHOD
		vfeacpa_aoflexb_dCifcCa_WBA119o
		"LINEAR     [0.000000, 0H] [4.9999237060546875, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/rpm/Bar"
    COEFFS 0 13107.19999999999 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin COMPU_METHOD
		vjoyynb_ojdvbhc_fdvbarc__A_aooa
		"LINEAR     [0.000000, 0H] [429496729.500000, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		""
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin COMPU_METHOD
		vtyvFka_akFtnud_rnCproc_n__1a0a
		"LINEAR     [-10.000000, 0H] [200.000000, 5208H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100 1000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/begin COMPU_METHOD
		vvxxxvb_xwaqtrc_Cgvyxia_b_A_1oa
		"LINEAR     [0.000000, 0H] [4500, 1194H]"
		RAT_FUNC
		"%6.3"
		"bar"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin COMPU_METHOD
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		"LINEAR______0_000000__00H___1200_000000__2EE0H_"
		RAT_FUNC
		"%6.3"
		"°C"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		vwnzpdd_tusDwnc_yeBhlaa_T__0o0a
		"LINEAR     [0.000000, 0H] [1020.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"TDC"
    COEFFS 0 0.25 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin COMPU_METHOD
		wCxComb_nadiaac_aAowvka_NsA_20a
		"LINEAR     [0.000000, 0H] [127.500000, FFH]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 2 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		wEhhyja_Axxgvcd_eexoyBd_m3A_00a
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"mg/m3"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/begin COMPU_METHOD
		wijukob_vbAeApa_hCDsnsa_n__a40a
		"LINEAR______0._00000__0H___2._00000__800H_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 1024 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/begin COMPU_METHOD
		wmkbkad_wwidqld_lsCArsa_f__a40a
		"LINEAR     [0.000000, 0H] [100.000000, 801H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 20.49 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		wmkdrfc_obthmla_Efhawmc_JCRa00a
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/K"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		wplABcb_oudlxCc_nrbwooc_n_ao33a
		"LINEAR     [0.000000, 0H] [29.999542, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 2184.5333333333351 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/begin COMPU_METHOD
		wtkCiEa_ekAonmb_Erxavpb_vCRa38a
		"LINEAR_______32768_000000__0H___32767_000000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"µs"
    COEFFS 0 1 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/begin COMPU_METHOD
		wvjbzud_wnqzgwd_bAahjmd_n_39695
		"LINEAR     [0.666666, 0H] [1.333323, FFFFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 98303.999999999258 -65535.993446399509 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		"LINEAR     [-40.000000, 0H] [160.000000, C8H]"
		RAT_FUNC
		"%6.3"
		"°C"
    COEFFS 0 1 40 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		wygbdBb_nhzhruc_ycrdhca_n_Ra0oa
		"LINEAR     [0.000000, 0H] [4.000000, 320H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 200 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/begin COMPU_METHOD
		wzddcwc_BwcCemc_Fbfbcrc_n_R0ooa
		"LINEAR     [-1.000000, E0H] [1.000000, 20H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		xBBsjld_iAhBsha_ycnokja_B__000a
		"LINEAR     [-163.840000, 8000H] [163.835000, 7FFFH]"
		RAT_FUNC
		"%6.3"
		"[-]"
    COEFFS 0 200 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/begin COMPU_METHOD
		xbqgAic_iekFyac_DialEla_f_a999a
		"LINEAR     [0.000000, 0H] [4294.967295, FFFFFFFFH]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 999999.99999999988 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		xdBqnAa_fmFFrja_Dkxfxyb_Np__1a0
		"LINEAR     [0.000000, 0H] [7.999878, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm/rpm"
    COEFFS 0 8192 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/begin COMPU_METHOD
		xgtCpnd_gszbitc_FbDberc_n_R0ooa
		"LINEAR     [0.000000, 0H] [5.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 51 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/begin COMPU_METHOD
		xhkomjb_oEsFhsa_hslCgmd_1C_522a
		"LINEAR     [0.000000, 0H] [1953.1,7FFFH]"
		RAT_FUNC
		"%6.3"
		"1/s²"
    COEFFS 0 33.554432000782768 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin COMPU_METHOD
		xjpwlzd_oiewmrb_devberc_s_R0ooa
		"LINEAR     [0.000000, 00H] [5.100000, FFH]"
		RAT_FUNC
		"%6.3"
		"s"
    COEFFS 0 50 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		"LINEAR     [0.000000, 0H] [100.000000, 3E8H]"
		RAT_FUNC
		"%6.3"
		"g"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/begin COMPU_METHOD
		xmoyqad_zuxgeuc_aAwwvka_NsA_10a
		"LINEAR     [0.000000, 0H] [255.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin COMPU_METHOD
		xpgjDwb_wDebpEb_ulakuqa_roA_00a
		"LINEAR______0_000000__0H___2_550000__FFH_"
		RAT_FUNC
		"%6.3"
		"ratio"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin COMPU_METHOD
		xrnmuaa_rEFCrod_vifAgta_roCR1a0
		"LINEAR______0_000000__0H___655_350000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"ratio/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/begin COMPU_METHOD
		xtpgvBa_feuvdca_zFDnrdb_s__000a
		"LINEAR     [-655.350000, FFFFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"s/s"
    COEFFS 0 -100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		xuCdrCc_xlEAFsd_fCEjphd_q__0o0a
		"LINEAR_______25_000000__0H___0_000000__FAH_"
		RAT_FUNC
		"%6.3"
		"°C/s"
    COEFFS 0 10 250 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/begin COMPU_METHOD
		xwqvgta_Fpebsfa_ysaecca_n_Raooa
		"LINEAR______0_000000__0H___9_960937__FFH_"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 25.6 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin COMPU_METHOD
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		"LINEAR______0_000000__0H___100_000000__800H_"
		RAT_FUNC
		"%6.3"
		"%Vsens"
    COEFFS 0 20.48 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/begin COMPU_METHOD
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		"LINEAR     [0.000000, 0H] [100.000000, FFH]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 2.55 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		"LINEAR     [233.000000, 0H] [1473.000000, 3070H]"
		RAT_FUNC
		"%6.3"
		"K"
    COEFFS 0 10 -2330 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		"LINEAR     [0.000000, 0H] [1.000000, 64H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		ydcnqBd_xAtpyCa_aAbyxwb_1_A_1oa
		"LINEAR     [0.000000, 0H] [65535.000000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"1/m"
    COEFFS 0 1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin COMPU_METHOD
		yeeojyb_qFtgBBa_upakrld_Bs2_a0a
		"LINEAR     [-32768000.000000, FFFF8000H] [32767000.000000, FFFF7FFFH]"
		RAT_FUNC
		"%6.3"
		"[hPa2s2/Kg2]"
    COEFFS 0 0.001 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		yiElrDb_aknicqc_ADFwaxb_WkC_00o
		"LINEAR     [0.000000, 0H] [0.00000065535, FFFFH]"
		RAT_FUNC
		"%6.3"
		"W/(m^2*K^4)"
    COEFFS 0 100000000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		ykmzBoa_nqupBma_Ffvbarc_m_R0ooa
		"LINEAR     [0.000000, 0H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"m"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		ykuBijd_yAhnlEa_ffapzdb_ih_Raa0
		"LINEAR     [0.000000, 0H] [655.350000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"(m³/h)/s"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin COMPU_METHOD
		yuEqExb_buwnyAb_Fbvbdrc_n_R0ooa
		"LINEAR     [0.000000, 0H] [1.000000, 14H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 20 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		yukbljb_yACsEga_BkCnrhd_m__000a
		"LINEAR     [0.000000, 0H] [65.535000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"mg/s"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/begin COMPU_METHOD
		yvyupqb_iFBfdid_awzApyb_kE__0a0
		"LINEAR______0_000000__0H___5_00000__C350H_"
		RAT_FUNC
		"%6.3"
		"kg/m^3"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		yxobnfa_FlrsAhb_sEheatb_n__1o7a
		"LINEAR     [-1.27, 0H] [1.27, FEH]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 100 127 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/begin COMPU_METHOD
		zACxkkc_ssivyfc_azzAlyb_kE__0a0
		"LINEAR     [0.000000, 0H] [6.553500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"kg/s^2"
    COEFFS 0 10000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/begin COMPU_METHOD
		zBkCrcc_hurzhhc_julDphb_ip1__0a
		"LINEAR     [0.000000, 0H] [1.000000, 3E8H]"
		RAT_FUNC
		"%6.3"
		"(Nm/rpm)^(1/2)"
    COEFFS 0 1000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		"LINEAR     [-100.000000, 0H] [100.000000, 1000H]"
		RAT_FUNC
		"%6.3"
		"%"
    COEFFS 0 20.48 2048 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/begin COMPU_METHOD
		zDagvvb_eDdCjqb_ycnokfa_B__000a
		"LINEAR     [0.000000, 0H] [2.000000, C8H]"
		RAT_FUNC
		"%6.3"
		"[-]"
    COEFFS 0 100 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/begin COMPU_METHOD
		zaiesxc_pDtfwqc_lixtcqc_nA_0a00
		"LINEAR      [-1.000000,0H] [0.000000,2710H]"
		RAT_FUNC
		"%6.3"
		"-"
    COEFFS 0 10000 10000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		"LINEAR     [0.000000, 0H] [2047.968750, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm"
    COEFFS 0 32 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin COMPU_METHOD
		zbhcjic_qmhpFyc_chelcsd_N__338a
		"LINEAR     [-1024.000000, 0H] [1023.968750, FFFFH]"
		RAT_FUNC
		"%6.3"
		"Nm"
    COEFFS 0 32 32768 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'oucbofuo.xml' */
/begin COMPU_METHOD
		zdbvomb_zEuFced_rjyApva_mt__5a0
		"LINEAR______0_000000__0H___600_000000__E4E1C0H_"
		RAT_FUNC
		"%6.3"
		"mg/stk"
    COEFFS 0 25000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : From 'asegrctl.xml' */
/begin COMPU_METHOD
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		"STATUS_OK_NOK_FAIL_2_7"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF zdkvpcb_haoDnad_Ctrtujd_nn2N__i_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : From 'smisrctl.xml' */
/begin COMPU_METHOD
		zidvspc_fBftdda_rbmFAla_nssN_34
		"RANGE_STATE_IDLE_SPEED_REG"
		TAB_VERB
		"%6.3"
		"-"
	/* RSA::SAXHandler : Magically created */
    COMPU_TAB_REF zidvspc_fBftdda_rbmFAla_nssN_34_VTAB 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		zitsqmc_gxniCsc_dCEebrc_f___00a
		"LINEAR [0.100000, 1H] [6553.500000, FFFFH]"
		RAT_FUNC
		"%6.3"
		"%/s"
    COEFFS 0 10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/begin COMPU_METHOD
		zjDDbid_AAaguja_ulakuCa_roA_00a
		"LINEAR______0_000000__0H___327_675000__FFFFH_"
		RAT_FUNC
		"%6.3"
		"ratio"
    COEFFS 0 200 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/begin COMPU_METHOD
		zkbcymc_ixcjqia_ikunepd_ijp_a1a
		"LINEAR     [-10.000000, 0H] [200.000000, 5208H]"
		RAT_FUNC
		"%6.3"
		"(km/h)/K*rpm"
    COEFFS 0 100 1000 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/begin COMPU_METHOD
		zkjfeib_dzryiya_cCDvqxb_J__000a
		"LINEAR     [0.000000, 0H] [32.767500, FFFFH]"
		RAT_FUNC
		"%6.3"
		"J/K"
    COEFFS 0 2000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/begin COMPU_METHOD
		zlhAlxa_lflywEd_dCwmhyc_NsA_n0a
		"LINEAR     [-255.000000, FFH] [0.000000, 0H]"
		RAT_FUNC
		"%6.3"
		"Nm/s"
    COEFFS 0 -1 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/begin COMPU_METHOD
		zqyfxbd_bjFzFBd_nzzBAub_smA_3a0
		"LINEAR     [0.000000, 0H] [3.999938, FFFFH]"
		RAT_FUNC
		"%6.3"
		"s/rpm"
    COEFFS 0 16384 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin COMPU_METHOD
		zvldabd_plckxob_dwyrutb_k__00o0
		"LINEAR     [0.000000, 0H] [0.065535, 270FD8F0H]"
		RAT_FUNC
		"%6.3"
		"kg"
    COEFFS 0 10000000000 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin COMPU_METHOD
		zwgdwmb_haBEzgc_ysgmtAd_f__010a
		"LINEAR [-6553.500000, FFFFH] [-0.100000, 1H]"
		RAT_FUNC
		"%6.3"
		"%/s"
    COEFFS 0 -10 0 0 0 1 
/end COMPU_METHOD
/* RSA::SAXHandler : Magically created for 'BBkhydb_BopFqDa_zoqBvwc___s2ewx' */
/begin COMPU_VTAB
		BBkhydb_BopFqDa_zoqBvwc___s2ewx_VTAB
		"BBkhydb_BopFqDa_zoqBvwc___s2ewx_VTAB is required by BBkhydb_BopFqDa_zoqBvwc___s2ewx"
		TAB_VERB
		5
		1 "Nsx_pft_wait_req_stt_1" 
		2 "Nsx_pft_wait_req_stt_2" 
		3 "Nsx_pft_wait_req_stt_3" 
		4 "Nsx_pft_wait_req_stt_4" 
		5 "Nsx_pft_wait_req_stt_5" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd' */
/begin COMPU_VTAB
		Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd_VTAB
		"Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd_VTAB is required by Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd"
		TAB_VERB
		2
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'Brgjoob_bBymenb_rozDxfc_n1n2dax' */
/begin COMPU_VTAB
		Brgjoob_bBymenb_rozDxfc_n1n2dax_VTAB
		"Brgjoob_bBymenb_rozDxfc_n1n2dax_VTAB is required by Brgjoob_bBymenb_rozDxfc_n1n2dax"
		TAB_VERB
		3
		1 "Nsx_ant_neut" 
		2 "Nsx_ant_drag_red_agb" 
		3 "Nsx_ant_driv" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'Btazhnd_dbwbdEa_sBBrftd_n_l__bt' */
/begin COMPU_VTAB
		Btazhnd_dbwbdEa_sBBrftd_n_l__bt_VTAB
		"Btazhnd_dbwbdEa_sBBrftd_n_l__bt_VTAB is required by Btazhnd_dbwbdEa_sBBrftd_n_l__bt"
		TAB_VERB
		3
		0 "Nsx_stal_acs_ena" 
		1 "Nsx_stal_ac_ant_dsb" 
		2 "Nsx_stal_acs_dsb" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'DbqmAvc_FCazhwd_yFuDCFc_B3x__2l' */
/begin COMPU_VTAB
		DbqmAvc_FCazhwd_yFuDCFc_B3x__2l_VTAB
		"DbqmAvc_FCazhwd_yFuDCFc_B3x__2l_VTAB is required by DbqmAvc_FCazhwd_yFuDCFc_B3x__2l"
		TAB_VERB
		3
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_' */
/begin COMPU_VTAB
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1__VTAB
		"DpjnsAb_Ehtwufc_xFpuivb_B3xi_1__VTAB is required by DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_"
		TAB_VERB
		3
		0 "Nsx_tac_wait" 
		2 "Nsx_tac_end" 
		12 "Nsx_tac_abrt" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'EvAetkc_wufdhja_gbEzBsd______4p' */
/begin COMPU_VTAB
		EvAetkc_wufdhja_gbEzBsd______4p_VTAB
		"EvAetkc_wufdhja_gbEzBsd______4p_VTAB is required by EvAetkc_wufdhja_gbEzBsd______4p"
		TAB_VERB
		3
		1 "Nsx_brk_pdl_off" 
		2 "Nsx_brk_pdl_on" 
		4 "Nsx_brk_pdl_vld_on" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'RB_CONV_AtCatDgn_OBD_Status' */
/begin COMPU_VTAB
		RB_CONV_AtCatDgn_OBD_Status_VTAB
		"RB_CONV_AtCatDgn_OBD_Status_VTAB is required by RB_CONV_AtCatDgn_OBD_Status"
		TAB_VERB
		7
		0 "Nsx_ocd_init" 
		1 "Nsx_ocd_wait" 
		2 "Nsx_ocd_ofsad" 
		3 "Nsx_ocd_stab" 
		4 "Nsx_ocd_pi" 
		5 "Nsx_ocd_calculation" 
		6 "Nsx_ocd_end" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'RB_CONV_AtCatDgn_Vld_Status_2' */
/begin COMPU_VTAB
		RB_CONV_AtCatDgn_Vld_Status_2_VTAB
		"RB_CONV_AtCatDgn_Vld_Status_2_VTAB is required by RB_CONV_AtCatDgn_Vld_Status_2"
		TAB_VERB
		3
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'RB_CONV_AtCatDgn_bool' */
/begin COMPU_VTAB
		RB_CONV_AtCatDgn_bool_VTAB
		"RB_CONV_AtCatDgn_bool_VTAB is required by RB_CONV_AtCatDgn_bool"
		TAB_VERB
		2
		0 "0" 
		1 "1" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'RB_CONV_OuCboUeg_Vld_Status' */
/begin COMPU_VTAB
		RB_CONV_OuCboUeg_Vld_Status_VTAB
		"RB_CONV_OuCboUeg_Vld_Status_VTAB is required by RB_CONV_OuCboUeg_Vld_Status"
		TAB_VERB
		8
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
		3 "Nsx_vld_fail_3" 
		4 "Nsx_vld_fail_4" 
		5 "Nsx_vld_fail_5" 
		6 "Nsx_vld_fail_6" 
		7 "Nsx_vld_fail_7" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'RB_CONV_OuCboUeg_bool' */
/begin COMPU_VTAB
		RB_CONV_OuCboUeg_bool_VTAB
		"RB_CONV_OuCboUeg_bool_VTAB is required by RB_CONV_OuCboUeg_bool"
		TAB_VERB
		2
		0 "0" 
		1 "1" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'VA_Bool_ON_OFF' */
/begin COMPU_VTAB
		VA_Bool_ON_OFF_VTAB
		"VA_Bool_ON_OFF_VTAB is required by VA_Bool_ON_OFF"
		TAB_VERB
		2
		0 "OFF" 
		1 "ON" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf' */
/begin COMPU_VTAB
		ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf_VTAB
		"ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf_VTAB is required by ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf"
		TAB_VERB
		3
		0 "Nsx_pft_eng_nul" 
		1 "Nsx_pft_eng_cold" 
		2 "Nsx_pft_eng_med" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'cqvsmgd_egstFCa_yhphkFc_n_v0v2l' */
/begin COMPU_VTAB
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l_VTAB
		"cqvsmgd_egstFCa_yhphkFc_n_v0v2l_VTAB is required by cqvsmgd_egstFCa_yhphkFc_n_v0v2l"
		TAB_VERB
		3
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'crcpByb_qtnxvic_rzBrBqc_n0o_2ax' */
/begin COMPU_VTAB
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax_VTAB
		"crcpByb_qtnxvic_rzBrBqc_n0o_2ax_VTAB is required by crcpByb_qtnxvic_rzBrBqc_n0o_2ax"
		TAB_VERB
		4
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
		3 "Nsx_vld_fail_3" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'dBCtsuc_hqDqtlb_iowwora_n_1a__x' */
/begin COMPU_VTAB
		dBCtsuc_hqDqtlb_iowwora_n_1a__x_VTAB
		"dBCtsuc_hqDqtlb_iowwora_n_1a__x_VTAB is required by dBCtsuc_hqDqtlb_iowwora_n_1a__x"
		TAB_VERB
		5
		0 "Nsx_init_tco_fail" 
		1 "Nsx_wait_tco_fail" 
		10 "Nsx_inc_mdl" 
		20 "Nsx_no_inc_mdl" 
		30 "Nsx_no_inc_max_mdl" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'eDlybpa_szqqFga_puaotid___N_fs_' */
/begin COMPU_VTAB
		eDlybpa_szqqFga_puaotid___N_fs__VTAB
		"eDlybpa_szqqFga_puaotid___N_fs__VTAB is required by eDlybpa_szqqFga_puaotid___N_fs_"
		TAB_VERB
		2
		1 "Nsx_brk_pdl_off" 
		2 "Nsx_brk_pdl_on" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'fxDqmCc_ygftyxa_jCwvBkb_n__0m2p' */
/begin COMPU_VTAB
		fxDqmCc_ygftyxa_jCwvBkb_n__0m2p_VTAB
		"fxDqmCc_ygftyxa_jCwvBkb_n__0m2p_VTAB is required by fxDqmCc_ygftyxa_jCwvBkb_n__0m2p"
		TAB_VERB
		3
		0 "Nsx_wpmp_egr_stop" 
		10 "Nsx_wpmp_egr_dly" 
		20 "Nsx_wpmp_egr_run" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'gFhcrdc_ukljqcc_zFmtlua__1csc8c' */
/begin COMPU_VTAB
		gFhcrdc_ukljqcc_zFmtlua__1csc8c_VTAB
		"gFhcrdc_ukljqcc_zFmtlua__1csc8c_VTAB is required by gFhcrdc_ukljqcc_zFmtlua__1csc8c"
		TAB_VERB
		3
		1 "Nsx_coup_clos" 
		2 "Nsx_coup_sli" 
		8 "Nsx_coup_open" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'gkvtrya_ftnfaCc_Braotid_n2NkfN_' */
/begin COMPU_VTAB
		gkvtrya_ftnfaCc_Braotid_n2NkfN__VTAB
		"gkvtrya_ftnfaCc_Braotid_n2NkfN__VTAB is required by gkvtrya_ftnfaCc_Braotid_n2NkfN_"
		TAB_VERB
		2
		1 "Nsx_brk_pdl_off" 
		2 "Nsx_brk_pdl_on" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni' */
/begin COMPU_VTAB
		iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni_VTAB
		"iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni_VTAB is required by iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni"
		TAB_VERB
		4
		0 "Nsx_diag_sta_disa_stt" 
		1 "Nsx_diag_sta_run_stt" 
		2 "Nsx_diag_sta_end_stt" 
		3 "Nsx_diag_sta_abrt_stt" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'itzAFCa_walhowa_fCBrBqc___kv_i_' */
/begin COMPU_VTAB
		itzAFCa_walhowa_fCBrBqc___kv_i__VTAB
		"itzAFCa_walhowa_fCBrBqc___kv_i__VTAB is required by itzAFCa_walhowa_fCBrBqc___kv_i_"
		TAB_VERB
		4
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
		3 "Nsx_vld_fail_3" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'lfldkha_AFwjwnb_tkAxmyc_n_sfsnx' */
/begin COMPU_VTAB
		lfldkha_AFwjwnb_tkAxmyc_n_sfsnx_VTAB
		"lfldkha_AFwjwnb_tkAxmyc_n_sfsnx_VTAB is required by lfldkha_AFwjwnb_tkAxmyc_n_sfsnx"
		TAB_VERB
		3
		0 "Nsx_cnt_off" 
		1 "Nsx_cnt_on" 
		2 "Nsx_no_cnt" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'mlnqhha_zmkpBDa_BftlAdc__db43yt' */
/begin COMPU_VTAB
		mlnqhha_zmkpBDa_BftlAdc__db43yt_VTAB
		"mlnqhha_zmkpBDa_BftlAdc__db43yt_VTAB is required by mlnqhha_zmkpBDa_BftlAdc__db43yt"
		TAB_VERB
		631
		0 "NO_ERROR" 
		1 "ac_prs_h" 
		2 "ac_prs_l" 
		3 "acel_pdl_chr" 
		4 "acel_pdl_secu_1" 
		5 "acel_pdl_secu_2" 
		6 "acel_pdl_tot" 
		7 "acel_pdl_v1_h" 
		8 "acel_pdl_v1_l" 
		9 "acel_pdl_v2_h" 
		10 "acel_pdl_v2_l" 
		11 "actr_rly_oc" 
		12 "actr_rly_scg" 
		13 "actr_rly_scw" 
		14 "agb_data_chr" 
		15 "agb_data_seq_ctr" 
		16 "agb_data_tout" 
		17 "agb_no_frm" 
		18 "cata_dirt_lkg" 
		19 "cata_nok_cge" 
		20 "cata1_dirt_lkg" 
		21 "cata2_dirt_lkg" 
		22 "clu_cnt_nok" 
		23 "comb_trs_tout" 
		24 "doc1_utp_chr" 
		25 "doc1_utp_h" 
		26 "doc1_utp_l" 
		27 "doc2_utp_chr" 
		28 "doc2_utp_h" 
		29 "doc2_utp_l" 
		30 "doc2_utp_neg_dev" 
		31 "doc2_utp_pos_dev" 
		32 "efi_inj_oc" 
		33 "efi_inj_scg" 
		34 "efi_inj_scw" 
		35 "efi_pump_oc" 
		36 "efi_pump_scg" 
		37 "efi_pump_scw" 
		38 "egr_byp_oc" 
		39 "egr_byp_scg" 
		40 "egr_byp_scw" 
		41 "emtv_flow_meca" 
		42 "emtv_hbdg_el" 
		43 "emtv_hbdg_ovh" 
		44 "emtv_ofs_no_norm" 
		45 "emtv_reg_blk" 
		46 "emtv_reg_blk_open" 
		47 "emtv_reg_dirt" 
		48 "esp_data_chr" 
		49 "esp_data_seq_ctr" 
		50 "esp_no_frm" 
		51 "ex_prs_no_lk" 
		52 "ex_prs_nok" 
		53 "exh_temp_cmp" 
		54 "gas_pump_oc" 
		55 "gas_pump_scg" 
		56 "gas_pump_scw" 
		57 "glow_cmd_oc" 
		58 "glow_cmd_scg" 
		59 "glow_cmd_scw" 
		60 "igc_1_4_oc" 
		61 "igc_1_4_scg" 
		62 "igc_1_4_scw" 
		63 "igc_2_3_oc" 
		64 "igc_2_3_scg" 
		65 "igc_2_3_scw" 
		66 "in_vvtc_blk" 
		67 "in_vvtc_dirt_lkg" 
		68 "in_vvtc_sldv_oc" 
		69 "in_vvtc_sldv_scg" 
		70 "in_vvtc_sldv_scw" 
		71 "inj_ecu_lbdw_icp" 
		72 "inj_ecu_lbup_icp" 
		73 "inj1_oc" 
		74 "inj1_scg" 
		75 "inj1_scw" 
		76 "inj2_oc" 
		77 "inj2_scg" 
		78 "inj2_scw" 
		79 "inj3_oc" 
		80 "inj3_scg" 
		81 "inj3_scw" 
		82 "inj4_oc" 
		83 "inj4_scg" 
		84 "inj4_scw" 
		85 "it_cmd_el" 
		86 "it_hbdg_el" 
		87 "it_hbdg_ovh" 
		88 "it_ofs_meca" 
		89 "it_ofs_no_norm" 
		90 "it_ofs_secu_nok" 
		91 "it_reg_blk" 
		92 "it_reg_blk_clos" 
		93 "it_reg_blk_open" 
		94 "it_reg_dirt" 
		95 "knk_oor" 
		96 "knk_shp" 
		97 "lbdw_oc" 
		98 "lbdw_scg" 
		99 "lbdw_scw" 
		100 "lbup_oc" 
		101 "lbup_scg" 
		102 "lbup_scw" 
		103 "maf_reg_neg_err" 
		104 "mafs_plau_diag_h" 
		105 "mafs_plau_diag_l" 
		106 "oil_dil_ovs" 
		107 "pft_dirt" 
		108 "pft_dirt_lkg" 
		109 "pft_dp_chr" 
		110 "pft_dp_dirt_lkg" 
		111 "pft_dtp_chr" 
		112 "pft_dtp_h" 
		113 "pft_dtp_l" 
		114 "pft_dtp_ovh" 
		115 "pft_no_lk" 
		116 "pft_rgn_max_err" 
		117 "pft_utp_chr" 
		118 "pft_utp_h" 
		119 "pft_utp_l" 
		120 "pft_utp_neg_err" 
		121 "pft_utp_ovh" 
		122 "pft_utp_pos_err" 
		123 "pftrelprs_chr" 
		124 "pftrelprs_dirt_lkg" 
		125 "ps_toil_max_h_t" 
		126 "ps_toil_max_l_t" 
		127 "ps_toil_min_h_t" 
		128 "ps_toil_min_l_t" 
		129 "ps_toil_sig_nok" 
		130 "psoilprty_max_h_t" 
		131 "psoilprty_max_l_t" 
		132 "psoilprty_min_h_t" 
		133 "psoilprty_min_l_t" 
		134 "psoilprty_sig_nok" 
		135 "psoilvisc_max_h_t" 
		136 "psoilvisc_max_l_t" 
		137 "psoilvisc_min_h_t" 
		138 "psoilvisc_min_l_t" 
		139 "psoilvisc_sig_nok" 
		140 "pws_1_h" 
		141 "pws_1_l" 
		142 "pws_2_h" 
		143 "pws_2_l" 
		144 "pws_3_h" 
		145 "pws_3_l" 
		146 "sens_amp_h" 
		147 "sens_amp_l" 
		148 "sens_amp_reg_chr" 
		149 "sens_emtv_nok" 
		150 "sens_ex_prs_h" 
		151 "sens_ex_prs_l" 
		152 "sens_it_1_nok" 
		153 "sens_it_2_nok" 
		154 "sens_it_chr" 
		155 "sens_it_nok" 
		156 "sens_it_sig_mcut" 
		157 "sens_maf_h" 
		158 "sens_maf_l" 
		159 "sens_map_h" 
		160 "sens_map_l" 
		161 "sens_map_nok" 
		162 "sens_map_oc" 
		163 "sens_map_scg" 
		164 "sens_map_scw" 
		165 "sens_pft_dp_h" 
		166 "sens_pft_dp_l" 
		167 "sens_pft_dp_oor" 
		168 "sens_pftrelprs_h" 
		169 "sens_pftrelprs_l" 
		170 "sens_pftrelprs_oor" 
		171 "sens_spg_h" 
		172 "sens_spg_l" 
		173 "sens_spg_nok" 
		174 "sens_spg_oc" 
		175 "sens_spg_scg" 
		176 "sens_spg_scw" 
		177 "sens_tco_h" 
		178 "sens_tco_l" 
		179 "sens_tia_h" 
		180 "sens_tia_l" 
		181 "sens_toil_h" 
		182 "sens_toil_l" 
		183 "sens_up_it_temp_h" 
		184 "sens_up_it_temp_l" 
		185 "spg_reg_apl_down" 
		186 "spg_reg_apl_up" 
		187 "spg_reg_neg_err" 
		188 "spg_reg_pos_err" 
		189 "tbt_chr" 
		190 "tbt_h" 
		191 "tbt_l" 
		192 "tbt_reg_neg_err" 
		193 "tbt_reg_pos_err" 
		194 "thpl_cmd1_oc" 
		195 "thpl_cmd1_scg" 
		196 "thpl_cmd1_scw" 
		197 "thpl_cmd2_oc" 
		198 "thpl_cmd2_scg" 
		199 "thpl_cmd2_scw" 
		200 "thpl_cmd3_oc" 
		201 "thpl_cmd3_scg" 
		202 "thpl_cmd3_scw" 
		203 "vb_h" 
		204 "vb_l" 
		205 "vb_rly_oc_scg" 
		206 "vb_rly_scw" 
		207 "vnt_oc" 
		208 "vnt_scg" 
		209 "vnt_scw" 
		210 "cp_oc" 
		211 "cp_scg" 
		212 "cp_scw" 
		213 "sens_mat_h" 
		214 "sens_mat_l" 
		215 "egr_cool_dirt_lkg" 
		216 "fuel_temp_l" 
		217 "fuel_temp_plaus" 
		218 "fuel_temp_scg" 
		219 "fuel_temp_h" 
		220 "fuel_temp_sig_mcut" 
		221 "maf_reg_dirt_lkg" 
		222 "pcv_h" 
		223 "pcv_oc" 
		224 "pcv_scg" 
		225 "pcv_scw" 
		226 "rail_prs_plaus" 
		227 "rail_prs_h_lvl" 
		228 "rail_prs_l" 
		229 "rail_prs_scg" 
		230 "rail_prs_h" 
		231 "rail_prs_sig_mcut" 
		232 "sens_amp_oc" 
		233 "sens_amp_scg" 
		234 "sens_amp_scw" 
		235 "sens_ex_prs_no_lk" 
		236 "sens_ex_prs_nok" 
		237 "sens_maf_oc" 
		238 "sens_maf_scg" 
		239 "sens_maf_scw" 
		240 "sens_tia_oc" 
		241 "sens_tia_scg" 
		242 "sens_tia_scw" 
		243 "vcv_h" 
		244 "vcv_oc" 
		245 "vcv_scg" 
		246 "vcv_scw" 
		247 "bgin_clu_cmp" 
		248 "bgin_clu_nok" 
		249 "brk_pdl_chr" 
		250 "brk_pdl_clos_nok" 
		251 "brk_pdl_cmp" 
		252 "brk_pdl_no_norm" 
		253 "brk_pdl_open_nok" 
		254 "cata_cpt" 
		255 "cru_cmp" 
		256 "cru_sl_swi_chr" 
		257 "cru_sl_tot" 
		258 "cru_vs_cmp" 
		259 "cru_whl_cmd_nok" 
		260 "cru_whl_cmd_oc_scw" 
		261 "cru_whl_cmd_oor" 
		262 "cyl_bal_1_h_lvl" 
		263 "cyl_bal_1_l_lvl" 
		264 "cyl_bal_2_h_lvl" 
		265 "cyl_bal_2_l_lvl" 
		266 "cyl_bal_3_h_lvl" 
		267 "cyl_bal_3_l_lvl" 
		268 "cyl_bal_4_h_lvl" 
		269 "cyl_bal_4_l_lvl" 
		270 "efi_sldv_oc" 
		271 "efi_sldv_scg" 
		272 "efi_sldv_scw" 
		273 "ff_actr_blk_clos" 
		274 "ff_actr_blk_open" 
		275 "ff_actr_crt_up" 
		276 "ff_fct_dirt_lkg" 
		277 "ff_fct_h_lvl" 
		278 "ff_fct_l_lvl" 
		279 "ff_fct_neg_err" 
		280 "ff_fct_pos_err" 
		281 "ff_fct_shp" 
		282 "fprs_actr_blk_clos" 
		283 "fprs_actr_blk_open" 
		284 "fprs_actr_crt_up" 
		285 "fprs_fct_dirt_lkg" 
		286 "fprs_fct_h_lvl" 
		287 "fprs_fct_l_lvl" 
		288 "fprs_fct_neg_err" 
		289 "fprs_fct_pos_err" 
		290 "fprs_fct_shp" 
		291 "fprs_h_oor" 
		292 "fprs_l_oor" 
		293 "fsys_cpt" 
		294 "fsys_lpg_cpt" 
		295 "inj1_chk_sum" 
		296 "inj1_crt_intv" 
		297 "inj1_fast_trs" 
		298 "inj1_slow_trs" 
		299 "inj2_chk_sum" 
		300 "inj2_crt_intv" 
		301 "inj2_fast_trs" 
		302 "inj2_slow_trs" 
		303 "inj3_chk_sum" 
		304 "inj3_crt_intv" 
		305 "inj3_fast_trs" 
		306 "inj3_slow_trs" 
		307 "inj4_chk_sum" 
		308 "inj4_crt_intv" 
		309 "inj4_fast_trs" 
		310 "inj4_slow_trs" 
		311 "lbdw_hot_oc" 
		312 "lbdw_hot_scg" 
		313 "lbdw_hot_scw" 
		314 "lbup_hot_oc" 
		315 "lbup_hot_scg" 
		316 "lbup_hot_scw" 
		317 "map_chr" 
		318 "map_oor" 
		319 "mis_1_cata" 
		320 "mis_1_lpg_cata" 
		321 "mis_1_lpg_trs_h" 
		322 "mis_1_trs_h" 
		323 "mis_2_cata" 
		324 "mis_2_lpg_cata" 
		325 "mis_2_lpg_trs_h" 
		326 "mis_2_trs_h" 
		327 "mis_3_cata" 
		328 "mis_3_lpg_cata" 
		329 "mis_3_lpg_trs_h" 
		330 "mis_3_trs_h" 
		331 "mis_4_cata" 
		332 "mis_4_lpg_cata" 
		333 "mis_4_lpg_trs_h" 
		334 "mis_4_trs_h" 
		335 "mis_cata" 
		336 "mis_lpg_cata" 
		337 "mis_lpg_trs_h" 
		338 "mis_min_fuel_cata" 
		339 "mis_min_fuel_trs_h" 
		340 "mis_trs_h" 
		341 "mis_unk_cata" 
		342 "mis_unk_lpg_cata" 
		343 "mis_unk_lpg_trs_h" 
		344 "mis_unk_trs_h" 
		345 "sens_wfl_h" 
		346 "sens_wfl_l" 
		347 "spg_chr" 
		348 "spg_oor" 
		349 "tlz_ad_b_cpt" 
		350 "unk_thpl_chr" 
		351 "unk_thpl1_chr" 
		352 "unk_thpl2_chr" 
		353 "unk_thpl3_chr" 
		354 "unk_thpl4_chr" 
		355 "wgc_oc" 
		356 "wgc_scg" 
		357 "wgc_scw" 
		358 "wpmp_tcr_oc" 
		359 "wpmp_tcr_scg" 
		360 "wpmp_tcr_scw" 
		361 "crk_chr" 
		362 "crk_cyc" 
		363 "crk_el" 
		364 "crk_no_norm" 
		365 "crk_syn" 
		366 "ex_cam_chr" 
		367 "ex_cam_crk_cmp" 
		368 "ex_cam_l_puls" 
		369 "ex_cam_syn" 
		370 "in_cam_chr" 
		371 "in_cam_crk_cmp" 
		372 "in_cam_frq_h" 
		373 "in_cam_l_puls" 
		374 "in_cam_no_sig" 
		375 "in_cam_syn" 
		376 "in_vvtc_ad" 
		377 "it_reg_el" 
		378 "lbup_cpt" 
		379 "sens_pftrelprs_lkg" 
		380 "sens_pftrelprs_nok" 
		381 "sens_wfl_oc" 
		382 "ups_crt_intv" 
		383 "ups_heat_scg" 
		384 "ups_heat_scw" 
		385 "ups_hot_chr" 
		386 "ups_lamb_oc" 
		387 "ups_lamb_scg" 
		388 "ups_lamb_scw" 
		389 "ups_pump_oc" 
		390 "ups_pump_scg" 
		391 "ups_pump_scw" 
		392 "ups_shp" 
		393 "ups_slow_trs" 
		394 "ups_trim_oc" 
		395 "ups_trim_scg" 
		396 "ups_trim_scw" 
		397 "ups_virt_scg" 
		398 "ups_virt_scw" 
		399 "egr_byp_h" 
		400 "egr_byp_l" 
		401 "vnt_h" 
		402 "vnt_l" 
		403 "oit_hbdg_el" 
		404 "oit_hbdg_ovh" 
		405 "sit_hbdg_el" 
		406 "sit_hbdg_ovh" 
		407 "sit_reg_el" 
		408 "sit_reg_blk" 
		409 "sit_reg_blk_open" 
		410 "ff_actr_blk" 
		411 "fprs_actr_blk" 
		412 "sens_rup_l" 
		413 "sens_rup_h" 
		414 "rup_dirt_lkg" 
		415 "rup_nok" 
		416 "sfty_tq_chr" 
		417 "sfty_tq_clc_chr" 
		418 "sfty_tq_lih_chr" 
		419 "ff_actr_crt_down" 
		420 "fprs_actr_crt_down" 
		421 "fprs_fct_chr" 
		422 "tbt_reg_apl_up" 
		423 "crk_no_sig" 
		424 "crk_puls" 
		425 "crk_trs" 
		426 "ecm_err_itl" 
		427 "ecm_mon_tron" 
		428 "glow_cmd_cpt_blk" 
		429 "glow_cmd_fail" 
		430 "inj_ecu_itl" 
		431 "inj1_4_oor" 
		432 "inj1_freq_l" 
		433 "inj1_h_lvl" 
		434 "inj1_h_puls" 
		435 "inj1_l_lvl" 
		436 "inj1_l_puls" 
		437 "inj1_nok" 
		438 "inj1_r" 
		439 "inj1_shp" 
		440 "inj2_3_oor" 
		441 "inj2_freq_l" 
		442 "inj2_h_lvl" 
		443 "inj2_h_puls" 
		444 "inj2_l_lvl" 
		445 "inj2_l_puls" 
		446 "inj2_nok" 
		447 "inj2_r" 
		448 "inj2_shp" 
		449 "inj3_freq_l" 
		450 "inj3_h_lvl" 
		451 "inj3_h_puls" 
		452 "inj3_l_lvl" 
		453 "inj3_l_puls" 
		454 "inj3_nok" 
		455 "inj3_r" 
		456 "inj3_shp" 
		457 "inj4_freq_l" 
		458 "inj4_h_lvl" 
		459 "inj4_h_puls" 
		460 "inj4_l_lvl" 
		461 "inj4_l_puls" 
		462 "inj4_nok" 
		463 "inj4_r" 
		464 "inj4_shp" 
		465 "ip_lght_tco_ovh" 
		466 "map_nok" 
		467 "ptc_rov_oc" 
		468 "ptc_rov_scg" 
		469 "ptc_rov_scw" 
		470 "sens_alt_pwm_h" 
		471 "sens_alt_pwm_l" 
		472 "sfty_tq_lim" 
		473 "spg_nok" 
		474 "tbf_fct_apl_down" 
		475 "tbf_fct_apl_up" 
		476 "in_cam_nok" 
		477 "in_cam_cyc" 
		478 "crk_cmp" 
		479 "crk_shp" 
		480 "crk_oc" 
		481 "inj_oor" 
		482 "ecm_inj_bus_mcut" 
		483 "ecm_inj_ini" 
		484 "ecm_inj_oor" 
		485 "cl_rich_chr" 
		486 "ecm_mon_secu_1" 
		487 "ecm_mon_secu_2" 
		488 "ecm_adc_tron" 
		489 "wpmp_egr_oc" 
		490 "wpmp_egr_scg" 
		491 "wpmp_egr_scw" 
		492 "mdf1_oc" 
		493 "mdf1_scg" 
		494 "mdf1_scw" 
		495 "mdf2_oc" 
		496 "mdf2_scg" 
		497 "mdf2_scw" 
		498 "pft_nok_cge" 
		499 "tqi_cor_chr" 
		500 "fsys_apl_down" 
		501 "fsys_apl_up" 
		502 "fsys_h_lvl" 
		503 "ff_fct_chr" 
		504 "ff_fct_no_norm" 
		505 "ecm_inj_h" 
		506 "ecm_inj_l" 
		507 "ecm_inj_cpt_blk" 
		508 "ecm_it_nok" 
		509 "ecm_inj_no_norm" 
		510 "ecm_err_no_norm" 
		511 "ecm_inj_cmp" 
		512 "ecm_mcw_clc_chr" 
		513 "ecm_mcw_nok" 
		514 "ecm_mcw_seq_ctr" 
		515 "amp_reg_chr" 
		516 "ups_ro2_oor" 
		517 "ups_ro2_slow_trs" 
		518 "ups_tip_oor" 
		519 "sens_tco_sig_mcut" 
		520 "igc_1_oc" 
		521 "alt_pwm_apl_down" 
		522 "igc_1_scg" 
		523 "igc_1_scw" 
		524 "igc_2_oc" 
		525 "inj_cpt_blk" 
		526 "inj1_frq_l" 
		527 "inj2_frq_l" 
		528 "inj3_frq_l" 
		529 "inj4_frq_l" 
		530 "ff_actr_ovh" 
		531 "fprs_actr_ovh" 
		532 "ac_clu_oc" 
		533 "ac_clu_scg" 
		534 "ac_clu_scw" 
		535 "sfty_tq_supl" 
		536 "ups_uo2_oor" 
		537 "ups_ecu_oor" 
		538 "ups_ecu_itl" 
		539 "ups_ecu_chr" 
		540 "sens_ups_wire_scw" 
		541 "sens_ups_wire_oc" 
		542 "sens_ups_virt_oc" 
		543 "sens_ups_pump_oc" 
		544 "sens_ups_lamb_oc" 
		545 "sens_ups_heat_oc" 
		546 "sens_ups_heat_ovh" 
		547 "sens_ups_heat_scg" 
		548 "sens_ups_heat_scw" 
		549 "ecm_it_lih_chr" 
		550 "sens_ups_wire_scg" 
		551 "wpmp_tcr_blk" 
		552 "ecm_temp_nok" 
		553 "cp_blk_open" 
		554 "evap_chr" 
		555 "eva_fcap_abn_cple" 
		556 "eva_fcap_no_lk" 
		557 "evap_lkg" 
		558 "eva_sldv_blk_clos" 
		559 "eva_sldv_oc" 
		560 "eva_sldv_scg" 
		561 "eva_sldv_scw" 
		562 "sens_rvc_h" 
		563 "sens_rvc_l" 
		564 "sens_rvc_nok" 
		565 "sens_rvc_sig_mcut" 
		566 "lbup_nok" 
		567 "lbup_hot_apl_down" 
		568 "igc_2_scg" 
		569 "igc_2_scw" 
		570 "igc_3_oc" 
		571 "igc_3_scg" 
		572 "igc_3_scw" 
		573 "igc_4_oc" 
		574 "igc_4_scg" 
		575 "igc_4_scw" 
		576 "egr_byp_blk" 
		577 "isr_h_lvl" 
		578 "isr_l_lvl" 
		579 "sfty_tq_fail" 
		580 "vb_clc_chr" 
		581 "lbdw_hot_dirt_lkg" 
		582 "lbup_hot_dirt_lkg" 
		583 "spg_cmd_blk_clos" 
		584 "sens_egr_temp_h" 
		585 "sens_egr_temp_l" 
		586 "tco_cl_no_norm" 
		587 "tsta_reg_no_norm" 
		588 "dps_ecu_chr" 
		589 "dps_ecu_itl" 
		590 "dps_ecu_oor" 
		591 "dps_ro2_oor" 
		592 "dps_ro2_slow_trs" 
		593 "dps_tip_oor" 
		594 "dps_uo2_oor" 
		595 "sens_dps_heat_oc" 
		596 "sens_dps_heat_ovh" 
		597 "sens_dps_heat_scg" 
		598 "sens_dps_heat_scw" 
		599 "sens_dps_lamb_oc" 
		600 "sens_dps_pump_oc" 
		601 "sens_dps_virt_oc" 
		602 "sens_dps_wire_scg" 
		603 "sens_dps_wire_scw" 
		604 "it_reg_ad" 
		605 "mafs_apl_down" 
		606 "mafs_apl_up" 
		607 "mvac_pump_rly_h" 
		608 "mvac_pump_rly_l" 
		609 "mvac_sys_cpt" 
		610 "oil_dil_nok" 
		611 "pft_rgn_dirt" 
		612 "ptc1_oc" 
		613 "ptc1_scg" 
		614 "ptc1_scw" 
		615 "ptc2_oc" 
		616 "ptc2_scg" 
		617 "ptc2_scw" 
		618 "ptc3_oc" 
		619 "ptc3_scg" 
		620 "ptc3_scw" 
		621 "inj_ecu_bus_mcut" 
		622 "wpmp_egr_2_freq_h" 
		623 "wpmp_egr_2_freq_l" 
		624 "wpmp_egr_2_no_sig" 
		625 "wpmp_egr_2_oc" 
		626 "wpmp_egr_2_scg" 
		627 "wpmp_egr_2_scw" 
		628 "wpmp_egr_freq_h" 
		629 "wpmp_egr_freq_l" 
		630 "wpmp_egr_no_sig" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'nesxhqd_lCemnod_hfytbqc_n__MENM' */
/begin COMPU_VTAB
		nesxhqd_lCemnod_hfytbqc_n__MENM_VTAB
		"nesxhqd_lCemnod_hfytbqc_n__MENM_VTAB is required by nesxhqd_lCemnod_hfytbqc_n__MENM"
		TAB_VERB
		2
		0 "COMPLETE" 
		1 "NO_COMPLETE" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'nngBqjb_bunueAa_okABDAa_nft_Nc_' */
/begin COMPU_VTAB
		nngBqjb_bunueAa_okABDAa_nft_Nc__VTAB
		"nngBqjb_bunueAa_okABDAa_nft_Nc__VTAB is required by nngBqjb_bunueAa_okABDAa_nft_Nc_"
		TAB_VERB
		4
		1 "Nsx_pft_load_spd_clc_stt_1" 
		2 "Nsx_pft_load_spd_clc_stt_2" 
		3 "Nsx_pft_load_spd_clc_stt_3" 
		4 "Nsx_pft_load_spd_clc_stt_4" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'nqbBDkb_olADjia_huaouid_nd_xpr_' */
/begin COMPU_VTAB
		nqbBDkb_olADjia_huaouid_nd_xpr__VTAB
		"nqbBDkb_olADjia_huaouid_nd_xpr__VTAB is required by nqbBDkb_olADjia_huaouid_nd_xpr_"
		TAB_VERB
		8
		0 "Nsx_pft_load" 
		8 "Nsx_pft_spd_req" 
		16 "Nsx_pft_chk_temp" 
		24 "Nsx_pft_cata_hot" 
		32 "Nsx_pft_rgn_req" 
		56 "Nsx_pft_rgn_rest" 
		64 "Nsx_pft_rgn_ok" 
		80 "Nsx_pft_rgn_fail" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'qoqFqhc_FAxzcac_irphkFc__0v1v_l' */
/begin COMPU_VTAB
		qoqFqhc_FAxzcac_irphkFc__0v1v_l_VTAB
		"qoqFqhc_FAxzcac_irphkFc__0v1v_l_VTAB is required by qoqFqhc_FAxzcac_irphkFc__0v1v_l"
		TAB_VERB
		3
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'rzlnwjb_BlbxuAc_tkosmyc___xfxnx' */
/begin COMPU_VTAB
		rzlnwjb_BlbxuAc_tkosmyc___xfxnx_VTAB
		"rzlnwjb_BlbxuAc_tkosmyc___xfxnx_VTAB is required by rzlnwjb_BlbxuAc_tkosmyc___xfxnx"
		TAB_VERB
		3
		0 "Nsx_cnt_off" 
		1 "Nsx_cnt_on" 
		2 "Nsx_no_cnt" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'sdjirsa_kAEhhma_hlsAEfc_n_q_ors' */
/begin COMPU_VTAB
		sdjirsa_kAEhhma_hlsAEfc_n_q_ors_VTAB
		"sdjirsa_kAEhhma_hlsAEfc_n_q_ors_VTAB is required by sdjirsa_kAEhhma_hlsAEfc_n_q_ors"
		TAB_VERB
		4
		0 "Nsx_no_tq_req" 
		1 "Nsx_asr_msr_tq_req_noq" 
		5 "Nsx_asr_tq_req" 
		6 "Nsx_msr_tq_req" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'thpfgAb_auenodc_jygDerb_nNmt_r_' */
/begin COMPU_VTAB
		thpfgAb_auenodc_jygDerb_nNmt_r__VTAB
		"thpfgAb_auenodc_jygDerb_nNmt_r__VTAB is required by thpfgAb_auenodc_jygDerb_nNmt_r_"
		TAB_VERB
		4
		0 "Nsx_eng_tq_nom" 
		1 "Nsx_eng_tq_bad_acry" 
		2 "Nsx_eng_tq_trs_mod" 
		3 "Nsx_eng_tq_no_ans" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'uADawDa_nypsEha_DoCvmhd_n2_l_Nd' */
/begin COMPU_VTAB
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd_VTAB
		"uADawDa_nypsEha_DoCvmhd_n2_l_Nd_VTAB is required by uADawDa_nypsEha_DoCvmhd_n2_l_Nd"
		TAB_VERB
		2
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'utCpcna_olpdfvb_iFvAkza_nC___01' */
/begin COMPU_VTAB
		utCpcna_olpdfvb_iFvAkza_nC___01_VTAB
		"utCpcna_olpdfvb_iFvAkza_nC___01_VTAB is required by utCpcna_olpdfvb_iFvAkza_nC___01"
		TAB_VERB
		2
		0 "0" 
		1 "1" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'uvuyAtd_vhgEiaa_gbFndcd___s1_2l' */
/begin COMPU_VTAB
		uvuyAtd_vhgEiaa_gbFndcd___s1_2l_VTAB
		"uvuyAtd_vhgEiaa_gbFndcd___s1_2l_VTAB is required by uvuyAtd_vhgEiaa_gbFndcd___s1_2l"
		TAB_VERB
		3
		0 "Nsx_pres" 
		1 "Nsx_abst" 
		2 "Nsx_vld_abst" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'zdkvpcb_haoDnad_Ctrtujd_nn2N__i' */
/begin COMPU_VTAB
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i_VTAB
		"zdkvpcb_haoDnad_Ctrtujd_nn2N__i_VTAB is required by zdkvpcb_haoDnad_Ctrtujd_nn2N__i"
		TAB_VERB
		8
		0 "Nsx_vld_nok_0" 
		1 "Nsx_vld_ok_1" 
		2 "Nsx_vld_fail_2" 
		3 "Nsx_vld_fail_3" 
		4 "Nsx_vld_fail_4" 
		5 "Nsx_vld_fail_5" 
		6 "Nsx_vld_fail_6" 
		7 "Nsx_vld_fail_7" 
/end COMPU_VTAB
/* RSA::SAXHandler : Magically created for 'zidvspc_fBftdda_rbmFAla_nssN_34' */
/begin COMPU_VTAB
		zidvspc_fBftdda_rbmFAla_nssN_34_VTAB
		"zidvspc_fBftdda_rbmFAla_nssN_34_VTAB is required by zidvspc_fBftdda_rbmFAla_nssN_34"
		TAB_VERB
		6
		2 "Nsx_out_is" 
		4 "Nsx_tkof_is" 
		8 "Nsx_sta_is" 
		16 "Nsx_ast_is" 
		32 "Nsx_cdn_is" 
		64 "Nsx_act_is" 
/end COMPU_VTAB
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl
		""
	/begin SUB_FUNCTION
			AsBstCtl_Bpcdmxx
			AsBstCtl_Bpcpcox
			AsBstCtl_Bpcpcxx
			AsBstCtl_Bpcpprx
			AsBstCtl_Bpcprij
			AsBstCtl_Bpolcco
			AsBstCtl_Bpolcpr
			AsBstCtl_Bpolcri
			AsBstCtl_Mdpcoxx
			AsBstCtl_Mdpprxx
			AsBstCtl_Mdprijx
			AsBstCtl_Mdxxxxx
			AsBstCtl_Rcocxxx
			AsBstCtl_Spgpitc
			AsBstCtl_Spgslpx
			AsBstCtl_Tobpcxx
			AsBstCtl_Bpcpnpu
			AsBstCtl_Bpolcnr
			AsBstCtl_Mdpnpux
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpcdmxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_vnt_sens_vld_diag_inhi_cfm
			Ctx_esd_did_spg_reg_apl_down[0]
			Ctx_esd_did_spg_reg_apl_down[1]
			Ctx_esd_did_spg_reg_apl_down[2]
			Ctx_esd_did_spg_reg_apl_down[3]
			Ctx_esd_did_spg_reg_apl_down[4]
			Ctx_esd_did_spg_reg_apl_down[5]
			Ctx_esd_did_spg_reg_apl_up[0]
			Ctx_esd_did_spg_reg_apl_up[1]
			Ctx_esd_did_spg_reg_apl_up[2]
			Ctx_esd_did_spg_reg_apl_up[3]
			Ctx_esd_did_spg_reg_apl_up[4]
			Ctx_esd_did_spg_reg_apl_up[5]
			Cxx_dfdec_spg_cmd_blk_clos
			Cxx_dfdec_spg_reg_apl_down
			Cxx_dfdec_spg_reg_apl_up
			Cxx_dfinc_spg_cmd_blk_clos
			Cxx_dfinc_spg_reg_apl_down
			Cxx_dfinc_spg_reg_apl_up
			Cxx_esd_did_spg_reg_apl_down
			Cxx_esd_did_spg_reg_apl_up
			Cxx_ex_reg_apl_down_max
			Cxx_spg_reg_apl_down_max
			Cxx_spg_reg_apl_up_max
			Cxx_spg_sp_dev_max
			Cxx_spg_sp_t_fil
			Cxx_vnt_reg_ex_err_min
			Cxx_vnt_reg_spg_err_min
			Cbx_run_eng_ena_inhi
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_spg_cmd_blk_clos
			Vbx_df_spg_reg_apl_down
			Vbx_df_spg_reg_apl_up
			Vbx_ex_reg_apl_down
			Vbx_ex_reg_int_rst
			Vbx_spg_reg_apl_down
			Vbx_spg_reg_apl_up
			Vbx_spg_reg_int_rst
			Vbx_vnt_diag_stt_ok
			Vbx_vnt_diag_stt_ok_ex_prs
			Vbx_vnt_err_sgn
			Vbx_vnt_err_sgn_cge_h
			Vbx_vnt_err_sgn_cge_l
			Vxx_ex_reg_apl_down
			Vxx_spg_reg_apl_down
			Vxx_spg_reg_apl_up
			Vxx_vnt_dev_int
			Vxx_vnt_ex_dev_int
			Vxx_vnt_spg_sp_diff
			Vxx_vnt_spg_sp_dt1
			Vbx_vnt_diag_ok_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpcpcox
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfz_fac_slop_neg
			Cxx_dfz_fac_slop_pos
			Cxx_vnt_tran_pwm_slop_neg
			Cxx_vnt_tran_pwm_slop_pos
			Cxx_i_fac_neg_slop
			Cxx_i_fac_ex_reg_neg_slop
			Cxx_i_fac_pos_slop
			Cxx_i_fac_ex_reg_pos_slop
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_vnt_reg_i_fac_slop_on
			Vxx_n_cpr_rat_vnt_sge_t
			Vbx_vnt_tran_pwm_slop_on
			Vxx_n_vnt_sge_off_thd
			Vxx_n_vnt_sge_on_thd
			Vxx_vnt_sge_pwm
			Vxx_n_vnt_reg_i_fac_npu
			Vxx_n_vnt_reg_i_fac_pr
			Vxx_n_vnt_reg_i_fac_rij
			Vxx_vnt_reg_dfz_fac
			Vxx_vnt_reg_dfz_fac_npu
			Vxx_vnt_reg_dfz_fac_pr
			Vxx_vnt_reg_dfz_fac_rij
			Vxx_vnt_tran_pwm
			Vbx_vnt_sge_ena
			Vbx_vnt_reg_dfz_fac_slop_on
			Vbx_vnt_ex_reg_i_fac_slop_on
			Vxx_n_vnt_reg_i_fac
			Vxx_n_vnt_ex_reg_i_fac
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpcpcxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_vnt_ex_reg_max
			Ctb_x_vnt_ex_reg_min
			Ctb_x_vnt_pft_max_lim
			Ctb_x_vnt_reg_i_fac_neg
			Ctb_x_vnt_reg_i_fac_pos
			Ctb_x_vnt_reg_i_win_neg
			Ctb_x_vnt_reg_i_win_pos
			Ctb_x_vnt_reg_min
			Ctb_y_vnt_pft_max_lim
			Cxx_vnt_ex_i_ini
			Cxx_vnt_ex_i_win_neg
			Cxx_vnt_ex_i_win_pos
			Cxx_vnt_ex_reg_dfz_fmt
			Cxx_vnt_ex_reg_dfz_max
			Cxx_vnt_ex_reg_dfz_min
			Cxx_vnt_ex_reg_err_drv_red
			Cxx_vnt_ex_reg_err_red
			Cxx_vnt_reg_dfz_fmt
			Cxx_vnt_reg_dfz_max
			Cxx_vnt_reg_dfz_min
			Cxx_vnt_reg_err_drv_red
			Cxx_vnt_reg_err_red
			Cxx_vnt_reg_i_ini
			Cmp_ff_ms_vnt_reg_max
			Ctb_x_vnt_reg_i_fac_sig
			Ctp_csm_vnt_ex_reg_max
			Ctp_csm_vnt_ex_reg_min
			Ctp_csm_vnt_reg_min
			Ctd_dri_vnt_reg_i_win_neg
			Ctd_dri_vnt_reg_i_fac_neg
			Ctd_dri_vnt_reg_i_fac_pos
			Ctd_dri_vnt_reg_i_fac_sig
			Ctd_dri_vnt_reg_i_win_pos
			Cxx_gear_df_spg
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vtx_vnt_fzy_para_mux.field_1
			Vtx_vnt_fzy_para_mux.field_2
			Vtx_vnt_fzy_para_mux.field_3
			Vtx_vnt_fzy_para_mux.field_4
			Vtx_vnt_fzy_para_mux.field_5
			Vtx_vnt_reg_lim_mux.field_1
			Vtx_vnt_reg_lim_mux.field_2
			Vtx_vnt_i_para_mux.field_1
			Vtx_vnt_i_para_mux.field_2
			Vtx_vnt_i_para_mux.field_3
			Vtx_vnt_i_para_mux.field_4
			Vtx_vnt_i_para_mux.field_5
			Vtx_vnt_i_para_mux.field_6
			Vtx_vnt_reg_ex_lim_mux.field_1
			Vtx_vnt_reg_ex_lim_mux.field_2
			Vtx_vnt_i_ex_para_mux.field_1
			Vtx_vnt_i_ex_para_mux.field_2
			Vtx_vnt_i_ex_para_mux.field_3
			Vtx_vnt_i_ex_para_mux.field_4
			Vtx_vnt_i_ex_para_mux.field_5
			Vtx_vnt_i_ex_para_mux.field_6
			Vtx_vnt_i_para_spg_mux.field_1
			Vtx_vnt_i_para_spg_mux.field_2
			Vtx_vnt_i_para_spg_mux.field_3
			Vtx_vnt_i_para_spg_mux.field_4
			Vtx_vnt_i_para_spg_mux.field_5
			Vtx_vnt_i_para_spg_mux.field_6
			Vxx_vnt_i_raw_neg
			Vxx_vnt_i_raw_pos
			Vxx_vnt_i_raw_sig
			Vxx_gear_spg
			Vtx_vnt_reg_spg_lim_mux.field_1
			Vtx_vnt_reg_spg_lim_mux.field_2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpcpnpu
		""
	/begin OUT_MEASUREMENT
			Vtx_vnt_para_mux_npu.field_1
			Vtx_vnt_para_mux_npu.field_2
			Vxx_vnt_tran_pwm_npu
			Vtx_vnt_sge_para_mux_npu.field_1
			Vtx_vnt_sge_para_mux_npu.field_2
			Vtx_vnt_sge_para_mux_npu.field_3
			Vtx_vnt_sge_para_mux_npu.field_4
			Vtx_vnt_sge_para_mux_npu.field_5
			Vxx_n_vnt_ex_reg_i_fac_npu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpcpprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_n_vnt_sge_on_h_thd_pr
			Ctb_x_n_vnt_sge_on_l_thd_pr
			Ctb_x_n_vnt_sge_t_pr
			Ctb_x_vnt_ex_reg_i_fac_pr
			Ctb_x_vnt_reg_dfz_fac_pr
			Ctb_x_vnt_reg_i_fac_pr
			Ctb_x_vnt_tran_pwm_pr
			Ctb_y_cpr_rat_vnt_sge_t_pr
			Ctb_y_vnt_tran_pwm_pr
			Cmp_n_cpr_rat_vnt_sge_t_pr
			Cmp_vnt_tran_pwm_pr
			Ctp_n_vnt_sge_on_h_thd_pr
			Ctp_n_vnt_sge_on_l_thd_pr
			Ctp_vnt_ex_reg_i_fac_pr
			Ctp_vnt_reg_dfz_fac_pr
			Ctp_vnt_reg_i_fac_pr
			Cbx_vnt_sge_ena_pr
			Cxx_vnt_sge_pwm_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_cpr_rat_pr
			Vtx_vnt_para_mux_pr.field_1
			Vtx_vnt_para_mux_pr.field_2
			Vtx_vnt_sge_para_mux_pr.field_1
			Vtx_vnt_sge_para_mux_pr.field_2
			Vtx_vnt_sge_para_mux_pr.field_3
			Vtx_vnt_sge_para_mux_pr.field_4
			Vtx_vnt_sge_para_mux_pr.field_5
			Vxx_n_vnt_ex_reg_i_fac_pr
			Vxx_vnt_tran_pwm_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpcprij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_vnt_reg_dfz_fac_rij
			Ctb_x_vnt_reg_i_fac_rij
			Ctb_x_vnt_tran_pwm_rij
			Ctb_y_vnt_tran_pwm_rij
			Cmp_vnt_tran_pwm_rij
			Ctp_vnt_reg_dfz_fac_rij
			Ctp_vnt_reg_i_fac_rij
			Cbx_vnt_sge_ena_rij
			Ctb_x_n_vnt_sge_on_h_thd_rij
			Ctb_x_n_vnt_sge_on_l_thd_rij
			Ctb_x_n_vnt_sge_t_rij
			Ctb_y_cpr_rat_vnt_sge_t_rij
			Cmp_n_cpr_rat_vnt_sge_t_rij
			Ctp_n_vnt_sge_on_h_thd_rij
			Ctp_n_vnt_sge_on_l_thd_rij
			Cxx_vnt_sge_pwm_rij
			Ctb_x_vnt_ex_reg_i_fac_rij
			Ctp_vnt_ex_reg_i_fac_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_vnt_tran_pwm_rij
			Vtx_vnt_para_mux_rij.field_1
			Vtx_vnt_para_mux_rij.field_2
			Vtx_vnt_sge_para_mux_rij.field_1
			Vtx_vnt_sge_para_mux_rij.field_2
			Vtx_vnt_sge_para_mux_rij.field_3
			Vtx_vnt_sge_para_mux_rij.field_4
			Vtx_vnt_sge_para_mux_rij.field_5
			Vxx_cpr_rat_rij
			Vxx_n_vnt_ex_reg_i_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpolcco
		""
	/begin DEF_CHARACTERISTIC
			Cxx_vnt_ctl_max
			Cxx_vnt_ctl_min
			Cxx_vnt_ctl_slop_neg
			Cxx_vnt_ctl_slop_pos
			Cxx_vnt_ctl_ofs_gear_nok
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_vnt_ctl_slop_on
			Vxx_vnt_ctl_pwm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpolcnr
		""
	/begin OUT_MEASUREMENT
			Vxx_vnt_ctl_npu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpolcpr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_pft_vnt_ctl_ofs_pr
			Ctb_x_vnt_ctl_amp_pr
			Ctb_x_vnt_ctl_bas_amp_pr
			Ctb_x_vnt_ctl_bas_pr
			Ctb_x_vnt_ctl_bas_tia_pr
			Ctb_x_vnt_ctl_bas_tkof_pr
			Ctb_x_vnt_ctl_ex_df_pr
			Ctb_x_vnt_ctl_tia_pr
			Ctb_x_vnt_ctl_tkof_pr
			Ctb_y_pft_vnt_ctl_ofs_pr
			Ctb_y_vnt_ctl_bas_amp_pr
			Ctb_y_vnt_ctl_bas_pr
			Ctb_y_vnt_ctl_bas_tia_pr
			Ctb_y_vnt_ctl_bas_tkof_pr
			Ctb_y_vnt_ctl_ex_df_pr
			Cmp_pft_ms_vnt_ctl_ofs_pr
			Cmp_tqi_n_vnt_ctl_amp_pr
			Cmp_tqi_n_vnt_ctl_bas_pr
			Cmp_tqi_n_vnt_ctl_tia_pr
			Cmp_tqi_n_vnt_ctl_tkof_pr
			Cmp_vnt_ctl_ex_df_pr
			Ctp_amp_vnt_ctl_pr
			Ctp_tia_vnt_ctl_pr
			Ctp_tkof_vnt_ctl_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_tia_ol_spg_pr
			Vxx_vnt_ctl_amp_bas_pr
			Vxx_vnt_ctl_amp_fac_pr
			Vxx_vnt_ctl_amp_pr
			Vxx_vnt_ctl_bas_amp_pr
			Vxx_vnt_ctl_bas_pr
			Vxx_vnt_ctl_ex_lim_ex_df_pr
			Vxx_vnt_ctl_pft_ofs_pr
			Vxx_vnt_ctl_tia_bas_pr
			Vxx_vnt_ctl_tia_fac_pr
			Vxx_vnt_ctl_tia_pr
			Vxx_vnt_ctl_tkof_bas_pr
			Vxx_vnt_ctl_tkof_fac_pr
			Vxx_vnt_ctl_tkof_pr
			Vxx_vnt_ctl_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Bpolcri
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_vnt_ctl_amp_rij
			Ctb_x_vnt_ctl_bas_amp_rij
			Ctb_x_vnt_ctl_bas_rij
			Ctb_x_vnt_ctl_bas_tco_rij
			Ctb_x_vnt_ctl_bas_tia_rij
			Ctb_x_vnt_ctl_tco_rij
			Ctb_x_vnt_ctl_tia_rij
			Ctb_y_vnt_ctl_bas_amp_rij
			Ctb_y_vnt_ctl_bas_rij
			Ctb_y_vnt_ctl_bas_tco_rij
			Ctb_y_vnt_ctl_bas_tia_rij
			Cmp_tqi_n_vnt_ctl_amp_rij
			Cmp_tqi_n_vnt_ctl_bas_rij
			Cmp_tqi_n_vnt_ctl_tco_rij
			Cmp_tqi_n_vnt_ctl_tia_rij
			Ctp_amp_vnt_ctl_rij
			Ctp_tco_vnt_ctl_rij
			Ctp_tia_vnt_ctl_rij
			Ctb_x_pft_vnt_ctl_ofs
			Ctb_y_pft_vnt_ctl_ofs
			Cmp_pft_ms_vnt_ctl_ofs
			Cmp_vnt_ctl_ex_df_rij
			Ctb_x_vnt_ctl_ex_df_rij
			Ctb_y_vnt_ctl_ex_df_rij
			Cxx_tia_df_ol_spg
			Ctb_x_vnt_ctl_bas_tkof_rij
			Ctb_y_vnt_ctl_bas_tkof_rij
			Cmp_tqi_n_vnt_ctl_tkof_rij
			Ctb_x_vnt_ctl_tkof_rij
			Ctp_tkof_vnt_ctl_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_vnt_ctl_amp_bas_rij
			Vxx_vnt_ctl_amp_fac_rij
			Vxx_vnt_ctl_amp_rij
			Vxx_vnt_ctl_bas_amp_rij
			Vxx_vnt_ctl_bas_rij
			Vxx_vnt_ctl_rij
			Vxx_vnt_ctl_tco_bas_rij
			Vxx_vnt_ctl_tco_fac_rij
			Vxx_vnt_ctl_tco_rij
			Vxx_vnt_ctl_tia_bas_rij
			Vxx_vnt_ctl_tia_fac_rij
			Vxx_vnt_ctl_tia_rij
			Vxx_tia_ol_spg_rij
			Vxx_vnt_ctl_pft_ofs
			Vxx_vnt_ctl_ex_lim_ex_df_rij
			Vxx_vnt_ctl_tkof_fac_rij
			Vxx_vnt_ctl_tkof_bas_rij
			Vxx_vnt_ctl_tkof_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Mdpcoxx
		""
	/begin OUT_MEASUREMENT
			Vxx_n_vnt_diag_off_thd
			Vxx_n_vnt_diag_on_thd
			Vxx_vnt_zon_n_thd_1
			Vxx_vnt_zon_n_thd_2
			Vxx_vnt_zon_n_thd_3
			Vxx_vnt_zon_tqi_thd_2
			Vxx_vnt_zon_tqi_thd_3
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Mdpnpux
		""
	/begin OUT_MEASUREMENT
			Vtx_vnt_zon_thd_mux_npu.field1
			Vtx_vnt_zon_thd_mux_npu.field2
			Vtx_vnt_zon_thd_mux_npu.field3
			Vtx_vnt_zon_thd_mux_npu.field4
			Vtx_vnt_zon_thd_mux_npu.field5
			Vtx_vnt_stt_thd_mux_npu.field1
			Vtx_vnt_stt_thd_mux_npu.field2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Mdpprxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_vnt_diag_stt_off_pr
			Ctb_x_vnt_diag_stt_on_pr
			Ctb_x_vnt_stt_cor_pr
			Ctb_y_vnt_stt_cor_pr
			Cmp_n_tia_vnt_stt_cor_pr
			Ctp_n_vnt_diag_stt_off_pr
			Ctp_n_vnt_diag_stt_on_pr
			Cxx_vnt_zon_n_thd_1_pr
			Cxx_vnt_zon_n_thd_2_pr
			Cxx_vnt_zon_n_thd_3_pr
			Cxx_vnt_zon_tqi_thd_2_pr
			Cxx_vnt_zon_tqi_thd_3_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vtx_vnt_stt_thd_mux_pr.field1
			Vtx_vnt_stt_thd_mux_pr.field2
			Vtx_vnt_zon_thd_mux_pr.field1
			Vtx_vnt_zon_thd_mux_pr.field2
			Vtx_vnt_zon_thd_mux_pr.field3
			Vtx_vnt_zon_thd_mux_pr.field4
			Vtx_vnt_zon_thd_mux_pr.field5
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Mdprijx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_vnt_diag_stt_off_rij
			Ctb_x_vnt_diag_stt_on_rij
			Ctb_x_vnt_stt_cor_rij
			Ctb_y_vnt_stt_cor_rij
			Cxx_vnt_zon_n_thd_1_rij
			Cxx_vnt_zon_n_thd_2_rij
			Cxx_vnt_zon_n_thd_3_rij
			Cxx_vnt_zon_tqi_thd_2_rij
			Cxx_vnt_zon_tqi_thd_3_rij
			Cmp_n_tia_vnt_stt_cor_rij
			Ctp_n_vnt_diag_stt_off_rij
			Ctp_n_vnt_diag_stt_on_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vtx_vnt_stt_thd_mux_rij.field1
			Vtx_vnt_stt_thd_mux_rij.field2
			Vtx_vnt_zon_thd_mux_rij.field1
			Vtx_vnt_zon_thd_mux_rij.field2
			Vtx_vnt_zon_thd_mux_rij.field3
			Vtx_vnt_zon_thd_mux_rij.field4
			Vtx_vnt_zon_thd_mux_rij.field5
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Mdxxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_vnt_pwm_inv
			Ctb_x_vnt_diag_lih_cdn
			Ctb_x_vnt_diag_lih_fac
			Ctb_x_vnt_diag_lih_ofs
			Ctb_x_vnt_diag_lih_set
			Cxx_vnt_cold_sta_n_thd
			Cxx_vnt_diag_pwm_max
			Cxx_vnt_diag_pwm_min
			Cxx_vnt_lih_slop_neg
			Cxx_vnt_lih_slop_pos
			Cxx_vnt_mnl_pwm
			Cxx_vnt_moni_neg_dif_set_dly
			Cxx_vnt_moni_spg_neg_dif_thd
			Ctd_stt_vnt_diag_lih_cdn
			Ctd_stt_vnt_diag_lih_fac
			Ctd_stt_vnt_diag_lih_ofs
			Ctd_stt_vnt_diag_lih_set
			Ctp_tco_vnt_cold_sta_dly
			Cbx_vnt_ex_ctl_lih_ena
			Cbx_vnt_mnl_pwm_ena
			Cbx_vnt_tran_lih_ena
			Cxx_vnt_moni_spg_neg_lim_dly
			Cxx_vnt_moni_spg_sp_neg_lim
			Ctb_x_vnt_cold_sta_dly
			Cbx_cold_sta_cfm
			Cbx_vnt_ex_prs_lim_cfm
			Cbx_vnt_tran_cfm
			Cxx_vnt_ex_lim_tia_cold_cut_dly
			Cxx_vnt_tia_cold_h_ex_lim_ena
			Cxx_vnt_tia_cold_l_ex_lim_ena
			Cbx_no_dly_bfr_nom_stt
			Cbx_inhi_air_vld_spg_reg_cfm
			Cbx_inhi_cmd_blk_clos_cfm
			Cbx_inhi_emtv_vld_spg_cfm
			Cbx_inhi_ex_prs_nok_cfm
			Cbx_inhi_inj_sys_vld_cfm
			Cbx_inhi_it_vld_spg_cfm
			Cbx_inhi_spg_apl_down_cfm
			Cbx_inhi_spg_apl_up_cfm
			Cbx_inhi_spg_it_cut_cfm
			Cbx_inhi_vnt_diag_cfm
			Cbx_vnt_ex_prs_lim_tia_cold_cut
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_vnt_diag_air_sys
			Vsx_spg_reg_vld
			Vsx_vnt_cold_sta
			Vsx_vnt_diag_lih_cdn
			Vsx_vnt_diag_stt
			Vsx_vnt_stt
			Vsx_vnt_zon
			Vxx_vnt_lih_pwm
			Vbx_vnt_ex_lim_act
			Vbx_ex_ctl_lih
			Vbx_ex_prs_fail_tran_req
			Vbx_ex_prs_lim_req
			Vbx_ex_prs_pres
			Vbx_no_prs_pres
			Vbx_spg_ctl_lih
			Vbx_sys_err
			Vbx_tran_req
			Vbx_vnt_ex_lim_tia_cold_cut
			Vbx_spg_it_cut
			Vxx_vnt_pwm_raw
			Vbx_no_dly_bfr_nom_stt
			Vbx_vnt_reg_dev
			Vbx_vnt_reg_dev_zon_0
			Vbx_vnt_reg_dev_zon_2
			Vbx_vnt_reg_dev_zon_3_4
			Vbx_vnt_diag_cut
			Vbx_vnt_diag_inhi
			Vbx_vnt_ex_ctl_lih_ena
			Vbx_vnt_diag_inhi_air_sys
			Vbx_vnt_diag_inhi_ex_prs
			Vbx_vnt_diag_inhi_gov_dev
			Vbx_vnt_diag_inhi_inj_sys
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Rcocxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_fzy_gear_typ
			Ctb_n_vnt_emtv_psn_thd
			Ctb_tqi_vnt_emtv_psn_thd
			Ctb_vnt_err_drv_neg_typ_1
			Ctb_vnt_err_drv_neg_typ_2
			Ctb_vnt_err_drv_neg_typ_3
			Ctb_vnt_err_drv_nul_typ_1
			Ctb_vnt_err_drv_nul_typ_2
			Ctb_vnt_err_drv_nul_typ_3
			Ctb_vnt_err_drv_pos_typ_1
			Ctb_vnt_err_drv_pos_typ_2
			Ctb_vnt_err_drv_pos_typ_3
			Ctb_vnt_err_neg_typ_1
			Ctb_vnt_err_neg_typ_2
			Ctb_vnt_err_neg_typ_3
			Ctb_vnt_err_nul_typ_1
			Ctb_vnt_err_nul_typ_2
			Ctb_vnt_err_nul_typ_3
			Ctb_vnt_err_pos_typ_1
			Ctb_vnt_err_pos_typ_2
			Ctb_vnt_err_pos_typ_3
			Ctb_vnt_pwm_i_rst_ena
			Ctb_x_vnt_pwm_i_rst
			Ctb_y_vnt_pwm_i_rst
			Cmp_n_tqi_vnt_emtv_psn_thd
			Cmp_vnt_pwm_i_rst
			Ctd_fzy_gear_typ
			Ctp_vnt_err_drv_neg_typ_1
			Ctp_vnt_err_drv_neg_typ_2
			Ctp_vnt_err_drv_neg_typ_3
			Ctp_vnt_err_drv_nul_typ_1
			Ctp_vnt_err_drv_nul_typ_2
			Ctp_vnt_err_drv_nul_typ_3
			Ctp_vnt_err_drv_pos_typ_1
			Ctp_vnt_err_drv_pos_typ_2
			Ctp_vnt_err_drv_pos_typ_3
			Ctp_vnt_err_neg_typ_1
			Ctp_vnt_err_neg_typ_2
			Ctp_vnt_err_neg_typ_3
			Ctp_vnt_err_nul_typ_1
			Ctp_vnt_err_nul_typ_2
			Ctp_vnt_err_nul_typ_3
			Ctp_vnt_err_pos_typ_1
			Ctp_vnt_err_pos_typ_2
			Ctp_vnt_err_pos_typ_3
			Ctp_vnt_pwm_i_rst_ena
			Cbx_inhi_amp_vld_cfm
			Cbx_rst_i_agb_down_shf
			Cbx_rst_i_fedg_ex_prs_lim_ena
			Cbx_rst_i_redg_ex_prs_lim_ena
			Cxx_vnt_cgv_dfz_neg
			Cxx_vnt_emtv_clos_psn
			Cxx_vnt_emtv_open_t
			Cxx_vnt_ena_ol
			Cxx_vnt_err_drv_max
			Cxx_vnt_pwm_i_rst_hys_h
			Cxx_vnt_reg_i_ini_egr_cut
			Cxx_vnt_reg_i_rst_emtv_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ex_lim_i_init
			Vbx_pwm_thd_i_init
			Vbx_rst_i_ex_prs_lim
			Vbx_vnt_emtv_i_init
			Vbx_vnt_i_frz
			Vbx_vnt_reg_ena
			Vbx_vnt_sge_act
			Vxx_gear_fzy
			Vxx_vnt_err_drv_fzy
			Vxx_vnt_err_drv_fzy_neg
			Vxx_vnt_err_drv_fzy_neg_typ_1
			Vxx_vnt_err_drv_fzy_neg_typ_2
			Vxx_vnt_err_drv_fzy_neg_typ_3
			Vxx_vnt_err_drv_fzy_nul
			Vxx_vnt_err_drv_fzy_nul_typ_1
			Vxx_vnt_err_drv_fzy_nul_typ_2
			Vxx_vnt_err_drv_fzy_nul_typ_3
			Vxx_vnt_err_drv_fzy_pos
			Vxx_vnt_err_drv_fzy_pos_typ_1
			Vxx_vnt_err_drv_fzy_pos_typ_2
			Vxx_vnt_err_drv_fzy_pos_typ_3
			Vxx_vnt_err_fzy
			Vxx_vnt_err_fzy_neg
			Vxx_vnt_err_fzy_neg_typ_1
			Vxx_vnt_err_fzy_neg_typ_2
			Vxx_vnt_err_fzy_neg_typ_3
			Vxx_vnt_err_fzy_nul
			Vxx_vnt_err_fzy_nul_typ_1
			Vxx_vnt_err_fzy_nul_typ_2
			Vxx_vnt_err_fzy_nul_typ_3
			Vxx_vnt_err_fzy_pos
			Vxx_vnt_err_fzy_pos_typ_1
			Vxx_vnt_err_fzy_pos_typ_2
			Vxx_vnt_err_fzy_pos_typ_3
			Vxx_vnt_inf_1
			Vxx_vnt_inf_2
			Vxx_vnt_inf_3
			Vxx_vnt_inf_4
			Vxx_vnt_inf_5
			Vxx_vnt_inf_6
			Vxx_vnt_inf_7
			Vxx_vnt_reg_dfz_fmt
			Vxx_vnt_reg_dfz_max
			Vxx_vnt_reg_dfz_min
			Vxx_vnt_reg_dfz_out
			Vxx_vnt_reg_err_drv_red
			Vxx_vnt_reg_err_red
			Vxx_vnt_reg_fmt
			Vxx_vnt_reg_fzy_pwm
			Vxx_vnt_reg_i_fac_neg
			Vxx_vnt_reg_i_fac_pos
			Vxx_vnt_reg_i_fac_sig
			Vxx_vnt_reg_i_ini
			Vxx_vnt_reg_i_pwm
			Vxx_vnt_reg_i_pwm_bfr
			Vxx_vnt_reg_i_pwm_raw
			Vxx_vnt_reg_i_pwm_sum
			Vxx_vnt_reg_i_win_neg
			Vxx_vnt_reg_i_win_pos
			Vxx_vnt_reg_lim
			Vxx_vnt_reg_max
			Vxx_vnt_reg_min
			Vxx_vnt_reg_raw
			Vxx_vnt_reg_raw_lim
			Vxx_vnt_rst_emtv_psn
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Spgpitc
		""
	/begin DEF_CHARACTERISTIC
			Cxx_vnt_reg_ex_prs_err_dt1
			Cxx_vnt_reg_spg_err_dt1
			Ctb_dt1_exp
			Ctp_dt1_exp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_vnt_reg_rco_err
			Vxx_vnt_reg_spg_err
			Vxx_vnt_spg_err_tran
			Vxx_vnt_reg_err_drv
			Vxx_vnt_reg_ex_prs_err_drv
			Vxx_vnt_reg_spg_err_drv
			Vxx_vnt_reg_rco_err_drv
			Vxx_vnt_reg_err
			Vxx_vnt_reg_ex_prs_err
			Vxx_dt1_exp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Spgslpx
		""
	/begin OUT_MEASUREMENT
			Vbx_spg_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/begin FUNCTION
		AsBstCtl_Tobpcxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_tran_off_thd
			Ctb_x_vnt_tran_amp_cor
			Ctb_y_tran_off_t
			Ctb_y_tran_off_thd
			Cxx_vnt_tran_pwm_max
			Cxx_vnt_tran_pwm_min
			Cmp_gear_n_tran_off_thd
			Ctp_vnt_tran_amp_cor
			Ctb_x_tran_off_t
			Cxx_gear_df_tran
			Cbx_tran_open_ena_cfm
			Ctb_x_tran_on_thd
			Ctb_x_tran_open_pwm
			Ctb_x_tran_open_t
			Ctb_y_tran_on_thd
			Ctb_y_tran_open_pwm
			Ctb_y_tran_open_t
			Cmp_gear_n_tran_on_thd
			Cmp_gear_n_tran_open_pwm
			Cmp_gear_n_tran_off_t
			Cmp_gear_n_tran_open_t
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_vnt_tran_req
			Vxx_vnt_off_t
			Vxx_vnt_off_thd
			Vxx_vnt_reg_pwm
			Vxx_gear_df_tran
			Vbx_vnt_tran_on
			Vxx_vnt_on_thd
			Vxx_vnt_tran_clos_open_pwm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin FUNCTION
		AsBstSpt
		""
	/begin SUB_FUNCTION
			AsBstSpt_Bpscoxx
			AsBstSpt_Bpsprxx
			AsBstSpt_Bpsrijx
			AsBstSpt_Bpsnpux
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin FUNCTION
		AsBstSpt_Bpscoxx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_spg_sp_max
			Cxx_spg_sp_min
			Cxx_spg_sp_slop_neg
			Cxx_spg_sp_slop_pos
			Ctb_x_amp_sp_max
			Ctb_y_amp_sp_max
			Cmp_amp_n_spg_sp_max
			Cmp_n_tia_spg_sp_max_fac
			Ctb_n_spg_sp_max_fac
			Ctb_tia_spg_sp_max_fac
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_spg_sp_slop_on
			Vxx_vnt_spg_sp
			Vxx_vnt_sp_max
			Vxx_vnt_sp_max_raw
			Vxx_vnt_sp_max_fac
			Vxx_tia_spg_sp_max
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin FUNCTION
		AsBstSpt_Bpsnpux
		""
	/begin OUT_MEASUREMENT
			Vxx_spg_sp_npu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin FUNCTION
		AsBstSpt_Bpsprxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_amp_spg_sp_cor_pr
			Ctb_x_pft_spg_sp_max_pr
			Ctb_x_spg_sp_amp_cor_pr
			Ctb_x_spg_sp_bas_pr
			Ctb_x_spg_sp_tia_cor_pr
			Ctb_y_pft_spg_sp_max_pr
			Ctb_y_spg_sp_amp_cor_pr
			Ctb_y_spg_sp_bas_pr
			Cmp_pft_n_spg_sp_max_pr
			Cmp_tqi_n_spg_sp_amp_cor_pr
			Cmp_tqi_n_spg_sp_bas_pr
			Ctp_tia_spg_sp_cor_pr
			Ctb_x_tia_spg_sp_cor_pr
			Ctb_y_spg_sp_tia_cor_pr
			Cmp_tqi_n_spg_sp_tia_cor_pr
			Ctp_amp_spg_sp_cor_pr
			Cmp_spg_sp_ex_df_cor_pr
			Ctb_x_spg_sp_ex_df_cor_pr
			Ctb_x_ex_df_spg_sp_cor_pr
			Ctb_y_spg_sp_ex_df_cor_pr
			Ctp_ex_df_spg_sp_cor_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_vnt_sp_amp_bas_pr
			Vxx_vnt_sp_amp_fac_pr
			Vxx_vnt_sp_amp_pr
			Vxx_vnt_sp_cor_pr
			Vxx_vnt_sp_tia_pr
			Vxx_vnt_spg_sp_bas_pr
			Vxx_vnt_spg_sp_pft_max_pr
			Vxx_vnt_sp_min_tia_amp_pr
			Vxx_tia_spg_sp_pr
			Vxx_vnt_sp_tia_bas_pr
			Vxx_vnt_sp_tia_fac_pr
			Vxx_vnt_sp_ex_df_bas_pr
			Vxx_vnt_sp_ex_df_fac_pr
			Vxx_spg_sp_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/begin FUNCTION
		AsBstSpt_Bpsrijx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_amp_spg_sp_cor_rij
			Ctb_x_pft_sp_max_rij
			Ctb_x_spg_sp_amp_cor_rij
			Ctb_x_spg_sp_tia_cor_rij
			Ctb_y_pft_sp_max_rij
			Ctb_y_spg_sp_amp_cor_rij
			Ctb_y_spg_sp_tia_cor_rij
			Cmp_pft_n_spg_sp_max_rij
			Cmp_tqi_n_spg_sp_bas_rij
			Ctp_tia_spg_sp_cor_rij
			Cmp_tqi_n_spg_sp_amp_cor_rij
			Ctb_x_spg_sp_bas_rij
			Ctb_y_spg_sp_bas_rij
			Ctb_x_tia_spg_sp_cor_rij
			Cmp_tqi_n_spg_sp_tia_cor_rij
			Ctp_amp_spg_sp_cor_rij
			Cmp_spg_sp_ex_df_cor_rij
			Ctb_x_spg_sp_ex_df_cor_rij
			Ctb_x_ex_df_spg_sp_cor_rij
			Ctb_y_spg_sp_ex_df_cor_rij
			Ctp_ex_df_spg_sp_cor_rij
			Cxx_tia_df_spg_sp
			Cxx_spg_sp_ex_df_slop_neg
			Cxx_spg_sp_ex_df_slop_pos
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_spg_sp_rij
			Vxx_vnt_sp_amp_fac_rij
			Vxx_vnt_sp_cor_rij
			Vxx_vnt_sp_tia_fac_rij
			Vxx_vnt_sp_tia_rij
			Vxx_vnt_spg_sp_bas_rij
			Vxx_vnt_spg_sp_pft_max_rij
			Vxx_vnt_sp_min_tia_amp_rij
			Vxx_vnt_sp_amp_bas_rij
			Vxx_tia_spg_sp_rij
			Vxx_vnt_sp_tia_bas_rij
			Vxx_vnt_sp_ex_df_bas_rij
			Vxx_vnt_sp_ex_df_fac_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin FUNCTION
		AsEgrCtl
		""
	/begin OUT_MEASUREMENT
			AsEgrCtl_NVM.Vxx_egr_byp_veh_dist_mem_NVM
			AsEgrCtl_NVM.Vxx_egr_byp_blk_val_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			AsEgrCtl_Esocoxx
			AsEgrCtl_Ecbssxx
			AsEgrCtl_Ecbscmd
			AsEgrCtl_Ecbvdxx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin FUNCTION
		AsEgrCtl_Ecbscmd
		""
	/begin DEF_CHARACTERISTIC
			Cbx_egr_byp_sta_1
			Cbx_egr_byp_sta_2
			Cbx_moni_id_18_sub_val
			Cxx_egr_byp_cmd_1
			Cxx_egr_byp_cmd_2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_egr_byp_act_req
			Vbx_egr_byp
			Vxx_egr_byp_pwm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin FUNCTION
		AsEgrCtl_Ecbssxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_egr_byp_tco_hys_low
			Ctb_y_egr_byp_tco_hys_low
			Cxx_egr_byp_dist_cmd
			Cxx_egr_byp_hys_tco_val_1
			Cxx_egr_byp_hys_tco_val_2
			Cxx_egr_byp_hys_tia_val_1
			Cxx_egr_byp_hys_tia_val_2
			Cxx_egr_byp_tco_hys_wid
			Cxx_t_egr_byp_dist_cmd
			Cmp_n_tqi_egr_byp_tco_hys_low
			Cbx_egr_byp_comb_mod_npu
			Cbx_egr_byp_comb_mod_pr
			Cbx_egr_byp_comb_mod_rij_pp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_egr_byp_act
			Vbx_egr_byp_cmd
			Vbx_egr_byp_dist_cmd
			Vxx_egr_byp_tco_hys_low
			Vxx_egr_byp_veh_dist
			Vbx_etun_egr_byp_req
			Vbx_egr_byp_mod_ena
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin FUNCTION
		AsEgrCtl_Ecbvdxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_diag_dsb_egr_byp_blk_cfm
			Cbx_egr_byp_obd_mask_cfm
			Cxx_dfdec_egr_byp_blk
			Cxx_dfinc_egr_byp_blk
			Cxx_down_egr_cool_temp_ftc
			Cxx_egr_byp_gear
			Cxx_egr_byp_h_n
			Cxx_egr_byp_h_thd_amp
			Cxx_egr_byp_h_thd_emtv_psn
			Cxx_egr_byp_h_thd_n
			Cxx_egr_byp_h_thd_tco
			Cxx_egr_byp_h_thd_tia_max
			Cxx_egr_byp_h_thd_tia_min
			Cxx_egr_byp_h_thd_tqi
			Cxx_egr_byp_h_tqi
			Cxx_egr_byp_l_n
			Cxx_egr_byp_l_thd_amp
			Cxx_egr_byp_l_thd_emtv_psn
			Cxx_egr_byp_l_thd_n
			Cxx_egr_byp_l_thd_tco
			Cxx_egr_byp_l_thd_tia_max
			Cxx_egr_byp_l_thd_tia_min
			Cxx_egr_byp_l_thd_tqi
			Cxx_egr_byp_l_tqi
			Cxx_egr_byp_n_ftc
			Cxx_egr_byp_stab_dly
			Cxx_egr_byp_tqi_ftc
			Cxx_frst_edge_dly
			Cxx_obd_dc_egr_byp_blk
			Cxx_snd_edge_dly
			Cxx_temp_dif_mv_max
			Cxx_temp_dif_mv_min
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_diag_egr_byp_req
			Vsx_egr_byp_blk_vld
			Vxx_egr_byp_blk_max
			Vxx_egr_byp_blk_min
			Vbx_df_egr_byp_blk
			Vbx_diag_byp_done
			Vbx_diag_byp_fail
			Vbx_diag_ena_egr_byp_blk
			Vbx_temp_dif_mv_clc_on
			Vbx_temp_max_det_on
			Vsx_diag_byp_stt
			Vxx_diag_byp_stab_dly
			Vxx_down_egr_cool_temp_dif_mv
			Vxx_down_egr_cool_temp_fil
			Vxx_down_egr_cool_temp_max
			Vxx_egr_byp_blk_val_mem
			Vxx_frst_edge_dly
			Vxx_snd_edge_dly
			Vxx_t_step
			Vxx_temp_frst_edge_bfr
			Vxx_temp_frst_edge_dif
			Vxx_temp_snd_edge_aftr
			Vxx_temp_snd_edge_dif
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/begin FUNCTION
		AsEgrCtl_Esocoxx
		""
	/begin OUT_MEASUREMENT
			Vxx_emtv_cmd_cut_npu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/begin FUNCTION
		AsExpSpt
		""
	/begin SUB_FUNCTION
			AsExpSpt_Eplxxxx
			AsExpSpt_Eplsprx
			AsExpSpt_Eplsrij
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/begin FUNCTION
		AsExpSpt_Eplsprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_ex_prs_sp_cor_pr
			Ctb_ex_prs_cor_ena_off_thd_pr
			Ctb_ex_prs_cor_ena_on_thd_pr
			Ctb_ex_prs_sp_pft_cor_pr
			Ctb_n_ex_prs_sp_amp_cor_pr
			Ctb_n_ex_prs_sp_bas_pr
			Ctb_n_ex_prs_sp_max_pr
			Ctb_n_ex_prs_sp_pft_cor_pr
			Ctb_n_ex_prs_sp_tia_cor_pr
			Ctb_tia_ex_prs_sp_cor_pr
			Ctb_tqi_ex_prs_sp_bas_pr
			Ctb_tqi_ex_prs_sp_pft_cor_pr
			Cmp_n_amp_ex_prs_sp_cor_pr
			Cmp_n_tia_ex_prs_sp_cor_pr
			Cmp_n_tqi_ex_prs_sp_bas_pr
			Cmp_ex_prs_sp_pft_cor_pr
			Ctp_ex_prs_cor_ena_off_thd_pr
			Ctp_ex_prs_cor_ena_on_thd_pr
			Ctp_ex_prs_sp_pft_cor_pr
			Ctp_n_ex_prs_sp_max_pr
			Ctb_amp_ex_prs_sp_tkof_pr
			Ctb_n_ex_prs_sp_amp_tkof_pr
			Cmp_n_amp_ex_prs_sp_tkof_pr
			Ctb_n_ex_prs_sp_tia_tkof_pr
			Ctb_tia_ex_prs_sp_tkof_pr
			Cmp_n_tia_ex_prs_sp_tkof_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ex_prs_lim_sp_cor_ena_pr
			Vxx_ex_prs_lim_amp_bas_sp_pr
			Vxx_ex_prs_lim_bas_sp_pr
			Vxx_ex_prs_lim_cor_sp_pr
			Vxx_ex_prs_lim_pft_cor_sp_pr
			Vxx_ex_prs_lim_tia_cor_pr
			Vxx_tia_ex_sp_pr
			Vxx_ex_prs_lim_amp_tkof_sp_pr
			Vxx_ex_prs_lim_tia_tkof_pr
			Vxx_ex_prs_lim_tkof_sp_pr
			Vxx_ex_prs_lim_max_sp_pr
			Vxx_ex_prs_lim_sp_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/begin FUNCTION
		AsExpSpt_Eplsrij
		""
	/begin DEF_CHARACTERISTIC
			Ctb_amp_ex_prs_sp_cor_rij
			Ctb_ex_cor_ena_off_thd_rij
			Ctb_ex_cor_ena_on_thd_rij
			Ctb_ex_prs_sp_pft_cor_rij
			Ctb_n_ex_prs_sp_amp_cor_rij
			Ctb_n_ex_prs_sp_bas_rij
			Ctb_n_ex_prs_sp_max_rij
			Ctb_n_ex_prs_sp_pft_cor_rij
			Ctb_n_ex_prs_sp_tia_cor_rij
			Ctb_tia_ex_prs_sp_cor_rij
			Ctb_tqi_ex_prs_sp_bas_rij
			Ctb_tqi_ex_prs_sp_pft_cor_rij
			Cmp_n_amp_ex_prs_sp_cor_rij
			Cmp_n_tia_ex_prs_sp_cor_rij
			Cmp_n_tqi_ex_prs_sp_bas_rij
			Cmp_ex_prs_sp_pft_cor_rij
			Ctp_ex_cor_ena_off_thd_rij
			Ctp_ex_cor_ena_on_thd_rij
			Ctp_ex_prs_sp_pft_cor_rij
			Ctp_n_ex_prs_sp_max_rij
			Cxx_tia_df_ex_prs_sp
			Ctb_ex_prs_sp_tkof_gear
			Ctd_ex_prs_sp_tkof_gear
			Cbx_ex_prs_sp_tkof_cfm
			Ctb_amp_ex_prs_sp_tkof_rij
			Ctb_n_ex_prs_sp_amp_tkof_rij
			Cmp_n_amp_ex_prs_sp_tkof_rij
			Ctb_n_ex_prs_sp_tia_tkof_rij
			Ctb_tia_ex_prs_sp_tkof_rij
			Cmp_n_tia_ex_prs_sp_tkof_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ex_prs_lim_sp_cor_ena_rij
			Vxx_ex_prs_lim_amp_bas_sp_rij
			Vxx_ex_prs_lim_bas_sp_rij
			Vxx_ex_prs_lim_cor_sp_rij
			Vxx_ex_prs_lim_max_sp_rij
			Vxx_ex_prs_lim_pft_cor_sp_rij
			Vxx_ex_prs_lim_sp_rij
			Vxx_ex_prs_lim_tia_cor_rij
			Vxx_tia_ex_sp_rij
			Vxx_ex_prs_lim_amp_tkof_sp_rij
			Vxx_ex_prs_lim_tia_tkof_rij
			Vxx_ex_prs_lim_tkof_sp_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/begin FUNCTION
		AsExpSpt_Eplxxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_ex_prs_thd_h
			Cxx_spg_prs_lih_neg_slop
			Cxx_spg_prs_lih_pos_slop
			Ctp_ex_prs_thd_h
			Cbx_ex_prs_max_lim_ena
			Cxx_ex_prs_lim_neg_slop
			Cxx_ex_prs_lim_pos_slop
			Cxx_ex_prs_lim_spg_err_thd
			Cxx_ex_prs_max_lim_ena_dly
			Cxx_ex_prs_max_lim_ofs
			Cxx_ex_prs_max_lim_spg_err_thd
			Cxx_ex_prs_lim_spg_err_ena_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_spg_prs_lih_ena
			Vxx_ex_prs_lim_max_sp
			Vxx_ex_prs_lim_sp
			Vsx_vnt_ex_prs_lim_req
			Vxx_ex_prs_cho
			Vxx_ex_prs_sp
			Vbx_ex_prs_lim_sp_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl
		""
	/begin OUT_MEASUREMENT
			AsMafCtl_NVM.Vxx_maf_reg_neg_err_val_NVM
			AsMafCtl_NVM.Vxx_maf_reg_neg_err_dyn_val_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			AsMafCtl_Airslop
			AsMafCtl_Amfcdmx
			AsMafCtl_Csecsoc
			AsMafCtl_Cuitsco
			AsMafCtl_Cuitspp
			AsMafCtl_Cuitspr
			AsMafCtl_Cuitsri
			AsMafCtl_Ecsocxx
			AsMafCtl_Eitcaes
			AsMafCtl_Emtvpsp
			AsMafCtl_Epolcco
			AsMafCtl_Epolcpp
			AsMafCtl_Epolcpr
			AsMafCtl_Epolcri
			AsMafCtl_Ezsocec
			AsMafCtl_Itcmdxx
			AsMafCtl_Itolcco
			AsMafCtl_Itolcpp
			AsMafCtl_Itolcpr
			AsMafCtl_Itolcri
			AsMafCtl_Itpspxx
			AsMafCtl_Itsxxxx
			AsMafCtl_Mafcxxx
			AsMafCtl_Ooitpsp
			AsMafCtl_Rfsocec
			AsMafCtl_Sfsocec
			AsMafCtl_Msocoxx
			AsMafCtl_Mfldvol
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Airslop
		""
	/begin OUT_MEASUREMENT
			Vbx_comb_mod_req_no_trs
			Vbx_comb_mod_req_trs
			Vbx_air_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Amfcdmx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_diag_dsb_maf_reg_neg_cfm
			Cbx_maf_reg_neg_obd_mask_cfm
			Cxx_amp_h_thd_mon
			Cxx_amp_l_thd_mon
			Cxx_dfdec_maf_reg_neg_err
			Cxx_dfinc_maf_reg_neg_err
			Cxx_ear_reg_h_thd
			Cxx_ear_reg_l_thd
			Cxx_gear_mon
			Cxx_maf_ftc_mon
			Cxx_maf_h_thd_mon
			Cxx_maf_l_thd_mon
			Cxx_n_ftc_mon
			Cxx_n_h_thd_mon
			Cxx_n_l_thd_mon
			Cxx_n_max_mon
			Cxx_n_min_mon
			Cxx_tco_h_thd_mon
			Cxx_tco_l_thd_mon
			Cxx_tia_max_h_thd_mon
			Cxx_tia_max_l_thd_mon
			Cxx_tia_min_h_thd_mon
			Cxx_tia_min_l_thd_mon
			Cxx_tqi_ftc_mon
			Cxx_tqi_h_thd_mon
			Cxx_tqi_l_thd_mon
			Cxx_tqi_max_mon
			Cxx_tqi_min_mon
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_maf_reg_neg_err
			Vbx_diag_ena_maf_reg_neg_err
			Vsx_maf_reg_neg_err_vld
			Vxx_maf_reg_neg_err_max
			Vxx_maf_reg_neg_err_min
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Csecsoc
		""
	/begin DEF_CHARACTERISTIC
			Cbx_egr_cut_ovn_slow_pp
			Cbx_egr_cut_ovn_slow_pr
			Cbx_egr_cut_ovn_slow_rij
			Cbx_it_pres_pp
			Cbx_it_pres_rij
			Ctb_x_egr_cut_tqi_thd_pp
			Ctb_x_egr_cut_tqi_thd_pr
			Ctb_x_egr_cut_tqi_thd_rij
			Ctb_y_egr_cut_tqi_thd_pp
			Ctb_y_egr_cut_tqi_thd_pr
			Ctb_y_egr_cut_tqi_thd_rij
			Cxx_egr_cut_n_thd_is_pr
			Cxx_egr_cut_n_thd_is_rij
			Cxx_egr_cut_t_thd_is_pp
			Cxx_egr_cut_t_thd_is_pr
			Cxx_egr_cut_t_thd_is_rij
			Cxx_egr_cut_tco_thd_is_pr
			Cxx_egr_cut_tqi_t_pp
			Cxx_egr_cut_tqi_t_pr
			Cxx_egr_cut_tqi_t_rij
			Cxx_egr_cut_vs_thd_is_pp
			Cxx_egr_cut_vs_thd_is_pr
			Cxx_egr_cut_vs_thd_is_rij
			Cxx_n_avg_h_thd_decl_pp
			Cxx_n_avg_h_thd_decl_pr
			Cxx_n_avg_h_thd_decl_rij
			Cxx_t_ovn_pp
			Cxx_t_ovn_pr
			Cxx_t_ovn_rij
			Cxx_tqi_l_thd_decl_pp
			Cxx_tqi_l_thd_decl_pr
			Cxx_tqi_l_thd_decl_rij
			Cmp_egr_cut_tqi_thd_pp
			Cmp_egr_cut_tqi_thd_pr
			Cmp_egr_cut_tqi_thd_rij
			Cbx_reg_cut_amp_dft_npu
			Cbx_reg_cut_pft_ms_dp_dft_npu
			Cbx_reg_cut_pft_ms_dp_dft_pp
			Cbx_reg_cut_pft_ms_dp_dft_rij
			Cbx_reg_cut_tco_dft_npu
			Cxx_egr_cut_n_thd_is_pp
			Cxx_egr_cut_amp_h_thd_pp
			Cxx_egr_cut_amp_h_thd_pr
			Cxx_egr_cut_amp_h_thd_rij
			Cxx_egr_cut_amp_l_thd_pp
			Cxx_egr_cut_amp_l_thd_pr
			Cxx_egr_cut_amp_l_thd_rij
			Cxx_egr_cut_n_ovs_h_thd_pp
			Cxx_egr_cut_n_ovs_h_thd_pr
			Cxx_egr_cut_n_ovs_h_thd_rij
			Cxx_egr_cut_n_ovs_l_thd_pp
			Cxx_egr_cut_n_ovs_l_thd_pr
			Cxx_egr_cut_n_ovs_l_thd_rij
			Cxx_egr_cut_n_uds_h_thd_pp
			Cxx_egr_cut_n_uds_h_thd_pr
			Cxx_egr_cut_n_uds_h_thd_rij
			Cxx_egr_cut_n_uds_l_thd_pp
			Cxx_egr_cut_n_uds_l_thd_pr
			Cxx_egr_cut_n_uds_l_thd_rij
			Cxx_egr_cut_tco_thd_is_pp
			Cxx_egr_cut_tco_h_thd_pp
			Cxx_egr_cut_tco_h_thd_pr
			Cxx_egr_cut_tco_h_thd_rij
			Cxx_egr_cut_tco_l_thd_pp
			Cxx_egr_cut_tco_l_thd_pr
			Cxx_egr_cut_tco_l_thd_rij
			Cxx_egr_cut_tco_thd_is_rij
			Cxx_egr_cut_tia_h_thd_pp
			Cxx_egr_cut_tia_h_thd_pr
			Cxx_egr_cut_tia_h_thd_rij
			Cxx_egr_cut_tia_l_thd_pp
			Cxx_egr_cut_tia_l_thd_pr
			Cxx_egr_cut_tia_l_thd_rij
			Cxx_egr_cut_tqi_hys_wid_pr
			Cxx_egr_cut_tqi_hys_wid_rij
			Cxx_egr_cut_tqi_tco_gear_thd
			Cxx_egr_cut_tqi_tco_n_thd
			Ctb_x_egr_cut_tqi_tco_pr
			Ctb_x_egr_cut_tqi_tco_rij_pp
			Ctp_egr_cut_tqi_tco_pr
			Ctp_egr_cut_tqi_tco_rij_pp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_egr_cut_ovn_slow
			Vbx_it_pres
			Vbx_moni_as_req
			Vxx_egr_cut_t_thd_is
			Vxx_egr_cut_tqi_t
			Vxx_egr_cut_tqi_thd
			Vxx_egr_cut_vs_thd_is
			Vxx_n_decl
			Vxx_t_ovn
			Vxx_tqi_ovn
			Vbx_reg_cut_amp_dft
			Vbx_reg_cut_no_npu
			Vbx_reg_cut_no_pr
			Vbx_reg_cut_npu
			Vbx_reg_cut_pft_ms_dp_dft
			Vbx_reg_cut_tco_dft
			Vxx_egr_cut_n_thd_is
			Vxx_egr_cut_amp_h_thd
			Vxx_egr_cut_amp_l_thd
			Vxx_egr_cut_n_ovs_h_thd
			Vxx_egr_cut_n_ovs_l_thd
			Vxx_egr_cut_n_uds_h_thd
			Vxx_egr_cut_n_uds_l_thd
			Vxx_egr_cut_tco_thd_is
			Vxx_egr_cut_tco_h_thd
			Vxx_egr_cut_tco_l_thd
			Vxx_egr_cut_tia_h_thd
			Vxx_egr_cut_tia_l_thd
			Vxx_egr_cut_tqi_hys_wid
			Vxx_egr_cut_tqi_tco_cor
			Vbx_egr_cut_tqi_tco_ena
			Vxx_egr_cut_tqi_tco_pr
			Vxx_egr_cut_tqi_tco_rij_pp
			Vbx_reg_cut_rij_pp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Cuitsco
		""
	/begin DEF_CHARACTERISTIC
			Cxx_emtv_sp_max_neg_slop
			Cxx_emtv_sp_max_pos_slop
			Cxx_sat_thd_dft_vlv
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_sat_clos_req_co
			Vbx_emtv_sp_max_slop_on
			Vxx_egr_pwm_rep_decl
			Vxx_emtv_sp_max_co
			Vsx_it_sat_co
			Vsx_it_use_drg_so
			Vxx_vnt_sge_emtv_req
			Vxx_it_psn_max_val
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Cuitspp
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_emtv_sp_max_pp
			Ctb_x_it_psn_max_pp
			Ctb_x_vnt_sge_emtv_req_pp
			Ctb_y_emtv_sp_max_pp
			Ctb_y_it_psn_max_pp
			Cmp_n_tqi_emtv_sp_max_pp
			Cmp_n_tqi_it_psn_max_pp
			Ctp_n_vnt_sge_emtv_req_pp
			Cbx_emtv_sat_clos_req_pp
			Csx_it_ena_pp
			Csx_it_sat_pp
			Cxx_egr_pwm_rep_decl_pp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_sat_clos_req_pp
			Vsx_it_ena_pp
			Vsx_it_sat_pp
			Vxx_egr_pwm_rep_decl_pp
			Vxx_emtv_sp_max_pp
			Vxx_it_psn_max_val_pp
			Vxx_vnt_sge_emtv_req_pp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Cuitspr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_emtv_sp_max_pr
			Ctb_x_it_psn_max_pr
			Ctb_x_vnt_sge_emtv_req_pr
			Ctb_y_emtv_sp_max_pr
			Ctb_y_it_psn_max_pr
			Cmp_n_tqi_emtv_sp_max_pr
			Cmp_n_tqi_it_psn_max_pr
			Ctp_n_vnt_sge_emtv_req_pr
			Cbx_emtv_sat_clos_req_pr
			Csx_it_ena_pr
			Csx_it_sat_pr
			Cxx_egr_pwm_rep_decl_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_sat_clos_req_pr
			Vsx_it_ena_pr
			Vsx_it_sat_pr
			Vxx_egr_pwm_rep_decl_pr
			Vxx_emtv_sp_max_pr
			Vxx_it_psn_max_val_pr
			Vxx_vnt_sge_emtv_req_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Cuitsri
		""
	/begin DEF_CHARACTERISTIC
			Cbx_emtv_sat_clos_req_rij
			Csx_it_ena_rij
			Cxx_egr_pwm_rep_decl_rij
			Cmp_n_tqi_emtv_sp_max_rij
			Ctb_x_emtv_sp_max_rij
			Ctb_y_emtv_sp_max_rij
			Csx_it_sat_rij
			Ctb_x_it_psn_max_rij
			Ctb_x_vnt_sge_emtv_req_rij
			Ctb_y_it_psn_max_rij
			Cmp_n_tqi_it_psn_max_rij
			Ctp_n_vnt_sge_emtv_req_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_sat_clos_req_rij
			Vsx_it_ena_rij
			Vxx_egr_pwm_rep_decl_rij
			Vxx_emtv_sp_max_rij
			Vsx_it_sat_rij
			Vxx_it_psn_max_val_rij
			Vxx_vnt_sge_emtv_req_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Ecsocxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_reg_cut_1_ovr_msk
			Cbx_reg_cut_2_ovr_msk
			Cbx_reg_cut_3_ovr_msk
			Cbx_vnt_sge_emtv_ctl_ena
			Cbx_vnt_sge_emtv_tia_msk
			Cxx_dly_is_val
			Cxx_dly_ovr_val
			Cxx_emtv_fail_ctr_max
			Cxx_sge_emtv_tia_thd
			Cxx_ton_dly_is_val
			Cxx_ton_dly_ovr_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_opn_fail_ena
			Vbx_reg_cut_ovr_ecm
			Vsx_air_reg_vld
			Vsx_egr_off
			Vsx_reg_cut_ovr
			Vsx_reg_cut_sge
			Vsx_slo_clos_req
			Vsx_slo_clos_req_ovr
			Vxx_emtv_fail_ctr_in
			Vxx_emtv_fail_ctr_out
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Eitcaes
		""
	/begin DEF_CHARACTERISTIC
			Cxx_emtv_psn_clos
			Cxx_emtv_sp_lim
			Cxx_neg_reg_clos_req
			Cxx_neg_slo_clos_req
			Cxx_pos_reg_clos_req
			Cxx_pos_slo_clos_req
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_it_sp_slop_on
			Vxx_emtv_it_sp
			Vxx_emtv_psn_clos_neg_slop
			Vxx_emtv_psn_clos_pos_slop
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Emtvpsp
		""
	/begin DEF_CHARACTERISTIC
			Cxx_emtv_sp_min
			Cxx_emtv_sp_min_last
			Cxx_emtv_sp_max_last
			Cxx_emtv_opn_fail_val
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_sp_slop_on
			Vxx_emtv_sp
			Vxx_emtv_sp_lim
			Vxx_emtv_sp_on_off_sat_1
			Vxx_emtv_psn_clos_ovr_neg_slop
			Vxx_emtv_psn_clos_ovr_pos_slop
			Vxx_emtv_sp_ecm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Epolcco
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pcmd_neg_slope
			Cxx_pcmd_pos_slope
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_emtv_psn_sp_cho_slop_on
			Vxx_emtv_psn_sp_cho
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Epolcpp
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_maf_sp_emtv_psn_sp_pp
			Ctb_y_maf_sp_emtv_psn_sp_pp
			Cmp_n_maf_sp_emtv_psn_sp_pp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_emtv_psn_sp_pp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Epolcpr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_maf_sp_emtv_psn_sp_pr
			Ctb_y_maf_sp_emtv_psn_sp_pr
			Cmp_n_maf_sp_emtv_psn_sp_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_emtv_psn_sp_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Epolcri
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_maf_sp_emtv_psn_sp_rij
			Ctb_y_maf_sp_emtv_psn_sp_rij
			Cmp_n_maf_sp_emtv_psn_sp_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_emtv_psn_sp_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Ezsocec
		""
	/begin DEF_CHARACTERISTIC
			Cbx_is_t_ovs_slo
			Ctb_x_egr_cut_dly_aftr_sta
			Cxx_egr_cut_t_thd_is_cutt_cln
			Cxx_egr_cut_tia_h_thd
			Cxx_egr_cut_tia_l_thd
			Ctp_egr_cut_dly_aftr_sta
			Cbx_egr_cutt_cln_cfm
			Cbx_emtv_blk_clos_cfm
			Cbx_emtv_blk_opn_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_reg_cut_aftr_sta
			Vsx_reg_cut_amp
			Vsx_reg_cut_drgn_sta
			Vsx_reg_cut_fast_acel
			Vsx_reg_cut_is_t_ovs
			Vsx_reg_cut_n_avg_ovs
			Vsx_reg_cut_n_avg_uds
			Vsx_reg_cut_tco_thd
			Vsx_slo_clos_req_is
			Vsx_reg_cut_tia_thd
			Vsx_reg_cut_1
			Vbx_emtv_opn_fail_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Itcmdxx
		""
	/begin OUT_MEASUREMENT
			Vxx_it_psn_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Itolcco
		""
	/begin DEF_CHARACTERISTIC
			Cxx_it_sat_val_neg_slop
			Cxx_it_sat_val_pos_slop
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_it_sat_val_slop_on
			Vxx_it_sat_val
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Itolcpp
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_it_sat_cor_amp_pp
			Ctb_x_it_sat_cor_tco_pp
			Ctb_x_it_sat_cor_tia_pp
			Ctb_x_it_sat_val_bas_pp
			Ctb_x_m_it_sat_cor_amp_pp
			Ctb_x_m_it_sat_cor_tco_pp
			Ctb_x_m_it_sat_cor_tia_pp
			Ctb_y_it_sat_val_bas_pp
			Ctb_y_m_it_sat_cor_amp_pp
			Ctb_y_m_it_sat_cor_tco_pp
			Ctb_y_m_it_sat_cor_tia_pp
			Cmp_it_sat_cor_amp_pp
			Cmp_it_sat_cor_tco_pp
			Cmp_it_sat_cor_tia_pp
			Cmp_it_sat_val_bas_pp
			Ctp_it_sat_cor_amp_pp
			Ctp_it_sat_cor_tco_pp
			Ctp_it_sat_cor_tia_pp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_it_sat_sp_ena_pp
			Vxx_it_sat_cor_amp_pp
			Vxx_it_sat_cor_tco_pp
			Vxx_it_sat_cor_tco_tia_pp
			Vxx_it_sat_cor_tia_pp
			Vxx_it_sat_val_bas_pp
			Vxx_it_sat_val_pp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Itolcpr
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_it_sat_cor_amp_pr
			Ctb_x_it_sat_cor_tco_pr
			Ctb_x_it_sat_cor_tia_pr
			Ctb_x_it_sat_val_bas_pr
			Ctb_x_m_it_sat_cor_amp_pr
			Ctb_x_m_it_sat_cor_tco_pr
			Ctb_x_m_it_sat_cor_tia_pr
			Ctb_y_it_sat_val_bas_pr
			Ctb_y_m_it_sat_cor_amp_pr
			Ctb_y_m_it_sat_cor_tco_pr
			Ctb_y_m_it_sat_cor_tia_pr
			Cmp_n_tqi_it_sat_cor_amp_pr
			Cmp_n_tqi_it_sat_cor_tco_pr
			Cmp_n_tqi_it_sat_cor_tia_pr
			Cmp_n_tqi_it_sat_val_bas_pr
			Ctp_it_sat_cor_amp_pr
			Ctp_it_sat_cor_tco_pr
			Ctp_it_sat_cor_tia_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_it_sat_sp_ena_pr
			Vxx_it_sat_cor_amp_pr
			Vxx_it_sat_cor_tco_pr
			Vxx_it_sat_cor_tco_tia_pr
			Vxx_it_sat_cor_tia_pr
			Vxx_it_sat_val_bas_pr
			Vxx_it_sat_val_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Itolcri
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_it_sat_cor_amp_rij
			Ctb_x_it_sat_cor_tco_rij
			Ctb_x_it_sat_cor_tia_rij
			Ctb_x_it_sat_val_bas_rij
			Ctb_x_m_it_sat_cor_amp_rij
			Ctb_x_m_it_sat_cor_tco_rij
			Ctb_x_m_it_sat_cor_tia_rij
			Ctb_y_it_sat_val_bas_rij
			Ctb_y_m_it_sat_cor_amp_rij
			Ctb_y_m_it_sat_cor_tco_rij
			Ctb_y_m_it_sat_cor_tia_rij
			Cmp_n_tqi_it_sat_cor_amp_rij
			Cmp_n_tqi_it_sat_cor_tco_rij
			Cmp_n_tqi_it_sat_cor_tia_rij
			Cmp_n_tqi_it_sat_val_bas_rij
			Ctp_it_sat_cor_amp_rij
			Ctp_it_sat_cor_tco_rij
			Ctp_it_sat_cor_tia_rij
			Cxx_n_avg_it_sat_sp_ena
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_it_sat_sp_ena_rij
			Vxx_it_sat_cor_amp_rij
			Vxx_it_sat_cor_tco_rij
			Vxx_it_sat_cor_tco_tia_rij
			Vxx_it_sat_cor_tia_rij
			Vxx_it_sat_val_bas_rij
			Vxx_it_sat_val_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Itpspxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_conv_egr_it_psn
			Cxx_it_psn_min
			Cxx_it_psn_off
			Cxx_it_psn_off_slop_neg
			Cxx_it_psn_off_slop_pos
			Cxx_it_sp_neg_slo
			Cxx_it_sp_pos_slo
			Ctp_conv_egr_it_psn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_ol_sat_it_cmd_slop_on
			Vxx_it_psn_reg_ol_sp
			Vxx_it_wit_emtv_cmd
			Vxx_ol_sat_it_cmd
			Vbx_it_psn_reg_ol_sp_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Itsxxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_moni_id_11_req
			Cxx_emtv_sat_hys_pos
			Cbx_moni_id_10_it_sat
			Cxx_emtv_sat_hys_neg
			Cxx_emtv_sat_thd_supl
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_emtv_pos_sat
			Vsx_it_use
			Vxx_emtv_sp_max
			Vsx_it_air_reg
			Vsx_it_sat_co_swt
			Vsx_it_sat_ena
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Mafcxxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_itcl_efl_ini_ena
			Cbx_itcl_erg_ini_ena
			Cbx_itol_efl_ini_ena
			Cbx_itol_erg_ini_ena
			Cbx_moni_maf_reg_off
			Cbx_npu_off_ini_ena
			Ctb_x_maf_reg_fac_pft_cor
			Cxx_dt1_maf_reg_fac_neg
			Cxx_dt1_maf_reg_fac_pos
			Cxx_dt1_maf_reg_fac_win
			Cxx_dt1_maf_reg_t_fac
			Cxx_dt1_maf_reg_win_neg
			Cxx_dt1_maf_reg_win_pos
			Cxx_ear_i_rep_cut_1
			Cxx_ear_i_rep_cut_2
			Cxx_ear_i_rep_cut_3
			Cxx_ear_i_rep_cut_ovr
			Cxx_ear_i_rep_itcl_efl
			Cxx_ear_i_rep_itcl_erg
			Cxx_ear_i_rep_itol_efl
			Cxx_ear_i_rep_itol_erg
			Cxx_egr_maf_reg_max_lim
			Cxx_egr_maf_reg_max_lim_air_reg
			Cxx_egr_maf_reg_min_lim_air_reg
			Cxx_maf_i_reg_ini
			Cxx_maf_i_reg_neg_fac
			Cxx_maf_i_reg_neg_fac_air_reg
			Cxx_maf_i_reg_pos_fac
			Cxx_maf_i_reg_pos_fac_air_reg
			Cxx_maf_i_reg_win_fac
			Cxx_maf_i_reg_win_fac_air_reg
			Cxx_maf_i_reg_win_neg
			Cxx_maf_i_reg_win_neg_air_reg
			Cxx_maf_i_reg_win_pos
			Cxx_maf_i_reg_win_pos_air_reg
			Cxx_maf_p_reg_neg_fac
			Cxx_maf_p_reg_neg_fac_air_reg
			Cxx_maf_p_reg_pos_fac
			Cxx_maf_p_reg_pos_fac_air_reg
			Cxx_maf_p_reg_win_fac
			Cxx_maf_p_reg_win_fac_air_reg
			Cxx_maf_p_reg_win_neg
			Cxx_maf_p_reg_win_neg_air_reg
			Cxx_maf_p_reg_win_pos
			Cxx_maf_p_reg_win_pos_air_reg
			Cxx_maf_reg_fac_cor_min
			Ctp_maf_reg_fac_pft_cor
			Ctp_maf_reg_fac_tia_tco_cor
			Ctb_x_maf_reg_fac_tia_tco_cor
			Cbx_maf_reg_fac_var_cfm
			Cxx_ear_i_rep_cut_sge
			Cxx_ear_i_rep_emtv_opn_fail
			Cbx_thr_on_off_cfm
			Ctb_x_egr_maf_reg_min_lim
			Ctb_y_egr_maf_reg_min_lim
			Cmp_n_tqi_egr_maf_reg_min_lim
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_dt1_maf_reg_damp_fac
			Vxx_maf_err
			Vxx_maf_i_reg
			Vxx_maf_i_reg_neg_fac
			Vxx_maf_i_reg_out
			Vxx_maf_i_reg_pos_fac
			Vxx_maf_i_reg_win_fac
			Vxx_maf_i_reg_win_neg
			Vxx_maf_p_reg
			Vxx_maf_p_reg_neg_fac
			Vxx_maf_p_reg_out
			Vxx_maf_p_reg_pos_fac
			Vxx_maf_p_reg_win_fac
			Vxx_maf_p_reg_win_neg
			Vxx_maf_p_reg_win_pos
			Vxx_maf_pi_reg_out
			Vxx_maf_reg_fac_cor
			Vxx_maf_reg_fac_tia_tco_cor
			Vxx_maf_i_reg_win_pos
			Vxx_it_psn_ocl_hys_dt1
			Vxx_it_psn_ocl_hys_dt1_swt
			Vxx_maf_reg_emtv_psn_out_1
			Vxx_maf_reg_emtv_psn_out_red
			Vbx_ear_out_lim_hit_max
			Vbx_ear_out_lim_hit_min
			Vbx_maf_i_reg_frz
			Vbx_maf_p_reg_on
			Vbx_maf_reg_off
			Vxx_maf_i_reg_1
			Vxx_maf_i_reg_2
			Vbx_maf_i_reg_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Mfldvol
		""
	/begin OUT_MEASUREMENT
			Vbx_maf_sp_npu_slop_on
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Msocoxx
		""
	/begin OUT_MEASUREMENT
			Vxx_it_cmd_cut_npu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		AsMafCtl_Ooitpsp
		""
	/begin OUT_MEASUREMENT
			Vxx_it_psn_ocl_hys
			Vxx_it_psn_on_off_cmd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Rfsocec
		""
	/begin DEF_CHARACTERISTIC
			Cbx_egr_cut_it_clos
			Cxx_it_clos_cut_thd
			Cbx_it_clos_slow
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_reg_cut_2
			Vsx_reg_cut_emtv_diag
			Vsx_reg_cut_it_diag
			Vsx_reg_cut_vnt_reg_err
			Vsx_reg_cut_it_clos
			Vbx_clos_it_ena
			Vbx_reg_cut_pft_req
			Vbx_slow_clos_req_it
			Vsx_air_reg_2_vld
			Vbx_reg_cut_emtv_diag_2
			Vbx_reg_cut_maf_reg_diag
			Vbx_reg_cut_maf_reg_diag_2
			Vbx_reg_cut_pft_req_2
			Vbx_reg_cut_it_diag_2
			Vbx_reg_cut_vnt_reg_err_2
			Vbx_clos_it_ena_egr_wpmp
			Vbx_clos_it_ena_emtv
			Vbx_reg_cut_egr_wpmp_diag
			Vbx_reg_cut_egr_wpmp_diag_2
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/begin FUNCTION
		AsMafCtl_Sfsocec
		""
	/begin OUT_MEASUREMENT
			Vsx_reg_cut_3
			Vsx_air_reg_3_vld
			Vbx_reg_cut_3_ecm
			Vbx_reg_cut_3_spc_npu
			Vbx_reg_cut_amp_dft_raw
			Vbx_reg_cut_egr_byp_dft_raw
			Vbx_reg_cut_gear_dft_raw
			Vbx_reg_cut_maf_dft_raw
			Vbx_reg_cut_pft_ms_dft_raw
			Vbx_reg_cut_tco_dft_raw
			Vbx_reg_cut_tia_dft_raw
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt
		""
	/begin SUB_FUNCTION
			AsMafSpt_Mafsbcx
			AsMafSpt_Mafscox
			AsMafSpt_Mafsppx
			AsMafSpt_Mafsprx
			AsMafSpt_Mafsrix
			AsMafSpt_Mafsnpu
			AsMafSpt_Mafstqx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt_Mafsbcx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_maf_cor_egr_byp_on
			Ctb_y_maf_cor_egr_byp_on
			Cmp_n_tqi_maf_cor_byp_on
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_maf_sp_cor_byp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt_Mafscox
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_maf_max_lim
			Ctb_y_maf_max_lim
			Cxx_maf_lim_min
			Cxx_maf_sp_slop_neg
			Cxx_maf_sp_slop_neg_npu
			Cxx_maf_sp_slop_pos
			Cxx_maf_sp_slop_pos_npu
			Cmp_n_tqi_maf_max_lim
			Cxx_pft_asd_rgn_maf_sp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_maf_stat_sp_slop_on
			Vxx_maf_sp
			Vxx_maf_sp_lim
			Vxx_maf_sp_lim_ecm
			Vxx_maf_sp_ecm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt_Mafsnpu
		""
	/begin OUT_MEASUREMENT
			Vxx_maf_sp_npu
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt_Mafsppx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_m_maf_cor_amp_pp
			Ctb_x_m_maf_cor_tco_pp
			Ctb_x_m_maf_cor_tia_pp
			Ctb_x_m_maf_cor_tkof_pp
			Ctb_x_maf_cor_amp_pp
			Ctb_x_maf_cor_prs_ratio_pp
			Ctb_x_maf_cor_tco_pp
			Ctb_x_maf_cor_tia_pp
			Ctb_x_maf_cor_tkof_pp
			Ctb_x_maf_sp_cor_prs_pp
			Ctb_x_maf_sp_gear_1_pp
			Ctb_x_maf_sp_gear_2_pp
			Ctb_x_maf_sp_gear_3_pp
			Ctb_x_maf_sp_gear_4_pp
			Ctb_x_maf_sp_gear_5_pp
			Ctb_x_maf_sp_gear_6_pp
			Ctb_y_m_maf_cor_amp_pp
			Ctb_y_m_maf_cor_tco_pp
			Ctb_y_m_maf_cor_tia_pp
			Ctb_y_m_maf_cor_tkof_pp
			Ctb_y_maf_sp_cor_prs_pp
			Ctb_y_maf_sp_gear_1_pp
			Ctb_y_maf_sp_gear_2_pp
			Ctb_y_maf_sp_gear_3_pp
			Ctb_y_maf_sp_gear_4_pp
			Ctb_y_maf_sp_gear_5_pp
			Ctb_y_maf_sp_gear_6_pp
			Cmp_n_tqi_maf_cor_amp_pp
			Cmp_n_tqi_maf_cor_tco_pp
			Cmp_n_tqi_maf_cor_tia_pp
			Cmp_n_tqi_maf_cor_tkof_pp
			Cmp_n_tqi_maf_sp_cor_prs_pp
			Cmp_n_tqi_maf_sp_gear_1_pp
			Cmp_n_tqi_maf_sp_gear_2_pp
			Cmp_n_tqi_maf_sp_gear_3_pp
			Cmp_n_tqi_maf_sp_gear_4_pp
			Cmp_n_tqi_maf_sp_gear_5_pp
			Cmp_n_tqi_maf_sp_gear_6_pp
			Ctp_maf_cor_amp_pp
			Ctp_maf_cor_prs_ratio_pp
			Ctp_maf_cor_tco_pp
			Ctp_maf_cor_tia_pp
			Ctp_maf_cor_tkof_pp
			Cxx_maf_sp_bas_slop_neg_pp
			Cxx_maf_sp_bas_slop_pos_pp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_maf_cor_amp_pp
			Vxx_maf_cor_byp_pp
			Vxx_maf_cor_pft_ovp_pp
			Vxx_maf_cor_tco_pp
			Vxx_maf_cor_tia_pp
			Vxx_maf_cor_tkof_pp
			Vxx_maf_sp_bas_pp
			Vxx_maf_sp_pp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt_Mafsprx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_m_maf_cor_amp_pr
			Ctb_x_m_maf_cor_tco_pr
			Ctb_x_m_maf_cor_tia_pr
			Ctb_x_maf_cor_amp_pr
			Ctb_x_maf_cor_prs_ratio_pr
			Ctb_x_maf_cor_tco_pr
			Ctb_x_maf_cor_tia_pr
			Ctb_x_maf_sp_cor_prs_pr
			Ctb_x_maf_sp_pr
			Ctb_y_m_maf_cor_amp_pr
			Ctb_y_m_maf_cor_tco_pr
			Ctb_y_m_maf_cor_tia_pr
			Ctb_y_maf_sp_cor_prs_pr
			Ctb_y_maf_sp_pr
			Cmp_n_tqi_maf_cor_amp_pr
			Cmp_n_tqi_maf_cor_tco_pr
			Cmp_n_tqi_maf_cor_tia_pr
			Cmp_n_tqi_maf_sp_cor_prs_pr
			Cmp_n_tqi_maf_sp_pr
			Ctp_maf_cor_amp_pr
			Ctp_maf_cor_prs_ratio_pr
			Ctp_maf_cor_tco_pr
			Ctp_maf_cor_tia_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_maf_cor_amp_pr
			Vxx_maf_cor_pft_ovp_pr
			Vxx_maf_cor_tco_pr
			Vxx_maf_cor_tia_pr
			Vxx_maf_sp_bas_pr
			Vxx_maf_sp_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt_Mafsrix
		""
	/begin DEF_CHARACTERISTIC
			Ctb_x_m_maf_cor_amp_rij
			Ctb_x_m_maf_cor_tco_rij
			Ctb_x_m_maf_cor_tia_rij
			Ctb_x_maf_cor_amp_rij
			Ctb_x_maf_cor_prs_ratio_rij
			Ctb_x_maf_cor_tco_rij
			Ctb_x_maf_cor_tia_rij
			Ctb_x_maf_sp_cor_prs_rij
			Ctb_x_maf_sp_gear_1_rij
			Ctb_x_maf_sp_gear_2_rij
			Ctb_x_maf_sp_gear_3_rij
			Ctb_x_maf_sp_gear_4_rij
			Ctb_x_maf_sp_gear_5_rij
			Ctb_x_maf_sp_gear_6_rij
			Ctb_y_m_maf_cor_amp_rij
			Ctb_y_m_maf_cor_tco_rij
			Ctb_y_m_maf_cor_tia_rij
			Ctb_y_maf_sp_cor_prs_rij
			Ctb_y_maf_sp_gear_1_rij
			Ctb_y_maf_sp_gear_2_rij
			Ctb_y_maf_sp_gear_3_rij
			Ctb_y_maf_sp_gear_4_rij
			Ctb_y_maf_sp_gear_5_rij
			Ctb_y_maf_sp_gear_6_rij
			Cmp_n_tqi_maf_cor_amp_rij
			Cmp_n_tqi_maf_cor_tco_rij
			Cmp_n_tqi_maf_cor_tia_rij
			Cmp_n_tqi_maf_sp_gear_1_rij
			Cmp_n_tqi_maf_sp_gear_2_rij
			Cmp_n_tqi_maf_sp_gear_3_rij
			Cmp_n_tqi_maf_sp_gear_4_rij
			Cmp_n_tqi_maf_sp_gear_5_rij
			Cmp_n_tqi_maf_sp_gear_6_rij
			Ctp_maf_cor_amp_rij
			Ctp_maf_cor_prs_ratio_rij
			Ctp_maf_cor_tco_rij
			Ctp_maf_cor_tia_rij
			Cmp_n_tqi_maf_sp_cor_prs_rij
			Cxx_n_avg_maf_sp_ena
			Ctb_x_maf_sp_gear
			Ctd_maf_sp_gear
			Cxx_maf_sp_bas_slop_neg_rij
			Cxx_maf_sp_bas_slop_pos_rij
			Ctb_x_m_maf_cor_tkof_rij
			Ctb_y_m_maf_cor_tkof_rij
			Cmp_n_tqi_maf_cor_tkof_rij
			Ctb_x_maf_cor_tkof_rij
			Ctp_maf_cor_tkof_rij
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_maf_cor_amp_rij
			Vxx_maf_cor_byp_rij
			Vxx_maf_cor_pft_ovp_rij
			Vxx_maf_cor_tco_rij
			Vxx_maf_cor_tia_rij
			Vxx_maf_sp_bas_rij
			Vxx_maf_sp_rij
			Vxx_maf_cor_tkof_rij
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asmafspt.xml' */
/begin FUNCTION
		AsMafSpt_Mafstqx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_egr_fisa_cor_cfm
			Cbx_egr_tqi_cfm
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_egr_tqi
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asspvcoo.xml' */
/begin FUNCTION
		AsSpvCoo
		""
	/begin SUB_FUNCTION
			AsSpvCoo_Asconpu_stbxxd
			AsSpvCoo_Econpux_xxxxxd
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asspvcoo.xml' */
/begin FUNCTION
		AsSpvCoo_Asconpu_stbxxd
		""
	/begin OUT_MEASUREMENT
			Vbx_npu_mod_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'asspvcoo.xml' */
/begin FUNCTION
		AsSpvCoo_Econpux_xxxxxd
		""
	/begin OUT_MEASUREMENT
			Vxx_emtv_sp_on_off
			Vxx_emtv_sp_on_off_ecm
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl
		""
	/begin SUB_FUNCTION
			AtPcbCtl_Efiactx
			AtPcbCtl_Lposact
			AtPcbCtl_Tregcnf
			AtPcbCtl_Tregdgn
			AtPcbCtl_Tregfms
			AtPcbCtl_Tregspv
			AtPcbCtl_Tregspx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl_Efiactx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_efi_off_pr_cfm
			Cxx_fms_efi_off_asd_utp_min_h
			Cxx_fms_efi_off_asd_utp_min_l
			Cxx_fms_efi_off_csm_min_h_pr
			Cxx_fms_efi_off_csm_min_l_pr
			Cxx_fms_efi_off_n_min_pr
			Cxx_fms_efi_off_utp_min_h_pr
			Cxx_fms_efi_off_utp_min_l_pr
			Cxx_fms_efi_off_n_tout
			Cxx_fms_efi_off_nul_inj_tout
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_efi_off_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl_Lposact
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_lpos_off_pr_cfm
			Cxx_fms_lpos_off_asd_utp_min_h
			Cxx_fms_lpos_off_asd_utp_min_l
			Cxx_fms_lpos_off_csm_min_h_pr
			Cxx_fms_lpos_off_csm_min_l_pr
			Cxx_fms_lpos_off_n_min_pr
			Cxx_fms_lpos_off_utp_min_h_pr
			Cxx_fms_lpos_off_utp_min_l_pr
			Cxx_fms_lpos_off_n_tout
			Cxx_fms_lpos_off_nul_inj_tout
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_fms_lpos_off_pr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl_Tregcnf
		""
	/begin DEF_CHARACTERISTIC
			Cbx_spc_cor_pr_cho
			Ctb_fms_amp_fac_pr
			Ctb_fms_ms_dp_fac_pr
			Ctb_fms_tia_fac_pr
			Ctb_maf_flp_maf_err_fac_pr
			Ctb_n_fms_amp_cor_pr
			Ctb_n_fms_ms_dp_cor_pr
			Ctb_n_fms_tia_cor_pr
			Ctb_tqi_fms_amp_cor_pr
			Ctb_tqi_fms_ms_dp_cor_pr
			Ctb_tqi_fms_tia_cor_pr
			Ctb_tt_fms_efi_max_pr
			Cxx_fms_flp_maf_n_max_fac_pr
			Cxx_fms_flp_maf_tqi_max_fac_pr
			Cxx_pft_rgn_asd_efi_max
			Cxx_pft_rgn_asd_efi_min
			Cxx_pft_rgn_asd_flp_max
			Cxx_pft_rgn_asd_flp_min
			Cmp_fms_amp_cor_pr
			Cmp_fms_ms_dp_cor_pr
			Cmp_fms_tia_cor_pr
			Cmp_n_tqi_fms_flp_max_pr
			Cmp_tt_egaf_fms_efi_max_pr
			Ctp_fms_amp_fac_pr
			Ctp_fms_ms_dp_fac_pr
			Ctp_fms_tia_fac_pr
			Ctp_pft_vnt_err_reg_max
			Cmp_fms_efi_maf_err_fac_pr
			Cbx_fms_efi_max_cho
			Cbx_pft_utp_reg_actr_cho
			Cmp_fms_efi_min_pr
			Cmp_fms_flp_maf_err_fac_pr
			Cmp_fms_flp_min_pr
			Cmp_n_tqi_fms_efi_max_pr
			Cmp_n_tqi_lpos_efi_exo_fac
			Ctb_egaf_fms_efi_max_pr
			Ctb_n_fms_efi_maf_err_fac_pr
			Ctb_n_fms_efi_max_pr
			Ctb_n_fms_efi_min_pr
			Ctb_n_fms_flp_maf_err_fac_pr
			Ctb_n_fms_flp_max_pr
			Ctb_n_fms_flp_min_pr
			Ctb_pft_utp_inj_fms_wup_slop
			Ctb_n_lpos_efi_exo_fac
			Ctb_pft_vnt_err_reg
			Ctb_tqi_fms_efi_max_pr
			Ctb_tqi_fms_efi_min_pr
			Ctb_tqi_fms_flp_max_pr
			Ctb_tqi_fms_flp_min_pr
			Ctb_tqi_lpos_efi_exo_fac
			Ctp_pft_utp_inj_fms_wup_slop
			Cxx_fms_efi_maf_err_ini
			Cxx_fms_efi_maf_err_t_fil
			Cxx_fms_efi_maf_n_max_fac_pr
			Cxx_fms_efi_maf_tqi_max_fac_pr
			Cxx_fms_flp_maf_err_ini
			Cxx_fms_flp_maf_err_t_fil
			Ctb_maf_efi_maf_err_fac_pr
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_efi_max_pr
			Vxx_efi_min_pr
			Vxx_flp_max_pr
			Vxx_flp_min_pr
			Vxx_fms_amp_fac_pr
			Vxx_fms_cor_pr
			Vxx_fms_efi_flp_cor
			Vxx_fms_ms_dp_fac_pr
			Vxx_fms_tia_fac_pr
			Vxx_pft_sat_pr
			Vxx_fms_efi_maf_err_fil
			Vxx_fms_efi_max_pr
			Vxx_fms_flp_maf_err_fil
			Vxx_fms_flp_max_pr
			Vxx_lpos_efi_exo_fac
			Vxx_fms_efi_min_pr
			Vxx_fms_flp_min_pr
			Vxx_fms_cor_flp_pr
			Vxx_pft_efi_ff
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl_Tregdgn
		""
	/begin DEF_CHARACTERISTIC
			Cmp_n_tqi_pft_utp_neg_err
			Cmp_n_tqi_pft_utp_pos_err
			Ctb_n_pft_neg_dev
			Ctb_n_pft_pos_dev
			Ctb_tqi_pft_neg_dev
			Ctb_tqi_pft_pos_dev
			Cxx_dfdec_pft_utp_neg_err
			Cxx_dfdec_pft_utp_pos_err
			Cxx_dfinc_pft_utp_neg_err
			Cxx_dfinc_pft_utp_pos_err
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_pft_utp_neg_err
			Vbx_df_pft_utp_pos_err
			Vbx_diag_ena_pft_utp_pos_err
			Vbx_diag_ena_pft_utp_neg_err
			Vsx_pft_utp_reg_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl_Tregfms
		""
	/begin DEF_CHARACTERISTIC
			Ctb_n_tt_bas
			Ctb_n_tt_bas_ftc
			Ctb_n_tt_pft_utp_fac
			Ctb_tqi_tt_bas
			Ctb_tqi_tt_bas_ftc
			Ctb_tqi_tt_pft_utp_fac
			Cxx_pft_inj_fms_bas_asd
			Cxx_pft_inj_fms_max_asd
			Cxx_pft_inj_fms_min_asd
			Cmp_n_tqi_pft_inj_fms_dg
			Cmp_n_tqi_pft_inj_fms_ig
			Cmp_n_tqi_pft_inj_fms_pg
			Cmp_n_tqi_tt_bas
			Cmp_n_tqi_tt_bas_ftc
			Cmp_n_tqi_tt_pft_utp_fac
			Cmp_tia_amp_pft_spc_max_env
			Cmp_tia_amp_pft_spc_min_env
			Cmp_n_tqi_pft_fms_spc_max_cor
			Cmp_n_tqi_pft_fms_spc_min_cor
			Cmp_n_tqi_pft_inj_fms_bas
			Cmp_n_tqi_pft_utp_bas
			Cmp_n_tqi_pft_utp_bas_ftc
			Cmp_n_tqi_pft_utp_inj_fms_fac
			Ctb_amp_pft_fms_cor
			Ctb_loop_dev_fms_dg_add_cor
			Ctb_loop_dev_fms_ig_add_cor
			Ctb_loop_dev_fms_pg_add_cor
			Ctb_n_pft_fms_cor
			Ctb_n_pft_fms_dg
			Ctb_n_pft_fms_ig
			Ctb_n_pft_fms_pg
			Ctb_n_pft_inj_fms_bas
			Ctb_n_pft_utp_bas
			Ctb_n_pft_utp_bas_ftc
			Ctb_n_pft_utp_inj_fms_fac
			Ctb_tqi_pft_fms_cor
			Ctb_tqi_pft_fms_dg
			Ctb_tqi_pft_fms_ig
			Ctb_tqi_pft_fms_pg
			Ctb_tqi_pft_inj_fms_bas
			Ctb_tqi_pft_utp_bas_ftc
			Ctb_tqi_pft_utp_inj_fms_fac
			Ctp_loop_dev_fms_dg_add_cor
			Ctp_loop_dev_fms_ig_add_cor
			Ctp_loop_dev_fms_pg_add_cor
			Cxx_pft_fms_dg_ig_init_low_lim
			Cxx_pft_fms_dg_ig_init_up_lim
			Cxx_pft_inj_fms_d_ftc
			Cxx_pft_inj_fms_dg_ada
			Cxx_pft_inj_fms_ig_ada
			Cxx_pft_inj_fms_max_ada_gain
			Cxx_pft_inj_fms_min_ada_gain
			Cxx_pft_inj_fms_pg_ada
			Cxx_pft_inj_fms_reg_ini_val
			Cxx_pft_utp_inj_fms_fac_cor
			Ctb_tia_pft_fms_cor
			Ctb_tqi_pft_utp_bas
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_fms_prectl_cor
			Vxx_pft_utp_fms_bas
			Vxx_pft_utp_fms_bas_ftc
			Vxx_pft_utp_inj_fms_bas
			Vxx_pft_utp_inj_fms_prectl_cor
			Vxx_tt_fms_bas
			Vxx_tt_fms_bas_ftc
			Vxx_tt_fms_pft_utp_fac
			Vxx_pft_inj_fms_spc_cor_rgn
			Vbx_pft_fms_dg_ig_init_win
			Vbx_pft_inj_fms_cor_req
			Vxx_pft_inj_fms_bas
			Vxx_pft_inj_fms_der_cor
			Vxx_pft_inj_fms_dg
			Vxx_pft_inj_fms_ig
			Vxx_pft_inj_fms_int_cor
			Vxx_pft_inj_fms_p_cor
			Vxx_pft_inj_fms_pg
			Vxx_pft_inj_fms_sat_rgn
			Vxx_pft_inj_fms_spc_cor
			Vxx_pft_inj_fms_spc_sat_rgn
			Vxx_pft_utp_inj_fms_fac
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl_Tregspv
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_reg_act_true
			Cxx_amp_lih_val
			Cxx_pft_ms_dp_lih_val
			Cxx_pft_utp_lih_val
			Cxx_pft_utp_wup_ol_cmd
			Cxx_tia_lih_val
			Cbx_maf_vld_utp_reg
			Cbx_pft_dtp_clc_ena
			Cbx_pft_dtp_mes_ena
			Cbx_pft_ms_esti_ena
			Cbx_pft_ms_lft_ena
			Cmp_n_tqi_pft_utp_reg_on_stt
			Ctb_n_pft_utp_reg_on_stt
			Ctb_tqi_pft_utp_reg_on_stt
			Cxx_pft_dtp_lih_val
			Cxx_pft_efy_prct_lih_val
			Cxx_pft_ms_lih_val
			Cxx_pft_temp_reg_act_dly
			Cxx_pft_temp_reg_ct_stop_dly
			Cxx_pft_utp_reg_off_is_dly
			Cxx_pft_utp_reg_off_is_n_thd
			Cxx_pft_utp_reg_off_thd
			Cxx_pft_utp_reg_off_utp_thd
			Cxx_pft_utp_reg_on_thd
			Cxx_pft_utp_reg_on_utp_ftc
			Cxx_pft_utp_reg_on_utp_thd
			Cxx_wup_pft_utp_thd
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_amp_reg
			Vxx_pft_efy_prct_reg
			Vxx_pft_ms_dp_reg
			Vxx_pft_utp_reg
			Vxx_tia_reg
			Vsx_pft_utp_reg_mod
			Vxx_pft_dtp_in
			Vxx_pft_ms_in
			Vbx_pft_utp_cmd_cor_act
			Vbx_pft_utp_cmd_cor_act_cdn
			Vbx_pft_utp_cmd_cor_act_req
			Vbx_pft_utp_ol_cmd_act
			Vbx_pft_utp_wup_cmd_act
			Vsx_pft_utp_reg_cmd_cor_vld
			Vsx_pft_efi_mod
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/begin FUNCTION
		AtPcbCtl_Tregspx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_maf_utp_dft
			Cmp_dtp_ms_pft_utp_var_sp
			Cmp_n_tqi_pft_utp_reg_ovs
			Cmp_n_tqi_pft_utp_sp
			Cmp_n_tqi_pft_utp_sp_max
			Cmp_t_ms_sta_asd_var_utp_sp
			Cmp_tia_amp_pft_utp_sp_cor
			Ctb_amp_pft_utp_sp_cor
			Ctb_dtp_pft_utp_var_sp
			Ctb_efy_rgn
			Ctb_maf_pft_utp_sp_max
			Ctb_ms_pft_utp_var_sp
			Ctb_ms_sta_asd_var_utp_sp
			Ctb_n_pft_utp_reg_ovs
			Ctb_n_pft_utp_sp
			Ctb_n_pft_utp_sp_max
			Ctb_t_asd_var_utp_sp
			Ctb_tia_pft_utp_sp_cor
			Ctb_tqi_pft_utp_reg_ovs
			Ctb_tqi_pft_utp_sp
			Ctb_tqi_pft_utp_sp_max
			Ctp_pft_efy_max_ms_sta_swi
			Cxx_pft_maf_utp_max_sp_ftc
			Cxx_pft_ms_cor_lih_val
			Cxx_pft_ms_sta_lih_val
			Cxx_pft_utp_sens_err
			Ctp_maf_pft_utp_max_sp
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_pft_asd_rgn_var_utp_ctr
			Vxx_pft_utp_sp_raw
			Vxx_pft_utp_reg_loop_dev
			Vxx_pft_utp_sp
			Vbx_pft_efy_max_ms_sta_swi
			Vxx_maf_pft_utp_max_sp
			Vxx_pft_ms_sta_asd
			Vxx_pft_utp_max_sp
			Vxx_pft_utp_reg_ovs
			Vxx_pft_utp_sp_cor
			Vxx_pft_utp_sp_max
			Vxx_temp_sp
			Vxx_pft_utp_cor_sp
			Vxx_pft_utp_var_sp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin FUNCTION
		AtPftDgn
		""
	/begin SUB_FUNCTION
			AtPftDgn_Csfdiag
			AtPftDgn_Obdclog
			AtPftDgn_Obdmalf
			AtPftDgn_Obd5xxx
			AtPftDgn_Sttclog
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin FUNCTION
		AtPftDgn_Csfdiag
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_diag_efy
			Ctb_pft_diag_egaf_fil
			Ctb_pft_diag_egaf_fil2
			Ctb_pft_diag_egaf_fil3
			Cmp_pft_diag_dp_err
			Cmp_pft_diag_rat_err_max
			Ctp_pft_diag_dp_min
			Ctp_pft_diag_dp_vrnc_err_max
			Ctp_pft_diag_err_step
			Cbx_diag_ena_npu_cfm
			Cbx_sens_pft_prs_cfm
			Cxx_dfdec_pft_no_lk
			Cxx_dfinc_pft_no_lk
			Cxx_pft_diag_aut_min_t
			Cxx_pft_diag_dp_fil_sq_max
			Cxx_pft_diag_dp_max
			Cxx_pft_diag_dp_t
			Cxx_pft_diag_egaf_min
			Cxx_pft_diag_egaf_min1
			Cxx_pft_diag_egaf_t
			Cxx_pft_diag_ena_t
			Cxx_pft_diag_err_max
			Cxx_pft_diag_err_min
			Cxx_pft_diag_rgn_nr_min
			Cxx_pft_diag_t
			Cxx_pft_diag_thd_tia_min
			Cxx_pft_dp_vrnc_err_max2
			Cxx_pft_dp_vrnc_max
			Cxx_pft_egaf_err_min
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			AtPftDgn_NVM.Vxx_pft_diag_err_ctr_NVM
			Vbx_df_pft_no_lk
			Vbx_diag_ena_pft_stt
			Vbx_pft_diag_done
			Vbx_pft_diag_rls_stt
			Vsx_pft_diag_ena_stt
			Vsx_sens_pft_dp_in_vld
			Vxx_pft_diag_dp_fil
			Vxx_pft_diag_dp_fil_frst
			Vxx_pft_diag_dp_fil_sq
			Vxx_pft_diag_dp_rat_vrnc
			Vxx_pft_diag_dp_vrnc_fil
			Vxx_pft_diag_dp_vrnc_sq
			Vxx_pft_diag_egaf_fil
			Vxx_pft_diag_egaf_fil3
			Vxx_pft_diag_egaf_fil_prev
			Vxx_pft_diag_err_ctr_mod6
			Vxx_pft_diag_err_max_mod6
			Vxx_pft_diag_rat_err
			Vxx_pft_egaf_err_mem
			Vxx_pft_no_lk_dyn_val
			Vxx_sens_pft_dp_in
			Vsx_pft_csf_diag_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin FUNCTION
		AtPftDgn_Obd5xxx
		""
	/begin OUT_MEASUREMENT
			Vsx_pft_ovl_vld
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin FUNCTION
		AtPftDgn_Obdclog
		""
	/begin DEF_CHARACTERISTIC
			Cxx_dfdec_pft_dirt
			Cxx_dfinc_pft_dirt
			Cxx_pft_diag_up_prs_obd_max
			Cxx_pft_diag_up_prs_obd_min
			Cxx_pft_up_prs_obd_max_def_t
			Cxx_pft_up_prs_obd_max_ok_t
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_df_pft_dirt
			Vbx_diag_ena_pft_up_prs_obd_max
			Vbx_pft_diag_up_prs_obd_max
			Vbx_pft_diag_up_prs_obd_max_err
			Vsx_sens_pft_ovl_prs_in_vld
			Vxx_pft_diag_src_nok_t_ctr
			Vxx_pft_diag_src_ok_t_ctr
			Vxx_pft_dirt_max
			Vxx_pft_dirt_min
			Vxx_pft_dirt_val
			Vxx_sens_pft_ovl_prs_in
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin FUNCTION
		AtPftDgn_Obdmalf
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_diag_gear
			Ctb_pft_diag_n
			Cmp_pft_diag_fms_max_zon_1
			Cmp_pft_diag_fms_max_zon_2
			Cmp_pft_diag_fms_max_zon_3
			Cmp_pft_diag_fms_max_zon_4
			Cbx_pft_diag_obd_cfm
			Cxx_dfinc_pft_nok_cge
			Cxx_dfinc_pft_nok_cge_zon_1
			Cxx_dfinc_pft_nok_cge_zon_2
			Cxx_dfinc_pft_nok_cge_zon_3
			Cxx_dfinc_pft_nok_cge_zon_4
			Cxx_pft_diag_amp_max_zon_1
			Cxx_pft_diag_amp_max_zon_2
			Cxx_pft_diag_amp_max_zon_3
			Cxx_pft_diag_amp_max_zon_4
			Cxx_pft_diag_amp_min_zon_1
			Cxx_pft_diag_amp_min_zon_2
			Cxx_pft_diag_amp_min_zon_3
			Cxx_pft_diag_amp_min_zon_4
			Cxx_pft_diag_dp_max_zon_1
			Cxx_pft_diag_dp_max_zon_2
			Cxx_pft_diag_dp_max_zon_3
			Cxx_pft_diag_dp_max_zon_4
			Cxx_pft_diag_dp_min
			Cxx_pft_diag_egaf_ind_max_zon_1
			Cxx_pft_diag_egaf_ind_max_zon_2
			Cxx_pft_diag_egaf_ind_max_zon_3
			Cxx_pft_diag_egaf_ind_max_zon_4
			Cxx_pft_diag_egaf_ind_min_zon_1
			Cxx_pft_diag_egaf_ind_min_zon_2
			Cxx_pft_diag_egaf_ind_min_zon_3
			Cxx_pft_diag_egaf_ind_min_zon_4
			Cxx_pft_diag_emtv_max_zon_1
			Cxx_pft_diag_emtv_max_zon_2
			Cxx_pft_diag_emtv_max_zon_3
			Cxx_pft_diag_emtv_max_zon_4
			Cxx_pft_diag_emtv_min_zon_1
			Cxx_pft_diag_emtv_min_zon_2
			Cxx_pft_diag_emtv_min_zon_3
			Cxx_pft_diag_emtv_min_zon_4
			Cxx_pft_diag_fms_hys_zon_1
			Cxx_pft_diag_fms_hys_zon_2
			Cxx_pft_diag_fms_hys_zon_3
			Cxx_pft_diag_fms_hys_zon_4
			Cxx_pft_diag_n_max_zon_1
			Cxx_pft_diag_n_max_zon_2
			Cxx_pft_diag_n_max_zon_3
			Cxx_pft_diag_n_max_zon_4
			Cxx_pft_diag_n_min_zon_1
			Cxx_pft_diag_n_min_zon_2
			Cxx_pft_diag_n_min_zon_3
			Cxx_pft_diag_n_min_zon_4
			Cxx_pft_diag_sum_nr_zon_1
			Cxx_pft_diag_sum_nr_zon_2
			Cxx_pft_diag_sum_nr_zon_3
			Cxx_pft_diag_sum_nr_zon_4
			Cxx_pft_malf_diag_dp_max
			Cxx_pft_malf_diag_ena_t
			Cxx_pft_malf_dp_t
			Cxx_pft_malf_egaf_t
			Cxx_pft_malf_thd_tia_hys_diff
			Cxx_pft_malf_thd_tia_min
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			AtPftDgn_NVM.Vxx_pft_nok_cge_max_NVM
			AtPftDgn_NVM.Vxx_pft_nok_cge_val_NVM
			Vbx_df_pft_nok_cge
			Vbx_diag_ov_polu_zon_rls_stt_1
			Vbx_diag_ov_polu_zon_rls_stt_10
			Vbx_diag_ov_polu_zon_rls_stt_2
			Vbx_diag_ov_polu_zon_rls_stt_3
			Vbx_diag_ov_polu_zon_rls_stt_4
			Vbx_diag_ov_polu_zon_rls_stt_7
			Vbx_diag_ov_polu_zon_rls_stt_8
			Vbx_diag_ov_polu_zon_rls_stt_9
			Vbx_diag_pft_rls_stt_zon_1
			Vbx_diag_pft_rls_stt_zon_2
			Vbx_diag_pft_rls_stt_zon_3
			Vbx_diag_pft_rls_stt_zon_4
			Vbx_diag_polu_zon_rls_stt_1
			Vbx_diag_polu_zon_rls_stt_10
			Vbx_diag_polu_zon_rls_stt_2
			Vbx_diag_polu_zon_rls_stt_3
			Vbx_diag_polu_zon_rls_stt_4
			Vbx_diag_polu_zon_rls_stt_7
			Vbx_diag_polu_zon_rls_stt_8
			Vbx_diag_polu_zon_rls_stt_9
			Vbx_mv_zon_1_calc_ena
			Vbx_mv_zon_2_calc_ena
			Vbx_mv_zon_3_calc_ena
			Vbx_mv_zon_4_calc_ena
			Vbx_pft_diag_mv_zon_1_calc_done
			Vbx_pft_diag_mv_zon_2_calc_done
			Vbx_pft_diag_mv_zon_3_calc_done
			Vbx_pft_diag_mv_zon_4_calc_done
			Vbx_pft_diag_zon_1_calc_done
			Vbx_pft_diag_zon_1_df
			Vbx_pft_diag_zon_2_calc_done
			Vbx_pft_diag_zon_2_df
			Vbx_pft_diag_zon_3_calc_done
			Vbx_pft_diag_zon_3_df
			Vbx_pft_diag_zon_4_calc_done
			Vbx_pft_diag_zon_4_df
			Vbx_pft_malf_diag_ena_stt
			Vbx_pft_malf_diag_stt_2
			Vbx_pft_malf_diag_stt_6
			Vbx_pft_malf_diag_stt_8
			Vsx_diag_ov_polu_zon_rls_stt
			Vsx_diag_polu_zon_rls_stt
			Vsx_pft_malf_diag_ena_stt
			Vsx_pft_malf_diag_stt
			Vsx_sens_pft_malf_dp_in_vld
			Vxx_dfinc_pft_nok_cge
			Vxx_pft_diag_mv_zon_1
			Vxx_pft_diag_mv_zon_2
			Vxx_pft_diag_mv_zon_3
			Vxx_pft_diag_mv_zon_4
			Vxx_pft_diag_sum_nr_zon_1
			Vxx_pft_diag_sum_nr_zon_2
			Vxx_pft_diag_sum_nr_zon_3
			Vxx_pft_diag_sum_nr_zon_4
			Vxx_pft_malf_dp_fil
			Vxx_pft_malf_egaf_fil
			Vxx_pft_malf_egaf_ind
			Vxx_pft_malf_mv_zon_1
			Vxx_pft_malf_mv_zon_2
			Vxx_pft_malf_mv_zon_3
			Vxx_pft_malf_mv_zon_4
			Vxx_pft_nok_cge_max_ini
			Vxx_pft_nok_cge_min
			Vxx_pft_nok_cge_val_ini
			Vxx_sens_pft_malf_dp_in
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/begin FUNCTION
		AtPftDgn_Sttclog
		""
	/begin DEF_CHARACTERISTIC
			Cbx_diag_ena_npu_cfm_lkg
			Cbx_pft_dsb_ms
			Cmp_ms_cor
			Cmp_pft_diag_dp_ovl
			Cmp_pft_diag_rat_ovl_max
			Ctb_inj_dist
			Ctb_pft_diag_efy_lkg
			Ctb_pft_diag_egaf_fil2_lkg
			Ctb_pft_egaf_ind_lkg
			Ctb_vh_dist
			Ctp_pft_diag_ovl_step
			Cxx_dfinc_pft_dirt_lkg
			Cxx_pft_diag_aut_min_t_lkg
			Cxx_pft_diag_dp_fil_sq_max_lkg
			Cxx_pft_diag_dp_max_lkg
			Cxx_pft_diag_dp_t_lkg
			Cxx_pft_diag_egaf_min2
			Cxx_pft_diag_egaf_min_lkg
			Cxx_pft_diag_egaf_t_lkg
			Cxx_pft_diag_ena_t_lkg
			Cxx_pft_diag_ovl_max
			Cxx_pft_diag_rgn_nr_min_lkg
			Cxx_pft_diag_t_lkg
			Cxx_pft_diag_thd_tia_min_lkg
			Cxx_pft_dp_vrnc_max_lkg
			Cxx_pft_dp_vrnc_ovl_max
			Cxx_pft_egaf_ovl_min
			Cxx_dfdec_pft_dirt_lkg
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_diag_ena_stt
			Vbx_pft_diag_rls_stt_lkg
			Vbx_pft_diag_rls_stt_lkg_1
			Vbx_pft_stt
			Vsx_pft_diag_ena_lkg_stt
			Vxx_pft_diag_dp_fil_frst_lkg
			Vxx_pft_diag_dp_fil_lkg
			Vxx_pft_diag_dp_fil_sq_lkg
			Vxx_pft_diag_dp_rat_vrnc_lkg
			Vxx_pft_diag_dp_vrnc_fil_lkg
			Vxx_pft_diag_dp_vrnc_sq_lkg
			Vxx_pft_diag_egaf_fil_lkg
			Vbx_pft_ovl_diag_done
			Vbx_pft_diag_stt_ovl_out
			Vbx_df_pft_dirt_lkg
			Vsx_pft_vld
			Vxx_pft_egaf_ind_lkg
			Vxx_pft_diag_ovl_ctr
			Vxx_pft_diag_rat_ovl
			Vxx_pft_egaf_ovl_mem
			Vxx_pft_diag_ovl_diag_done_ctr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin FUNCTION
		AtPftMdl
		""
	/begin OUT_MEASUREMENT
			AtPftMdl_NVM.Vxx_pft_ms_sim_ofs_NVM
			AtPftMdl_NVM.Vxx_pft_ms_lft_mem_NVM
			AtPftMdl_NVM.Vxx_pft_rgn_stop_ms_thd_NVM
			AtPftMdl_NVM.Vxx_pft_comb_ok_ms_thd_NVM
			AtPftMdl_NVM.Vxx_pft_ref_ms_NVM
			AtPftMdl_NVM.Vxx_ms_ofs_clc_t_ofs_NVM
			AtPftMdl_NVM.Vxx_pft_ms_sim_fail_t_NVM
			AtPftMdl_NVM.Vxx_pft_ms_NVM
			AtPftMdl_NVM.Vxx_pft_ms_ofs_NVM
			AtPftMdl_NVM.Vbx_pft_ms_ofs_clc_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			AtPftMdl_Chgxxxx
			AtPftMdl_Combxxx
			AtPftMdl_Lbtpmdl
			AtPftMdl_Mdlcb1d
			AtPftMdl_Miofxxx
			AtPftMdl_Mslftxx
			AtPftMdl_Msswixx
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin FUNCTION
		AtPftMdl_Chgxxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_dist_ms_new_pft_ofs
			Ctb_pft_egaf_mv_zon
			Ctb_pft_ms_test
			Ctb_pft_nr_driv_cdn
			Cmp_pft_dp_egaf_0
			Cmp_pft_dp_egaf_1
			Cmp_pft_dp_egaf_2
			Cmp_pft_dp_egaf_3
			Cmp_pft_dp_egaf_4
			Cmp_pft_dp_egaf_5
			Ctd_pft_iter_step_no_rgn
			Ctd_pft_iter_step_rgn
			Ctd_pft_max_nr_sp_zon_no_rgn
			Ctd_pft_max_nr_sp_zon_rgn
			Ctd_pft_min_mv_ms_no_rgn
			Ctd_pft_min_mv_ms_rgn
			Ctp_pft_dist_ms_new_pft_ofs
			Cbx_ms_ofs_rgn_swi
			Cbx_pft_ms_ofs_act
			Cbx_pft_ms_ofs_swi
			Ctx_pft_efy_bkp[0]
			Ctx_pft_efy_bkp[1]
			Ctx_pft_efy_bkp[2]
			Ctx_pft_efy_bkp[3]
			Ctx_pft_efy_bkp[4]
			Ctx_pft_efy_bkp[5]
			Ctx_pft_egaf_lim_h[0]
			Ctx_pft_egaf_lim_h[1]
			Ctx_pft_egaf_lim_h[2]
			Ctx_pft_egaf_lim_h[3]
			Ctx_pft_egaf_lim_h[4]
			Ctx_pft_egaf_lim_h[5]
			Ctx_pft_egaf_lim_h[6]
			Ctx_pft_egaf_lim_h[7]
			Ctx_pft_egaf_lim_h[8]
			Ctx_pft_egaf_lim_h[9]
			Ctx_pft_egaf_lim_l[0]
			Ctx_pft_egaf_lim_l[1]
			Ctx_pft_egaf_lim_l[2]
			Ctx_pft_egaf_lim_l[3]
			Ctx_pft_egaf_lim_l[4]
			Ctx_pft_egaf_lim_l[5]
			Ctx_pft_egaf_lim_l[6]
			Ctx_pft_egaf_lim_l[7]
			Ctx_pft_egaf_lim_l[8]
			Ctx_pft_egaf_lim_l[9]
			Cxx_min_tqi_sot_esti
			Cxx_pft_cold_sta_tco_thd
			Cxx_pft_cold_sta_tia_thd
			Cxx_pft_efy_prct_intv
			Cxx_pft_egaf_dev_ms
			Cxx_pft_egaf_t_fil
			Cxx_pft_egaf_urb_driv_cdn
			Cxx_pft_egaf_xurb_driv_cdn
			Cxx_pft_min_iter_nr
			Cxx_pft_ms_max
			Cxx_pft_ms_min
			Cxx_pft_ms_new_pft_ofs_max
			Cxx_pft_ms_new_pft_ofs_min
			Cxx_pft_ms_ofs_fac_rgn_max
			Cxx_pft_ms_ofs_fac_rgn_min
			Cxx_pft_ms_ofs_max
			Cxx_pft_ms_ofs_min
			Cxx_pft_ms_ofs_t_max
			Cxx_pft_ms_ofs_t_min
			Cxx_pft_ms_prs_max
			Cxx_pft_ms_prs_min
			Cxx_pft_ms_ref_ms_ofs
			Cxx_pft_ms_sta_ofs_dft
			Cxx_pft_nr_zon_max
			Cxx_pft_ofs_clc_tco_thd
			Cxx_tco_ms_ofs_clc_dft
			Cxx_tia_ms_ofs_clc_dft
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_inj_stt
			Vbx_pft_stt_ms_ena
			Vsx_pft_load_vld
			Vtx_pft_egaf_sum[0]
			Vtx_pft_egaf_sum[1]
			Vtx_pft_egaf_sum[2]
			Vtx_pft_egaf_sum[3]
			Vtx_pft_egaf_sum[4]
			Vtx_pft_egaf_sum[5]
			Vtx_pft_egaf_sum[6]
			Vtx_pft_egaf_sum[7]
			Vtx_pft_egaf_sum[8]
			Vtx_pft_egaf_sum[9]
			Vtx_pft_ms_test[0]
			Vtx_pft_ms_test[1]
			Vtx_pft_mv_egaf_zon[0]
			Vtx_pft_mv_egaf_zon[1]
			Vtx_pft_mv_egaf_zon[2]
			Vtx_pft_mv_egaf_zon[3]
			Vtx_pft_mv_egaf_zon[4]
			Vtx_pft_mv_egaf_zon[5]
			Vtx_pft_mv_egaf_zon[6]
			Vtx_pft_mv_egaf_zon[7]
			Vtx_pft_mv_egaf_zon[8]
			Vtx_pft_mv_egaf_zon[9]
			Vtx_pft_mv_prs_each_zon[0]
			Vtx_pft_mv_prs_each_zon[1]
			Vtx_pft_mv_prs_each_zon[2]
			Vtx_pft_mv_prs_each_zon[3]
			Vtx_pft_mv_prs_each_zon[4]
			Vtx_pft_mv_prs_each_zon[5]
			Vtx_pft_mv_prs_each_zon[6]
			Vtx_pft_mv_prs_each_zon[7]
			Vtx_pft_mv_prs_each_zon[8]
			Vtx_pft_mv_prs_each_zon[9]
			Vtx_pft_mv_sp_each_zon[0]
			Vtx_pft_mv_sp_each_zon[1]
			Vtx_pft_mv_sp_each_zon[2]
			Vtx_pft_mv_sp_each_zon[3]
			Vtx_pft_mv_sp_each_zon[4]
			Vtx_pft_mv_sp_each_zon[5]
			Vtx_pft_mv_sp_each_zon[6]
			Vtx_pft_mv_sp_each_zon[7]
			Vtx_pft_mv_sp_each_zon[8]
			Vtx_pft_mv_sp_each_zon[9]
			Vtx_pft_nr_sp_each_zon[0]
			Vtx_pft_nr_sp_each_zon[1]
			Vtx_pft_nr_sp_each_zon[2]
			Vtx_pft_nr_sp_each_zon[3]
			Vtx_pft_nr_sp_each_zon[4]
			Vtx_pft_nr_sp_each_zon[5]
			Vtx_pft_nr_sp_each_zon[6]
			Vtx_pft_nr_sp_each_zon[7]
			Vtx_pft_nr_sp_each_zon[8]
			Vtx_pft_nr_sp_each_zon[9]
			Vtx_pft_prs_clc[0]
			Vtx_pft_prs_clc[1]
			Vtx_pft_prs_err[0]
			Vtx_pft_prs_err[1]
			Vtx_pft_prs_sum[0]
			Vtx_pft_prs_sum[1]
			Vtx_pft_prs_sum[2]
			Vtx_pft_prs_sum[3]
			Vtx_pft_prs_sum[4]
			Vtx_pft_prs_sum[5]
			Vtx_pft_prs_sum[6]
			Vtx_pft_prs_sum[7]
			Vtx_pft_prs_sum[8]
			Vtx_pft_prs_sum[9]
			Vxx_pft_efy
			Vxx_pft_efy_intv_rat
			Vxx_pft_egaf_dev_ms
			Vxx_pft_egaf_nr_zon
			Vxx_pft_iter_step
			Vxx_pft_max_nr_ms_sp_zon
			Vxx_pft_min_mv_ms
			Vxx_pft_ms_cor_wio_ofs
			Vxx_pft_ms_new_pft_ofs
			Vxx_pft_ms_ofs_clc_t
			Vxx_pft_ms_ofs_corr
			Vxx_pft_ms_ofs_fac_rgn
			Vxx_pft_ms_ofs_fac_rgn_lft
			Vxx_pft_ms_ofs_sta
			Vxx_pft_nr_driv_cdn
			Vxx_pft_nr_efy_intv
			Vsx_pft_ms_prs_vld
			Vxx_pft_iter_nr
			Vxx_pft_ms_ofs_clc_t_cor
			Vxx_pft_ms_prs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin FUNCTION
		AtPftMdl_Combxxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_csm_sum_sta_drv_esti
			Ctb_pft_delta_temp_fil
			Ctb_pft_o2_fac_sot_esti
			Ctb_pft_temp_fac_sot_esti
			Cmp_pft_egaf_sot_esti
			Ctp_pft_csm_ms_esti
			Ctp_pft_fac_sot_esti
			Cxx_csm_drv_ms_mdl_dft
			Cxx_pft_ms_lft_ini_mdl_dft
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cmb_mdl_int_rst
			Vsx_pft_rgn_temp_vld
			Vxx_csm_sum_sta_drv_ms
			Vxx_pft_delta_temp_fil
			Vxx_pft_egaf_sot_esti
			Vxx_pft_temp_fac_sot_esti
			Vsx_pft_ms_lft_mdl_vld
			Vxx_pft_ms_lft_mdl
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin FUNCTION
		AtPftMdl_Lbtpmdl
		""
	/begin OUT_MEASUREMENT
			Vxx_ehr_clc_raw_dtp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin FUNCTION
		AtPftMdl_Mdlcb1d
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_cal_cpy_ehr_itl_temp
			Ctb_pft_ehr_clc_dtp_dly1
			Ctb_pft_ehr_clc_dtp_dly2
			Ctb_pft_ehr_clc_dtp_dly3
			Ctb_pft_ext_cnvt_fac_vs
			Ctp_pft_ehr_cal_cpy1
			Ctp_pft_ehr_cal_cpy2
			Ctp_pft_ehr_cal_cpy3
			Ctp_pft_ehr_rgn_spd1
			Ctp_pft_ehr_rgn_spd2
			Ctp_pft_ehr_rgn_spd3
			Ctp_pft_ex_gaz_cal_cpy1
			Ctp_pft_ex_gaz_cal_cpy2
			Ctp_pft_ex_gaz_cal_cpy3
			Ctp_pft_ext_cnvt_fac
			Cbx_pft_ext_temp_swi
			Cbx_pft_ms_ini_mdl_comb_vld
			Cbx_pft_o2_fac_vld_mdl_comb_vld
			Cbx_pft_tia_vld_mdl_comb_vld
			Cbx_pft_vs_vld_mdl_comb_vld
			Cxx_pft_ehr_ms_esti_min
			Cxx_pft_ehr_o2_fac_sot_min
			Cxx_pft_ext_ar
			Cxx_pft_ms_lft_esti_ini_dft
			Cxx_pft_sys_clc_dtp_ini
			Cxx_pft_wht
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_pft_cal_cpy1
			Vxx_pft_cal_cpy2
			Vxx_pft_cal_cpy3
			Vxx_pft_comb_bfr_entp1
			Vxx_pft_comb_bfr_entp2
			Vxx_pft_comb_bfr_entp3
			Vxx_pft_comb_entp1
			Vxx_pft_comb_entp2
			Vxx_pft_comb_entp3
			Vxx_pft_ehr_clc_dtp1
			Vxx_pft_ehr_clc_dtp1_dly
			Vxx_pft_ehr_clc_dtp2
			Vxx_pft_ehr_clc_dtp2_dly
			Vxx_pft_ehr_clc_dtp3
			Vxx_pft_ehr_clc_dtp3_dly
			Vxx_pft_ehr_clc_dtp_ini
			Vxx_pft_ehr_ex_gas_mol_esti1
			Vxx_pft_ehr_ex_gas_mol_esti2
			Vxx_pft_ehr_ex_gas_mol_esti3
			Vxx_pft_ehr_ext_ar
			Vxx_pft_ehr_ms_esti1
			Vxx_pft_ehr_ms_esti2
			Vxx_pft_ehr_ms_esti3
			Vxx_pft_ehr_ms_mol_dec_esti1
			Vxx_pft_ehr_ms_mol_dec_esti2
			Vxx_pft_ehr_ms_mol_dec_esti3
			Vxx_pft_ehr_o2_fac_sot_esti1
			Vxx_pft_ehr_o2_fac_sot_esti2
			Vxx_pft_ehr_o2_fac_sot_esti3
			Vxx_pft_ehr_o2_mol_esti1
			Vxx_pft_ehr_o2_mol_esti2
			Vxx_pft_ehr_o2_mol_esti3
			Vxx_pft_ehr_rgn_spd1
			Vxx_pft_ehr_rgn_spd2
			Vxx_pft_ehr_rgn_spd3
			Vxx_pft_ehr_wht
			Vxx_pft_ex_gaz_cal_cpy1
			Vxx_pft_ex_gaz_cal_cpy2
			Vxx_pft_ex_gaz_cal_cpy3
			Vxx_pft_ext_cnvt_fac
			Vxx_pft_ext_temp
			Vxx_pft_ms_cor_ehr
			Vxx_pft_ms_esti_ini
			Vxx_pft_ms_lft_ini_cor
			Vxx_pft_ms_prs_ehr
			Vxx_pft_ms_sim_ehr
			Vxx_pft_reac_entp1
			Vxx_pft_reac_entp2
			Vxx_pft_reac_entp3
			Vxx_pft_utp_cor
			Vbx_pft_soot_comb_ena
			Vbx_pft_soot_comb_stop
			Vsx_pft_ms_esti_vld
			Vsx_pft_sys_clc_dtp_vld
			Vxx_pft_ms_esti
			Vxx_pft_sys_clc_dtp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* ASAP2::Database : delete DEF_CHARACTERISTIC, since it is empty */
/begin FUNCTION
		AtPftMdl_Miofxxx
		""
	/* ASAP2::Database : delete 'Vbx_ms_sim_dp_ini_req' */
	/* ASAP2::Database : delete 'Vbx_ms_sim_int_ini' */
	/* ASAP2::Database : delete 'Vbx_pft_dp_ms_sim_ini' */
	/* ASAP2::Database : delete 'Vbx_pft_ms_sim_ini' */
	/* ASAP2::Database : delete 'Vbx_rgn_end_ms_sim_ini' */
	/* ASAP2::Database : delete 'Vbx_rgn_fail_ms_sim_ini' */
	/* ASAP2::Database : delete 'Vbx_ups_rich_cho' */
	/* ASAP2::Database : delete 'Vxx_pft_dtp_ms_sim' */
	/* ASAP2::Database : delete 'Vxx_pft_efy_prct_ms_sim' */
	/* ASAP2::Database : delete 'Vxx_pft_egaf_ms_sim' */
	/* ASAP2::Database : delete 'Vxx_pft_ex_temp_ms_emt_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_ex_temp_nox_emt_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_fim_clc_ms_sim' */
	/* ASAP2::Database : delete 'Vxx_pft_fim_ms_sim' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_emt_egr_act' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_emt_egr_off' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_emt_egr_wait' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_amp_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_dif' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_emt' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_ini' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_nox' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_rgn' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_tco_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_ms_sim_tia_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_nox_emt_egr_act' */
	/* ASAP2::Database : delete 'Vxx_pft_nox_emt_egr_off' */
	/* ASAP2::Database : delete 'Vxx_pft_nox_emt_egr_wait' */
	/* ASAP2::Database : delete 'Vxx_pft_nox_sim_amp_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_nox_sim_tco_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_nox_sim_tia_cor' */
	/* ASAP2::Database : delete 'Vxx_pft_nox_sot_rgn' */
	/* ASAP2::Database : delete 'Vxx_pft_rich_ms_sim' */
	/* ASAP2::Database : delete 'Vxx_pft_temp_ms_sim' */
	/* ASAP2::Database : delete 'Vxx_pft_utp_ms_sim' */
	/* ASAP2::Database : 35 referenced entries deleted */
	/begin OUT_MEASUREMENT
			Vsx_pft_ms_sim_vld
			Vxx_pft_ms_sim
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin FUNCTION
		AtPftMdl_Mslftxx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_comb_mdl_ini_swi
			Cbx_pft_eng_rest_stt_ms_lft_frz
			Cbx_pft_ms_comb_swi
			Cbx_pft_rgn_ok
			Csx_pft_cat_heat_ini_swi
			Csx_pft_rgn_req_ini_swi
			Cxx_pft_comb_ok
			Cxx_pft_comb_ok_prct
			Cxx_pft_ms_comb_stop
			Cxx_pft_ms_comb_stop_prct
			Cxx_pft_ms_esti_frst_1
			Cxx_pft_ms_sta_esti_frst_max
			Cxx_pft_rgn_ena_rst_t
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_ms_comb_stt_swi
			Vsx_pft_ms_lft_vld_mem
			Vsx_pft_ms_lft_ini_vld
			Vsx_pft_ms_lft_vld
			Vxx_pft_ms_lft
			Vxx_pft_ms_lft_ini
			Vxx_pft_rgn_stop_ms_abv_thd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/begin FUNCTION
		AtPftMdl_Msswixx
		""
	/begin DEF_CHARACTERISTIC
			Ntb_pft_sot_ms_cor
			Ctd_pft_sot_ms_cor_swi
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_sot_ms_cor_swi
			Vxx_pft_bal_ms_sim
			Vsx_pft_ms_cor_vld
			Vsx_pft_sot_ms_cor_stt
			Vxx_pft_ms_cor
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng
		""
	/begin OUT_MEASUREMENT
			AtPftMng_NVM.Vxx_pft_dist_load_frst_NVM
			AtPftMng_NVM.Vxx_pft_hot_ref_dist_NVM
			AtPftMng_NVM.Vxx_pft_hot_cold_ref_dist_NVM
			AtPftMng_NVM.Vxx_pft_hot_med_ref_dist_NVM
			AtPftMng_NVM.Vxx_pft_load_spd_dist_ref_NVM
			AtPftMng_NVM.Vxx_pft_rgn_err_t_ctr_NVM
			AtPftMng_NVM.Vxx_pft_rgn_err_vh_dist_NVM
			AtPftMng_NVM.Vxx_pft_load_spd_ms_ref_NVM
			AtPftMng_NVM.Vxx_pft_rgn_ena_t_ctr_NVM
			AtPftMng_NVM.Vxx_pft_ctr_cold_rgn_ok_NVM
			AtPftMng_NVM.Vxx_pft_ctr_hot_rgn_ok_NVM
			AtPftMng_NVM.Vxx_pft_ctr_med_rgn_ok_NVM
			AtPftMng_NVM.Vxx_pft_rgn_req_t_ctr_lft_NVM
			AtPftMng_NVM.Vxx_pft_vh_dist_rgn_err_cold_NVM
			AtPftMng_NVM.Vxx_pft_vh_dist_rgn_err_hot_NVM
			AtPftMng_NVM.Vxx_pft_vh_dist_rgn_err_med_NVM
			AtPftMng_NVM.Vxx_pft_ctr_rgn_err_cold_NVM
			AtPftMng_NVM.Vxx_pft_ctr_rgn_err_med_NVM
			AtPftMng_NVM.Vxx_pft_ctr_rgn_err_hot_NVM
			AtPftMng_NVM.Vsx_pft_rgn_cdn_tgt_NVM
			AtPftMng_NVM.Vsx_pft_load_spd_ms_ref_stt_NVM
			AtPftMng_NVM.Vxx_pft_ctr_rgn_err_NVM
			AtPftMng_NVM.Vxx_pft_mv_raw_sot_load_spd_NVM
			AtPftMng_NVM.Vsx_pft_load_spd_clc_stt_NVM
			AtPftMng_NVM.Vbx_pft_spd_req_lght_NVM
			AtPftMng_NVM.Vbx_pft_rgn_ok_NVM
			AtPftMng_NVM.Vbx_pft_load_spd_vld_ok_1_NVM
			AtPftMng_NVM.Vbx_pft_rgn_eng_rest_stt_NVM
	/end OUT_MEASUREMENT
	/begin SUB_FUNCTION
			AtPftMng_Rgntpxx
			AtPftMng_Nxtoppx
			AtPftMng_Rgnreqx
			AtPftMng_Rgnsucx
			AtPftMng_Sttoutx
			AtPftMng_Thdchgt
			AtPftMng_Catheat
			AtPftMng_Cdntgtx
			AtPftMng_Chgtend
			AtPftMng_Chktmpx
			AtPftMng_Csfsttx
			AtPftMng_Intvopp
			AtPftMng_Lastopp
			AtPftMng_Loadspd
			AtPftMng_Spdreqx
			AtPftMng_Waitreq
	/end SUB_FUNCTION
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Catheat
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_tia_cata_hot
			Cxx_pft_cata_hot_max_t_1
			Cxx_pft_cata_hot_max_t_2
			Cxx_pft_cata_hot_min_t_1
			Cxx_pft_cata_hot_min_t_2
			Cxx_pft_ff_sum_sta_cata_min_2
			Cxx_pft_utp_cata_min_2
			Ctp_pft_tia_cata_hot
			Cxx_csm_sum_sta_cata_hot_dft
			Cxx_tco_cata_hot_dft
			Cxx_tia_cata_hot_dft
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_trs_cdn_6
			Vbx_pft_trs_cdn_7
			Vbx_pft_trs_req_6
			Vxx_pft_cata_hot_t_ctr
			Vxx_tco_cata
			Vxx_tia_cata
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Cdntgtx
		""
	/begin DEF_CHARACTERISTIC
			Ctx_pft_dft_hot_med_dist_intv[0]
			Ctx_pft_dft_hot_med_dist_intv[1]
			Ctx_pft_dft_hot_med_dist_intv[2]
			Ctx_pft_dft_hot_med_dist_intv[3]
			Ctx_pft_dft_hot_med_dist_intv[4]
			Ctx_pft_dft_hot_med_dist_intv[5]
			Ctx_pft_dft_hot_med_dist_intv[6]
			Ctx_pft_dft_hot_med_dist_intv[7]
			Ctx_pft_dft_hot_med_dist_intv[8]
			Ctx_pft_dft_hot_med_dist_intv[9]
			Ctx_pft_dft_hot_med_dist_intv[10]
			Ctx_pft_dft_hot_med_dist_intv[11]
			Ctx_pft_dft_hot_med_dist_intv[12]
			Ctx_pft_dft_hot_med_dist_intv[13]
			Ctx_pft_dft_hot_med_dist_intv[14]
			Ctx_pft_dft_hot_med_dist_intv[15]
			Ctx_pft_dft_hot_cold_dist_intv[0]
			Ctx_pft_dft_hot_cold_dist_intv[1]
			Ctx_pft_dft_hot_cold_dist_intv[2]
			Ctx_pft_dft_hot_cold_dist_intv[3]
			Ctx_pft_dft_hot_cold_dist_intv[4]
			Ctx_pft_dft_hot_cold_dist_intv[5]
			Ctx_pft_dft_hot_cold_dist_intv[6]
			Ctx_pft_dft_hot_cold_dist_intv[7]
			Ctx_pft_dft_hot_cold_dist_intv[8]
			Ctx_pft_dft_hot_cold_dist_intv[9]
			Ctx_pft_dft_hot_cold_dist_intv[10]
			Ctx_pft_dft_hot_cold_dist_intv[11]
			Ctx_pft_dft_hot_cold_dist_intv[12]
			Ctx_pft_dft_hot_cold_dist_intv[13]
			Ctx_pft_dft_hot_cold_dist_intv[14]
			Ctx_pft_dft_hot_cold_dist_intv[15]
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_pft_med_cdn_tgt_dist
			Vxx_pft_med_cold_cdn_tgt_dist
			Vsx_pft_rgn_cdn_tgt_clc
			Vbx_cond_cdntgt_act
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Chgtend
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_cold_rgn_ena_act
			Cbx_pft_dist_min_suc_act
			Cbx_pft_max_ms_tgt_ena
			Cbx_pft_med_rgn_ena_act
			Cbx_pft_ms_thd_cold_rgn_ok
			Cbx_pft_ms_thd_hot_rgn_ok
			Cbx_pft_ms_thd_med_rgn_ok
			Cbx_pft_ms_thd_spd_req_ok
			Cbx_pft_vh_dist_thd_cold_rgn_ok
			Cbx_pft_vh_dist_thd_hot_rgn_ok
			Cbx_pft_vh_dist_thd_med_rgn_ok
			Cbx_pft_vh_dist_thd_spd_req_ok
			Ctb_pft_dil_rat
			Ctb_pft_eng_sp
			Cxx_csm_sum_rest_min
			Cxx_pft_ctr_rgn_err_max
			Cxx_pft_min_load_t
			Cxx_pft_rest_max_t
			Cxx_pft_rest_min_t
			Cxx_pft_rest_min_t_csm
			Cxx_pft_rest_min_t_utp
			Cxx_pft_utp_rest_min
			Ctd_pft_eng_sp_dist_fac
			Ctd_pft_eng_sp_t_fac
			Ctp_dil_rgn_err_dist_min
			Ctp_dil_rgn_min_t
			Ctp_pft_dist_min_inj_dist
			Ctp_pft_dist_min_rgn_err_tia
			Ctp_pft_dist_min_tia_mv
			Ctp_pft_dist_spd_req_oil_dil
			Ctp_pft_dist_spd_req_tia
			Ctp_pft_dist_spd_req_vh_dist
			Ctp_pft_t_min_rgn_err_tia
			Ctp_pft_dist_min_vh_dist
			Ctp_pft_dist_spd_req_inj_dist
			Ctb_inj_dist_min_rgn
			Ctp_dist_min_oil_dil_tgt_0
			Ctp_dist_min_oil_dil_tgt_1
			Ctp_dist_min_oil_dil_tgt_2
			Cbx_pft_eng_sp_forc_rgn_ms_ena
			Ctb_pft_tia_mv_dist_min
			Cxx_pft_max_ms_tgt_dft
			Cxx_pft_tia_mv_chg_end_dft
			Ctb_pft_dist_load_min
			Ctb_pft_vh_dist_dist_min
			Cxx_pft_ms_dft
			Cxx_pft_ms_sim_dft
			Cxx_pft_ms_sim_sta_swi
			Cxx_pft_ms_sta_swi
			Cxx_dfdec_pft_rgn_dirt
			Cxx_dfinc_pft_rgn_dirt
			Cbx_pft_hot_rgn_ena_act
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_load_stop_min_dist_cond
			Vbx_load_stop_min_t_cond
			Vbx_pft_cold_cdn
			Vbx_pft_dist_load_min
			Vbx_pft_dist_load_min_spd_req
			Vbx_pft_dist_min_ok_suc
			Vbx_pft_hot_cdn
			Vbx_pft_load_cdn_3
			Vbx_pft_ms_rgn_cold_cdn
			Vbx_pft_ms_rgn_hot_cdn
			Vbx_pft_ms_rgn_med_cdn
			Vbx_pft_ms_rgn_spd_req_cdn
			Vbx_pft_rest_rgn_req
			Vbx_pft_rgn_eng_rest_act
			Vbx_pft_rgn_eng_rest_stop
			Vbx_pft_rgn_forc_cdn
			Vbx_pft_rgn_forc_req
			Vbx_pft_rgn_spd_req
			Vbx_pft_spd_req_cdn
			Vbx_pft_spd_req_min_cond
			Vbx_pft_spd_req_rgn_cdn
			Vbx_pft_stt_load_cdn
			Vbx_pft_stt_min_load_t
			Vbx_pft_trs_cdn_0
			Vbx_pft_trs_cdn_1
			Vbx_pft_vh_dist_rgn_cold_cdn
			Vbx_pft_vh_dist_rgn_hot_cdn
			Vbx_pft_vh_dist_rgn_med_cdn
			Vbx_pft_vh_dist_rgn_ms_err_cdn
			Vbx_pft_vh_dist_rgn_ok
			Vbx_pft_vh_dist_rgn_spd_req_cdn
			Vxx_pft_dist_load_min
			Vxx_pft_dist_load_min_spd_req
			Vxx_pft_tia_mv_lh
			Vxx_pft_vh_dist_rgn
			Vsx_pft_load_mod_nr
			Vsx_pft_load_stop_req
			Vxx_pft_ms_sta
			Vxx_pft_rgn_mod_nr
			Vbx_pft_med_cdn
			Vbx_pft_ms_dist_load_min
			Vsx_pft_rgn_max_err_vld
			Vbx_pft_rgn_cond_ena
			Vsx_pft_ms_sta_vld
			Vsx_pft_ms_sim_sta_vld
			Vxx_pft_ms_sim_sta
			Vbx_df_pft_rgn_dirt
			Vbx_cond_chgtend_act_load
			Vbx_cond_chgtend_act
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Chktmpx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_tia_chk_temp
			Cxx_ff_sum_sta_cata_min_1
			Cxx_pft_tmr_max_chk_temp
			Cxx_pft_utp_cata_min_1
			Ctp_pft_tia_chk_temp
			Cxx_csm_sum_rgn_temp_chk_dft
			Cxx_tco_rgn_temp_chk_dft
			Cxx_tia_rgn_temp_chk_dft
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_trs_cdn_14
			Vbx_pft_trs_cdn_4
			Vbx_pft_trs_cdn_5
			Vbx_pft_trs_req_4
			Vxx_pft_chk_temp_t_ctr
			Vxx_tco_temp
			Vxx_tia_temp
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Csfsttx
		""
	/begin DEF_CHARACTERISTIC
			Csx_pft_stt_rgn_mnl
			Cbx_eng_stop_csf_swi
			Cbx_pft_comb_ena_stt
			Csx_comb_mod_spu_rich
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_spd_load_cdn
			Vbx_pft_stt_rgn_mnl
			Vxx_pft_ctr_rgn_err_ini
			Vxx_pft_ctr_rgn_err_raw
			Vxx_pft_dist_load_frst_ini
			Vxx_pft_dist_load_frst_raw
			Vbx_pft_ms_rst
			Vbx_pft_trs_req
			Vbx_pft_spd_req_ini
			Vbx_pft_rgn_ok_ini
			Vbx_pft_eng_stop_csf
			Vbx_pft_spd_req_ini_tmp
			Vbx_pft_spd_req_min_cond_tmp
			Vbx_pft_trs_cdn_0_tmp
			Vbx_pft_trs_cdn_1_tmp
			Vbx_pft_stt_mnl_load
			Vbx_pft_stt_mnl_spd_req
			Vbx_pft_stt_mnl_cat_heat
			Vbx_pft_stt_mnl_rgn_req
			Vbx_pft_stt_mnl_rgn_fail
			Vbx_pft_stt_mnl_rgn_ok
			Vbx_pft_stt_mnl_rgn_rst
			Vbx_pft_stt_mnl_chk_tmp
			Vbx_pft_rgn_no_end
			Vbx_pft_rgn_eng_rest_stt_ini
			Vbx_pft_spd_req_lght_off
			Vsx_pft_stt_rgn
			Vxx_pft_ctr_rgn_err_cold_ini
			Vxx_pft_ctr_rgn_err_hot_ini
			Vxx_pft_ctr_rgn_err_med_ini
			Vbx_act_dgtc_spd_req_lght
			Vbx_pft_spd_req_lght_ini
			Vbx_pft_stt_chg_ini
			Vsx_pft_eng_sp_sta
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Intvopp
		""
	/begin DEF_CHARACTERISTIC
			Ctx_pft_dft_hot_dist_intv[0]
			Ctx_pft_dft_hot_dist_intv[1]
			Ctx_pft_dft_hot_dist_intv[2]
			Ctx_pft_dft_hot_dist_intv[3]
			Ctx_pft_dft_hot_dist_intv[4]
			Ctx_pft_dft_hot_dist_intv[5]
			Ctx_pft_dft_hot_dist_intv[6]
			Ctx_pft_dft_hot_dist_intv[7]
			Ctx_pft_dft_hot_dist_intv[8]
			Ctx_pft_dft_hot_dist_intv[9]
			Ctx_pft_dft_hot_dist_intv[10]
			Ctx_pft_dft_hot_dist_intv[11]
			Ctx_pft_dft_hot_dist_intv[12]
			Ctx_pft_dft_hot_dist_intv[13]
			Ctx_pft_dft_hot_dist_intv[14]
			Ctx_pft_dft_hot_dist_intv[15]
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_hot_cold_dist_intv_vld
			Vsx_pft_hot_dist_intv_vld
			Vsx_pft_hot_med_dist_intv_vld
			Vtx_pft_hot_dist_intv[0]
			Vtx_pft_hot_dist_intv[1]
			Vtx_pft_hot_dist_intv[2]
			Vtx_pft_hot_dist_intv[3]
			Vtx_pft_hot_dist_intv[4]
			Vtx_pft_hot_dist_intv[5]
			Vtx_pft_hot_dist_intv[6]
			Vtx_pft_hot_dist_intv[7]
			Vtx_pft_hot_dist_intv[8]
			Vtx_pft_hot_dist_intv[9]
			Vtx_pft_hot_dist_intv[10]
			Vtx_pft_hot_dist_intv[11]
			Vtx_pft_hot_dist_intv[12]
			Vtx_pft_hot_dist_intv[13]
			Vtx_pft_hot_dist_intv[14]
			Vtx_pft_hot_dist_intv[15]
			Vtx_pft_hot_med_dist_intv[0]
			Vtx_pft_hot_med_dist_intv[1]
			Vtx_pft_hot_med_dist_intv[2]
			Vtx_pft_hot_med_dist_intv[3]
			Vtx_pft_hot_med_dist_intv[4]
			Vtx_pft_hot_med_dist_intv[5]
			Vtx_pft_hot_med_dist_intv[6]
			Vtx_pft_hot_med_dist_intv[7]
			Vtx_pft_hot_med_dist_intv[8]
			Vtx_pft_hot_med_dist_intv[9]
			Vtx_pft_hot_med_dist_intv[10]
			Vtx_pft_hot_med_dist_intv[11]
			Vtx_pft_hot_med_dist_intv[12]
			Vtx_pft_hot_med_dist_intv[13]
			Vtx_pft_hot_med_dist_intv[14]
			Vtx_pft_hot_med_dist_intv[15]
			Vtx_pft_hot_cold_dist_intv[0]
			Vtx_pft_hot_cold_dist_intv[1]
			Vtx_pft_hot_cold_dist_intv[2]
			Vtx_pft_hot_cold_dist_intv[3]
			Vtx_pft_hot_cold_dist_intv[4]
			Vtx_pft_hot_cold_dist_intv[5]
			Vtx_pft_hot_cold_dist_intv[6]
			Vtx_pft_hot_cold_dist_intv[7]
			Vtx_pft_hot_cold_dist_intv[8]
			Vtx_pft_hot_cold_dist_intv[9]
			Vtx_pft_hot_cold_dist_intv[10]
			Vtx_pft_hot_cold_dist_intv[11]
			Vtx_pft_hot_cold_dist_intv[12]
			Vtx_pft_hot_cold_dist_intv[13]
			Vtx_pft_hot_cold_dist_intv[14]
			Vtx_pft_hot_cold_dist_intv[15]
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Lastopp
		""
	/begin DEF_CHARACTERISTIC
			Cxx_pft_req_t_cold_rgn
			Cxx_pft_req_t_hot_rgn
			Cxx_pft_req_t_med_rgn
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_hot_cold_id
			Vbx_pft_hot_id
			Vbx_pft_hot_med_id
			Vxx_pft_last_hot_cold_dist
			Vxx_pft_last_hot_dist
			Vxx_pft_last_hot_med_dist
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Loadspd
		""
	/begin DEF_CHARACTERISTIC
			Ctp_pft_inj_dist_load_spd_dft
			Cxx_pft_load_spd_dft_max
			Cxx_pft_load_spd_dist_intv_min
			Ctp_pft_dist_load_spd_dft_cor
			Ctp_pft_tia_load_spd_dft_cor
			Cxx_ms_ref_aftr_rgn_dist_dly
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vsx_pft_mv_sot_load_spd_vld
			Vbx_pft_load_spd_clc_rst_ms
			Vbx_pft_load_spd_clc_rst_pft
			Vbx_pft_load_spd_clc_stt_dec
			Vbx_pft_load_spd_clc_stt_inc
			Vsx_pft_load_spd_clc_stt_prev
			Vxx_pft_load_spd_dft
			Vxx_pft_mv_pos_sot_load_spd
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Nxtoppx
		""
	/begin DEF_CHARACTERISTIC
			Ntx_pft_intv_ind_sum_rat
			Cxx_pft_esti_req_dist_prot_lvl
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_hot_cold_dist_intv_ovs
			Vbx_pft_hot_dist_intv_ovs
			Vbx_pft_hot_med_dist_intv_ovs
			Vbx_pft_per_req_intv_clc
			Vsx_pft_hot_cold_req_dist_vld
			Vsx_pft_hot_med_req_dist_vld
			Vsx_pft_hot_req_dist_vld
			Vtx_pft_hot_cold_intv_sum_rat[0]
			Vtx_pft_hot_cold_intv_sum_rat[1]
			Vtx_pft_hot_cold_intv_sum_rat[2]
			Vtx_pft_hot_cold_intv_sum_rat[3]
			Vtx_pft_hot_cold_intv_sum_rat[4]
			Vtx_pft_hot_cold_intv_sum_rat[5]
			Vtx_pft_hot_cold_intv_sum_rat[6]
			Vtx_pft_hot_cold_intv_sum_rat[7]
			Vtx_pft_hot_cold_intv_sum_rat[8]
			Vtx_pft_hot_cold_intv_sum_rat[9]
			Vtx_pft_hot_cold_intv_sum_rat[10]
			Vtx_pft_hot_cold_intv_sum_rat[11]
			Vtx_pft_hot_cold_intv_sum_rat[12]
			Vtx_pft_hot_cold_intv_sum_rat[13]
			Vtx_pft_hot_cold_intv_sum_rat[14]
			Vtx_pft_hot_cold_intv_sum_rat[15]
			Vtx_pft_hot_intv_sum_rat[0]
			Vtx_pft_hot_intv_sum_rat[1]
			Vtx_pft_hot_intv_sum_rat[2]
			Vtx_pft_hot_intv_sum_rat[3]
			Vtx_pft_hot_intv_sum_rat[4]
			Vtx_pft_hot_intv_sum_rat[5]
			Vtx_pft_hot_intv_sum_rat[6]
			Vtx_pft_hot_intv_sum_rat[7]
			Vtx_pft_hot_intv_sum_rat[8]
			Vtx_pft_hot_intv_sum_rat[9]
			Vtx_pft_hot_intv_sum_rat[10]
			Vtx_pft_hot_intv_sum_rat[11]
			Vtx_pft_hot_intv_sum_rat[12]
			Vtx_pft_hot_intv_sum_rat[13]
			Vtx_pft_hot_intv_sum_rat[14]
			Vtx_pft_hot_intv_sum_rat[15]
			Vtx_pft_hot_med_intv_sum_rat[0]
			Vtx_pft_hot_med_intv_sum_rat[1]
			Vtx_pft_hot_med_intv_sum_rat[2]
			Vtx_pft_hot_med_intv_sum_rat[3]
			Vtx_pft_hot_med_intv_sum_rat[4]
			Vtx_pft_hot_med_intv_sum_rat[5]
			Vtx_pft_hot_med_intv_sum_rat[6]
			Vtx_pft_hot_med_intv_sum_rat[7]
			Vtx_pft_hot_med_intv_sum_rat[8]
			Vtx_pft_hot_med_intv_sum_rat[9]
			Vtx_pft_hot_med_intv_sum_rat[10]
			Vtx_pft_hot_med_intv_sum_rat[11]
			Vtx_pft_hot_med_intv_sum_rat[12]
			Vtx_pft_hot_med_intv_sum_rat[13]
			Vtx_pft_hot_med_intv_sum_rat[14]
			Vtx_pft_hot_med_intv_sum_rat[15]
			Vxx_pft_hot_cold_dist_intv_ovs
			Vxx_pft_hot_cold_req_dist_intv
			Vxx_pft_hot_dist_intv_ovs
			Vxx_pft_hot_med_dist_intv_ovs
			Vxx_pft_hot_med_req_dist_intv
			Vxx_pft_hot_req_dist_intv
			Vxx_pft_nxt_hot_cold_req_dist
			Vxx_pft_nxt_hot_med_req_dist
			Vxx_pft_nxt_hot_req_dist
			Vxx_pft_per_hot_cold_req_dist
			Vxx_pft_per_hot_cold_req_intv
			Vxx_pft_per_hot_med_req_dist
			Vxx_pft_per_hot_med_req_intv
			Vxx_pft_per_hot_req_dist
			Vxx_pft_per_hot_req_intv
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Rgnreqx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_efy_ms_comb
			Ctb_pft_efy_ms_stop
			Ctb_pft_max_rgn_t_csm
			Ctb_pft_max_rgn_t_vs
			Ctb_pft_min_rgn_df_val_t
			Cxx_pft_csm_rgn_err_dft
			Cxx_pft_ctr_err_min_still
			Cxx_pft_fac_sot_comb
			Cxx_pft_fac_sot_stop
			Cxx_pft_ff_pft_hot
			Cxx_pft_ff_rgn_err
			Cxx_pft_ff_rgn_err_hot
			Cxx_pft_max_rgn_t_comp
			Cxx_pft_min_rgn_err_hot_t
			Cxx_pft_min_rgn_err_t
			Cxx_pft_min_rgn_t
			Cxx_pft_ms_sta_min
			Cxx_pft_utp_pft_hot
			Cxx_pft_utp_rgn_err
			Cxx_pft_utp_rgn_err_hot
			Ctp_pft_csm_max_rgn_t
			Ctp_pft_min_rgn_df_val_t
			Ctp_pft_ms_comb
			Ctp_pft_ms_stop
			Ctp_pft_vs_max_rgn_t
			Cbx_pft_swi_ms_comb_cfm
			Cbx_pft_swi_ms_stop_cfm
			Cxx_pft_csm_drv_max_rgn_t_dft
			Cxx_pft_efy_prct_sot_comb_dft
			Cbx_pft_spd_req_lght_ena
			Cbx_sot_comb_stt_rst_ena
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_rgn_req_end
			Vbx_pft_rgn_req_ini
			Vbx_pft_rgn_req_stt
			Vbx_pft_rgn_sta_cdn_1
			Vbx_pft_rgn_sta_cdn_2
			Vbx_pft_temp_l
			Vbx_pft_temp_l_hot
			Vbx_pft_trs_cdn_10
			Vbx_pft_trs_cdn_11
			Vbx_pft_trs_cdn_8
			Vbx_pft_trs_req_8
			Vxx_pft_max_rgn_t
			Vxx_pft_rgn_req_t_ctr
			Vbx_pft_sot_comb_esti_stt
			Vbx_pft_sot_comb_stt
			Vbx_pft_rgn_thd_temp_err
			Vxx_csm_sum_sta_drv_fil_rgn
			Vxx_pft_efy_prct_comb
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Rgnsucx
		""
	/begin DEF_CHARACTERISTIC
			Cbx_pft_ctr_rgn_rst
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_cond_rgnsuc_act
			Vxx_pft_rgn_ok_nr
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Rgntpxx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_tco_rgn
			Ctb_tco_rgn_ena
			Ctb_tia_rgn
			Ctb_tia_rgn_ena
			Cxx_pft_amp_rgn_ena_h
			Cxx_pft_amp_rgn_ena_l
			Cxx_pft_oil_max_t
			Cxx_pft_temp_min_rgn_h
			Cxx_pft_temp_min_rgn_l
			Cxx_rgn_dsb_max_t
			Cmp_pft_temp_min_rgn
			Cmp_pft_temp_min_rgn_ena
			Cbx_pft_oil_clc_ena
			Ctb_toil_rgn_err
			Ctp_toil_t_ctr_err_fac
			Cxx_pft_amp_rgn_ena_1_dft
			Cxx_pft_tco_rgn_ena_1_dft
			Cxx_pft_tia_rgn_ena_1_dft
			Csx_pft_rgn_err_t_ctr_mask
			Csx_pft_rgn_err_t_ctr_mask_2
			Csx_pft_rgn_err_vh_dist_mask
			Csx_pft_rgn_err_vh_dist_mask_2
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_stt_rgn_ena_1
			Vbx_pft_stt_rgn_ena_2
			Vbx_pft_trs_ena
			Vxx_tco_ena
			Vxx_tia_ena
			Vxx_pft_t_ofs
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Spdreqx
		""
	/begin DEF_CHARACTERISTIC
			Cxx_csm_sta_spd_req_dft
			Cxx_pft_ff_sum_sta_spd_req
			Cxx_pft_spd_req_max_t
			Cxx_pft_spd_vh_spd_req
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_trs_cdn_3
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Sttoutx
		""
	/begin DEF_CHARACTERISTIC
			Ctb_inj_dist_wait_cdn
			Ctb_pft_tia_wait_cdn
			Ctb_vh_dist_wait_cdn
			Ctp_ms_cor_inj_dist_wait_cdn
			Ctp_pft_ms_wait_cdn
			Ctp_pft_ms_wait_cdn_cor_tia
			Cbx_pft_clos_rgn_swi
			Cbx_pft_wait_mod_vh_dist_thd
			Cxx_pft_clos_rgn_dist_swi
			Cxx_pft_clos_rgn_ms_swi
			Cxx_pft_dist_rgn_ofs_clos_rgn
			Cxx_pft_min_ms_cor_wait_mod
			Cxx_pft_ms_rgn_ofs_clos_rgn
			Cxx_pft_tia_mv_wait_cdn_dft
			Cxx_pft_wait_mod_min_vh_dist
			Cxx_pft_wait_ms_ofs
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vxx_pft_ms_wait_cdn
			Vxx_pft_tia_mv_out
			Vbx_pft_clos_rgn
			Vbx_pft_wait_cdn_req
	/end OUT_MEASUREMENT
/end FUNCTION
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/begin FUNCTION
		AtPftMng_Thdchgt
		""
	/begin DEF_CHARACTERISTIC
			Ctb_pft_efy_rgn
			Ctb_pft_inj_dist_rgn
			Ctb_pft_tia_mv_err_ctr
			Ctb_pft_tia_mv_ms_rgn_cor
			Cxx_dist_fac_ms_1
			Cxx_dist_fac_ms_2
			Cxx_dist_fac_ms_4
			Cxx_ms_fac_dist_1
			Cxx_ms_fac_dist_2
			Cxx_ms_fac_dist_4
			Cxx_pft_ctr_spd_req_err
			Cxx_pft_dist_rgn_1_max
			Cxx_pft_dist_rgn_1_min
			Cxx_pft_dist_rgn_2_max
			Cxx_pft_dist_rgn_2_min
			Cxx_pft_dist_rgn_3_max
			Cxx_pft_dist_rgn_3_min
			Cxx_pft_dist_rgn_4_min
			Cxx_pft_ms_rgn_1_max
			Cxx_pft_ms_rgn_1_min
			Cxx_pft_ms_rgn_2_max
			Cxx_pft_ms_rgn_2_min
			Cxx_pft_ms_rgn_3_max
			Cxx_pft_ms_rgn_3_min
			Cxx_pft_ms_rgn_4_max
			Cxx_pft_ms_rgn_4_min
			Ctd_pft_tair_rgn_err_cold_cnd
			Ctd_pft_tair_rgn_err_wait_mod
			Ctp_pft_dist_cor_tia_mv_1
			Ctp_pft_dist_cor_tia_mv_2
			Ctp_pft_dist_cor_tia_mv_3
			Ctp_pft_dist_ctr_err_inj_dist
			Ctp_pft_dist_ctr_err_tia
			Ctp_pft_dist_rgn_1
			Ctp_pft_dist_rgn_2
			Ctp_pft_dist_rgn_3
			Ctp_pft_dist_rgn_4
			Ctp_pft_dist_rgn_err_forc
			Ctp_pft_dist_rgn_err_forc_inj
			Ctp_pft_dist_rgn_err_forc_tia
			Ctp_pft_dist_rgn_err_forc_vh
			Ctp_pft_min_ms_spd_req_err
			Ctp_pft_ms_cor_inj_dist_rgn_3
			Ctp_pft_ms_cor_tia_mv_1
			Ctp_pft_ms_cor_tia_mv_2
			Ctp_pft_ms_cor_tia_mv_3
			Ctp_pft_ms_cor_tia_mv_4
			Ctp_pft_ms_cor_tia_mv_forc
			Ctp_pft_ms_cor_vh_dist_rgn_1
			Ctp_pft_ms_cor_vh_dist_rgn_2
			Ctp_pft_ms_cor_vh_dist_rgn_3
			Ctp_pft_ms_cor_vh_dist_rgn_4
			Ctp_pft_ms_rgn_1
			Ctp_pft_ms_rgn_2
			Ctp_pft_ms_rgn_3
			Ctp_pft_ms_rgn_4
			Ctp_pft_ms_rgn_forc
			Ctb_pft_tia_mv_dist_thd
			Ctb_vh_dist_rgn
			Cxx_pft_dist_rgn_err_forc_max
			Cxx_pft_ms_rgn_forc_max
			Cxx_pft_ms_rgn_forc_min
			Cxx_pft_efy_prct_chg_end_dft
			Ctp_pft_dist_cor_tia_mv_4
			Ctp_pft_dist_cor_tia_mv_5
			Ctp_pft_dist_rgn_5
			Ctp_pft_dist_rgn_6
			Ctp_pft_dist_rgn_7
			Cxx_pft_dist_rgn_4_max
			Cxx_pft_dist_rgn_5_max
			Cxx_pft_dist_rgn_5_min
			Cxx_pft_rgn_err_max_cold_ofs
			Ctp_pft_dist_cor_inj_dist_1
			Ctp_pft_dist_cor_inj_dist_2
			Ctp_pft_dist_cor_inj_dist_3
			Ctp_pft_dist_cor_inj_dist_4
			Ctp_pft_dist_cor_inj_dist_5
			Ctp_pft_dist_cor_vh_dist_1
			Ctp_pft_dist_cor_vh_dist_2
			Ctp_pft_dist_cor_vh_dist_3
			Ctp_pft_dist_cor_vh_dist_4
			Ctp_pft_dist_cor_vh_dist_5
			Ctp_pft_ms_cor_dist_rgn_forc
			Ctb_pft_oil_dil_dist_rgn_cold
			Ctb_pft_oil_dil_dist_rgn_hot
			Ctb_pft_oil_dil_dist_rgn_med
			Ctp_pft_dist_err_oil_dil_cold
			Ctp_pft_dist_err_oil_dil_hot
			Ctp_pft_dist_err_oil_dil_med
			Ctp_pft_dist_err_dist_cold
			Ctp_pft_dist_err_dist_hot
			Ctp_pft_dist_err_dist_med
			Cxx_pft_dist_rgn_err_forc_min
			Cxx_pft_rgn_err_max_hot
			Cxx_pft_rgn_err_max_med
	/end DEF_CHARACTERISTIC
	/begin OUT_MEASUREMENT
			Vbx_pft_max_rgn_err_spd_rq
			Vbx_pft_max_rgn_err_wait_mod
			Vbx_pft_ms_thd_cold_ok
			Vbx_pft_ms_thd_hot_ok
			Vbx_pft_ms_thd_med_ok
			Vbx_pft_ms_thd_rgn_forc_ok
			Vbx_pft_ms_thd_spd_req_ok
			Vbx_pft_spd_req_err
			Vbx_pft_vh_dist_ms_err
			Vbx_pft_vh_dist_thd_cold_ok
			Vbx_pft_vh_dist_thd_hot_ok
			Vbx_pft_vh_dist_thd_med_ok
			Vbx_pft_vh_dist_thd_spd_req_ok
			Vxx_fac_dist_ms_1
			Vxx_fac_dist_ms_2
			Vxx_fac_dist_ms_4
			Vxx_fac_ms_dist_1
			Vxx_fac_ms_dist_2
			Vxx_fac_ms_dist_4
