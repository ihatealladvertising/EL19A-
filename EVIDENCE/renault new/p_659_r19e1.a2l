    SYSTEM_CONSTANT "RAIL_SWTPRESS_VAL" "0"
    SYSTEM_CONSTANT "RAIL_SWTWINDUP_TYPE" "2"
    SYSTEM_CONSTANT "RAIL_SWTWINDUP_VAL" "1"
    SYSTEM_CONSTANT "RAIL_TIMEUNCTLDT1_CURX" "16"
    SYSTEM_CONSTANT "RAIL_TIMEUNCTLPT1_CURX" "16"
    SYSTEM_CONSTANT "RAIL_TIMEUNRMPDUR_CURX" "10"
    SYSTEM_CONSTANT "RAIL_TIPCVCTLDT1_CURX" "16"
    SYSTEM_CONSTANT "RAIL_TIPCVRMPDUR_CURX" "10"
    SYSTEM_CONSTANT "RAIL_TMEUNCTLTYPE_CUR_X" "8"
    SYSTEM_CONSTANT "RAIL_TPCVCTLTYPE_CUR_X" "8"
    SYSTEM_CONSTANT "RAIL_WITHOUT_PRECTL" "0"
    SYSTEM_CONSTANT "RAIL_WITH_PRECTL" "1"
    SYSTEM_CONSTANT "RATAM_RES" "0.01"
    SYSTEM_CONSTANT "RATAM_RES_FL" "0.01"
    SYSTEM_CONSTANT "RATAM_RES_REV" "100"
    SYSTEM_CONSTANT "RATAM_ZERO" "0"
    SYSTEM_CONSTANT "RATASHM_RES" "1e-005"
    SYSTEM_CONSTANT "RATASHM_RES_REV" "100000"
    SYSTEM_CONSTANT "RATCM_RES" "1e-006"
    SYSTEM_CONSTANT "RATCOMASS_RES" "1e-006"
    SYSTEM_CONSTANT "RATCOMASS_RES_FL" "1e-006"
    SYSTEM_CONSTANT "RATFM_ONE" "1"
    SYSTEM_CONSTANT "RATFM_RES" "0.01"
    SYSTEM_CONSTANT "RATFM_RES_REV" "100"
    SYSTEM_CONSTANT "RATFM_ZERO" "0"
    SYSTEM_CONSTANT "RATMSNOX1_MAX" "1"
    SYSTEM_CONSTANT "RATMSNOX1_MIN" "0"
    SYSTEM_CONSTANT "RATMSNOX1_RES" "0.001"
    SYSTEM_CONSTANT "RATMSNOX1_RES_REV" "1000"
    SYSTEM_CONSTANT "RATNOXM_RES" "1e-007"
    SYSTEM_CONSTANT "RATNOXM_RES_FL" "1e-007"
    SYSTEM_CONSTANT "RATNOXM_RES_REV" "10000000"
    SYSTEM_CONSTANT "RATSOTM_RES" "1e-005"
    SYSTEM_CONSTANT "RATSOTM_RES_REV" "100000"
    SYSTEM_CONSTANT "RATSOTSOT_RESO" "0.001"
    SYSTEM_CONSTANT "RATSOXM_RES" "1e-008"
    SYSTEM_CONSTANT "RATSOXM_RES_FL" "1e-008"
    SYSTEM_CONSTANT "RATSOXM_RES_REV" "100000000"
    SYSTEM_CONSTANT "RAT_00125_RES_RSA" "800"
    SYSTEM_CONSTANT "RAT_NOXMON_MAX" "1"
    SYSTEM_CONSTANT "RAT_NOXMON_MIN" "0"
    SYSTEM_CONSTANT "RAT_NOXMON_RES" "0.001"
    SYSTEM_CONSTANT "RAT_NOXMON_RES_REV" "1000"
    SYSTEM_CONSTANT "RDCMASSPERTIME_RES" "0.0001"
    SYSTEM_CONSTANT "RDCMASSPERTIME_RES_REV" "10000"
    SYSTEM_CONSTANT "RDCMASSPERTIME_ZERO" "0"
    SYSTEM_CONSTANT "RDCMASS_RES" "0.001"
    SYSTEM_CONSTANT "RDCMASS_RES_REV" "1000"
    SYSTEM_CONSTANT "RESIST_RES" "0.1"
    SYSTEM_CONSTANT "RESO_T_INC_PER_DUR_TTH_ADAP" "10"
    SYSTEM_CONSTANT "RESVCONST_SY" "1"
    SYSTEM_CONSTANT "RESVREL_SY" "1"
    SYSTEM_CONSTANT "RES_ADAPT03_RSA" "3333"
    SYSTEM_CONSTANT "RES_FACT_256" "256"
    SYSTEM_CONSTANT "REVCNT_RES" "16"
    SYSTEM_CONSTANT "REVCNT_RES_EXP" "4"
    SYSTEM_CONSTANT "REVGEAR1" "-1"
    SYSTEM_CONSTANT "REYNOLDS_NUM1_RES" "1000"
    SYSTEM_CONSTANT "REYNOLDS_NUM_RES" "100"
    SYSTEM_CONSTANT "RHOQ0P001_INVRESO" "1000"
    SYSTEM_CONSTANT "RHOQ0P001_RESO" "0.001"
    SYSTEM_CONSTANT "RHO_FUEL_RES" "0.1"
    SYSTEM_CONSTANT "RHO_FUEL_RES_REV" "10"
    SYSTEM_CONSTANT "RHO_FUEL_RES_RSA_REV" "1"
    SYSTEM_CONSTANT "RHO_OILASH_RES" "0.1"
    SYSTEM_CONSTANT "RMPDTYCYC_MAX" "100"
    SYSTEM_CONSTANT "RMPDTYCYC_MIN" "0"
    SYSTEM_CONSTANT "RMPENG_N_HIRES" "0.1"
    SYSTEM_CONSTANT "RMPENG_N_HIRES_REV" "10"
    SYSTEM_CONSTANT "RMPGOVRESREV_SY" "512"
    SYSTEM_CONSTANT "RMPPRC_MAX" "100"
    SYSTEM_CONSTANT "RMPPRC_MIN" "0"
    SYSTEM_CONSTANT "RMPSQRVLG_S_1000_REF" "1000"
    SYSTEM_CONSTANT "RMPSQRVLG_S_100_REF" "100"
    SYSTEM_CONSTANT "RMPSQRVLG_S_REF" "1000"
    SYSTEM_CONSTANT "RMPSQRVLG_S_RES" "65536"
    SYSTEM_CONSTANT "RMP_INTMIN_DT10" "6554"
    SYSTEM_CONSTANT "RMP_INTMIN_DT100" "656"
    SYSTEM_CONSTANT "RMP_INTMIN_DT20" "3277"
    SYSTEM_CONSTANT "RMP_NRM_EXP" "16"
    SYSTEM_CONSTANT "RMP_RES" "0.0152587890625"
    SYSTEM_CONSTANT "RMP_RES_1" "0.001"
    SYSTEM_CONSTANT "RMP_RES_1_REV" "1000"
    SYSTEM_CONSTANT "RMP_RES_INV" "65.536"
    SYSTEM_CONSTANT "RNGMOD_TRQCHEXCHLOSS_MAP_X" "16"
    SYSTEM_CONSTANT "RNGMOD_TRQCHEXCHLOSS_MAP_Y" "16"
    SYSTEM_CONSTANT "RNGMOD_TRQFRCLD_MAP_X" "16"
    SYSTEM_CONSTANT "RNGMOD_TRQFRCLD_MAP_Y" "16"
    SYSTEM_CONSTANT "RNGMOD_TRQFRC_MAP_X" "16"
    SYSTEM_CONSTANT "RNGMOD_TRQFRC_MAP_Y" "16"
    SYSTEM_CONSTANT "RNGMOD_TRQSPD_CUR_X" "25"
    SYSTEM_CONSTANT "RNOX_ZERO" "0"
    SYSTEM_CONSTANT "RO2EXHGS_RESLO" "20000"
    SYSTEM_CONSTANT "ROOM_RES" "256"
    SYSTEM_CONSTANT "RPM025_RSA_RES" "0.25"
    SYSTEM_CONSTANT "RPM025_RSA_RES_REV" "4"
    SYSTEM_CONSTANT "RPM_025_RSA_RES" "0.25"
    SYSTEM_CONSTANT "RPM_32_RSA_RES" "32"
    SYSTEM_CONSTANT "RSA_CONST_CLUTCH_CLOSED" "1"
    SYSTEM_CONSTANT "RSA_CONST_IDLE_GEAR" "0"
    SYSTEM_CONSTANT "RSA_CONST_NEUT_GEAR" "1"
    SYSTEM_CONSTANT "RSA_TISEG_RES_REV" "15625"
    SYSTEM_CONSTANT "RSLTBUFSIZE" "48"
    SYSTEM_CONSTANT "RX_ACC_CANHS_R_01_FRM_SIZE" "8"
    SYSTEM_CONSTANT "RX_AIRBAGCRASH_FRM_SIZE" "2"
    SYSTEM_CONSTANT "RX_BCM_CANHS_RNR_01_FRM_SIZE" "8"
    SYSTEM_CONSTANT "RX_BCM_CANHS_RNR_02_FRM_SIZE" "8"
    SYSTEM_CONSTANT "RX_BCM_VERLOG_FRM_SIZE" "5"
    SYSTEM_CONSTANT "RX_BRAKE_CANHS_RNR_01_FRM_SIZE" "7"
    SYSTEM_CONSTANT "RX_BRAKE_CANHS_RNR_02_FRM_SIZE" "6"
    SYSTEM_CONSTANT "RX_BRAKE_CANHS_RNR_03_FRM_SIZE" "6"
    SYSTEM_CONSTANT "RX_BRAKE_CANHS_RNR_04_FRM_SIZE" "8"
    SYSTEM_CONSTANT "RX_BRAKE_CANHS_R_01_FRM_SIZE" "7"
    SYSTEM_CONSTANT "RX_CLIM_CANHS_R_01_FRM_SIZE" "6"
    SYSTEM_CONSTANT "RX_CLUSTER_CANHS_RNR_01_FRM_SIZE" "5"
    SYSTEM_CONSTANT "RX_CLUSTER_CANHS_R_01_FRM_SIZE" "8"
    SYSTEM_CONSTANT "RX_DDCM_CANLSFT_R_01_FRM_SIZE" "5"
    SYSTEM_CONSTANT "RX_SWA_CANHS_RNR_01_FRM_SIZE" "8"
    SYSTEM_CONSTANT "RX_TORQUE_AT_CANHS_RNR_01_FRM_SIZE" "8"
    SYSTEM_CONSTANT "RX_TORQUE_AT_CANHS_RNR_02_FRM_SIZE" "7"
    SYSTEM_CONSTANT "RX_USM_CANHS_RNR_01_FRM_SIZE" "5"
    SYSTEM_CONSTANT "R_COIL_MAX" "5000"
    SYSTEM_CONSTANT "R_COIL_MIN" "0"
    SYSTEM_CONSTANT "R_LAMREC_MAX" "4"
    SYSTEM_CONSTANT "R_LAMREC_MIN" "0"
    SYSTEM_CONSTANT "R_RES" "1"
    SYSTEM_CONSTANT "R_STOICH_FL" "14.5"
    SYSTEM_CONSTANT "SCALEFACDIV_RES" "200"
    SYSTEM_CONSTANT "SCR_DTYCYC_RES" "0.1"
    SYSTEM_CONSTANT "SCR_DTYCYC_RES_REV" "10"
    SYSTEM_CONSTANT "SCR_FACT_RES" "1000"
    SYSTEM_CONSTANT "SEC2USEC_FL" "1000000"
    SYSTEM_CONSTANT "SEC_RES" "1"
    SYSTEM_CONSTANT "SETPOINTCALC_TRQBASED_SY" "0"
    SYSTEM_CONSTANT "SIA_GENR_SY" "4"
    SYSTEM_CONSTANT "Signals_Mode1PidSize_SY" "2"
    SYSTEM_CONSTANT "Signals_NumberPID_SY" "2"
    SYSTEM_CONSTANT "Signals_NumberSigNumExt_SY" "79"
    SYSTEM_CONSTANT "Signals_NumberSigNumIntStd_SY" "100"
    SYSTEM_CONSTANT "Signals_NumberSigNumInt_SY" "100"
    SYSTEM_CONSTANT "SLPTIME_NORM" "10000"
    SYSTEM_CONSTANT "SLP_RES" "0.1"
    SYSTEM_CONSTANT "SLP_RES_REV" "10"
    SYSTEM_CONSTANT "SMKLIM_FACRHO" "10000"
    SYSTEM_CONSTANT "SMKLIM_FACSLPRMP_CURX" "5"
    SYSTEM_CONSTANT "SMKLIM_NUMINPVAL" "6"
    SYSTEM_CONSTANT "SMKLIM_QNT_RES" "1280000"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISFULLLD_MAP_X" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISFULLLD_MAP_Y" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISNRM_MAP_X" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISNRM_MAP_Y" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISRGN0_MAP_X" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISRGN0_MAP_Y" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISRGN1_MAP_X" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISRGN1_MAP_Y" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISRGN2_MAP_X" "16"
    SYSTEM_CONSTANT "SMKLIM_RLAMAXISRGN2_MAP_Y" "16"
    SYSTEM_CONSTANT "SMKLIM_RLMBDFULLLD_MAP_X" "16"
    SYSTEM_CONSTANT "SMKLIM_RLMBDFULLLD_MAP_Y" "16"
    SYSTEM_CONSTANT "SMKLIM_RLMBDSMK_MAP_X" "16"
    SYSTEM_CONSTANT "SMKLIM_RLMBDSMK_MAP_Y" "16"
    SYSTEM_CONSTANT "SOOT_GPERLTR_RES" "0.01"
    SYSTEM_CONSTANT "SOOT_GPERLTR_RES_REV" "100"
    SYSTEM_CONSTANT "SOOT_MASS_RES_RSA" "0.1"
    SYSTEM_CONSTANT "SOTMPT_RES" "0.01"
    SYSTEM_CONSTANT "SOTMPT_RES_REV" "100"
    SYSTEM_CONSTANT "SOTMSQ0P01_INVRESO" "100"
    SYSTEM_CONSTANT "SOTMS_KGPRSEC_INVRESO" "1"
    SYSTEM_CONSTANT "SOTMS_KGPRSEC_RESO" "1"
    SYSTEM_CONSTANT "SOXMPT_RES" "0.0001"
    SYSTEM_CONSTANT "SOXMPT_RES_REV" "10000"
    SYSTEM_CONSTANT "SPAVEL_RES" "10"
    SYSTEM_CONSTANT "SPDGOV_NSETP_ARRAY_HLSDEM_POS" "1"
    SYSTEM_CONSTANT "SPDGOV_OVRDS_PTPRT" "0"
    SYSTEM_CONSTANT "SPDGOV_SETPLO_ARRAYSIZE" "3"
    SYSTEM_CONSTANT "SPDIDX0" "16"
    SYSTEM_CONSTANT "SPDIDX1" "8"
    SYSTEM_CONSTANT "SPDIDX10" "5"
    SYSTEM_CONSTANT "SPDIDX2" "1"
    SYSTEM_CONSTANT "SPDIDX3" "9"
    SYSTEM_CONSTANT "SPDIDX4" "2"
    SYSTEM_CONSTANT "SPDIDX5" "10"
    SYSTEM_CONSTANT "SPDIDX6" "3"
    SYSTEM_CONSTANT "SPDIDX7" "11"
    SYSTEM_CONSTANT "SPDIDX8" "4"
    SYSTEM_CONSTANT "SPDIDX9" "12"
    SYSTEM_CONSTANT "SPDIDXHI" "14"
    SYSTEM_CONSTANT "SPDIDXLO" "13"
    SYSTEM_CONSTANT "SPECHEATFINE_RES" "0.2"
    SYSTEM_CONSTANT "SPECHEATFINE_RES_REV" "5"
    SYSTEM_CONSTANT "SPECHEAT_RES" "2"
    SYSTEM_CONSTANT "SPECHEAT_RES_FL" "2"
    SYSTEM_CONSTANT "SPECIFICHEAT_RES" "0.0001"
    SYSTEM_CONSTANT "SPECIFICHEAT_RES_REV" "10000"
    SYSTEM_CONSTANT "SPEED_RES_001_RSA" "100"
    SYSTEM_CONSTANT "SPEED_RES_1_RSA" "1"
    SYSTEM_CONSTANT "SPRT_SY" "0"
    SYSTEM_CONSTANT "SQRVLTG_S_RES" "0.1"
    SYSTEM_CONSTANT "SQRVLTG_S_RES_REV" "10"
    SYSTEM_CONSTANT "SQRVLTG_S_ZERO" "0"
    SYSTEM_CONSTANT "SSWTS_TYPE_DATASET" "2"
    SYSTEM_CONSTANT "SSWTS_TYPE_EEP" "1"
    SYSTEM_CONSTANT "STEEP_ADAPT" "1"
    SYSTEM_CONSTANT "STEEP_HOLD" "2"
    SYSTEM_CONSTANT "STRGTYP_HVELEC" "3"
    SYSTEM_CONSTANT "STRGTYP_LVELEC" "2"
    SYSTEM_CONSTANT "STRGTYP_MECH" "1"
    SYSTEM_CONSTANT "STRGTYP_NOSTRG" "0"
    SYSTEM_CONSTANT "STROKE_PML_RES" "0.1"
    SYSTEM_CONSTANT "STROKE_PML_RES_REV" "10"
    SYSTEM_CONSTANT "STRTTRQ_OFF" "0"
    SYSTEM_CONSTANT "STRTTRQ_ON" "1"
    SYSTEM_CONSTANT "STSP_SY" "0"
    SYSTEM_CONSTANT "STSYS_NSTRTCUTOUT_MAP_X" "4"
    SYSTEM_CONSTANT "STSYS_NSTRTCUTOUT_MAP_Y" "4"
    SYSTEM_CONSTANT "STSYS_TRQSTRTBAS_MAP_X" "16"
    SYSTEM_CONSTANT "STSYS_TRQSTRTBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "STWHL_DPHI_ZERO" "0"
    SYSTEM_CONSTANT "STWHL_PHI_ZERO" "0"
    SYSTEM_CONSTANT "ST_CHGREG" "4"
    SYSTEM_CONSTANT "ST_DYN" "1"
    SYSTEM_CONSTANT "ST_EIGHT" "8"
    SYSTEM_CONSTANT "ST_FIVE" "5"
    SYSTEM_CONSTANT "ST_FOUR" "4"
    SYSTEM_CONSTANT "ST_NOVRRUN" "2"
    SYSTEM_CONSTANT "ST_ONE" "1"
    SYSTEM_CONSTANT "ST_REGNV" "8"
    SYSTEM_CONSTANT "ST_RES_MAX" "2.5"
    SYSTEM_CONSTANT "ST_RES_MIN" "0"
    SYSTEM_CONSTANT "ST_RES_RES" "0.0001"
    SYSTEM_CONSTANT "ST_RES_RES_INV" "10000"
    SYSTEM_CONSTANT "ST_SIX" "6"
    SYSTEM_CONSTANT "ST_THREE" "3"
    SYSTEM_CONSTANT "ST_TWO" "2"
    SYSTEM_CONSTANT "ST_ZERO" "0"
    SYSTEM_CONSTANT "SVCRNT_ADCMAX_SY" "30000"
    SYSTEM_CONSTANT "SWT_DISABLED" "0"
    SYSTEM_CONSTANT "SWT_ENABLED" "1"
    SYSTEM_CONSTANT "SWT_TYPE_APPL" "2"
    SYSTEM_CONSTANT "SWT_TYPE_DATASET" "0"
    SYSTEM_CONSTANT "SWT_TYPE_EEP" "1"
    SYSTEM_CONSTANT "T15_ATS_SY" "1"
    SYSTEM_CONSTANT "TAA_CFG_SPDRNG" "1"
    SYSTEM_CONSTANT "TAA_ENTRY_PHIDVT" "84"
    SYSTEM_CONSTANT "TAA_ENTRY_TINC" "60"
    SYSTEM_CONSTANT "TAA_FACSINTAB_CAX" "30"
    SYSTEM_CONSTANT "TAA_FSTLRNURG" "25"
    SYSTEM_CONSTANT "TAA_INC_CMB" "20"
    SYSTEM_CONSTANT "TAA_INC_GAPHDL" "5"
    SYSTEM_CONSTANT "TAA_MAX_INC" "60"
    SYSTEM_CONSTANT "TAA_NUM_MAXGAP" "3"
    SYSTEM_CONSTANT "TAA_NUM_SPDRNG" "3"
    SYSTEM_CONSTANT "TAA_PHIMAX" "1"
    SYSTEM_CONSTANT "TCSOVRDSTSCINC_SY" "1"
    SYSTEM_CONSTANT "TCS_OVRDS_TSCINC" "1"
    SYSTEM_CONSTANT "TDC_Period_RES" "312500"
    SYSTEM_CONSTANT "TEGMOD_ALPHAEGPIPE_RES" "1280"
    SYSTEM_CONSTANT "TEGMOD_ALPHAPIPEENV_RES" "52428.8"
    SYSTEM_CONSTANT "TEGMOD_AREAPIPE_RES" "201.06192982976"
    SYSTEM_CONSTANT "TEGMOD_CMPRPWR_RES" "76747.2972710018"
    SYSTEM_CONSTANT "TEGMOD_DELTATEMP_RES" "100"
    SYSTEM_CONSTANT "TEGMOD_FACPT1_RES" "2812.5"
    SYSTEM_CONSTANT "TEGMOD_HEATFLOWKW_RES" "100000"
    SYSTEM_CONSTANT "TEGMOD_HEATFLOW_INTER_RES" "360"
    SYSTEM_CONSTANT "TEGMOD_HEATFLOW_RES" "1000"
    SYSTEM_CONSTANT "TEGMOD_HEATKJ_RES" "100"
    SYSTEM_CONSTANT "TEGMOD_HEATRANSOXIC_INTER1_RES" "81.92"
    SYSTEM_CONSTANT "TEGMOD_HEATRANSOXIC_RES" "1000"
    SYSTEM_CONSTANT "TEGMOD_HEATRANS_INTER_RES" "8192"
    SYSTEM_CONSTANT "TEGMOD_HEATRANS_RES" "10"
    SYSTEM_CONSTANT "TEGMOD_INTER1_RES" "0.01"
    SYSTEM_CONSTANT "TEGMOD_INTER2_RES" "0.001"
    SYSTEM_CONSTANT "TEGMOD_INTER_RES" "1"
    SYSTEM_CONSTANT "TEGMOD_PT1TIMECONST_RES" "335.54432"
    SYSTEM_CONSTANT "TEGMOD_REPIPEENV_RES" "17777.7777777778"
    SYSTEM_CONSTANT "TEGMOD_REPIPE_RES" "370.857896905592"
    SYSTEM_CONSTANT "TEGMOD_TEMPEG_INTER_RES" "2812.5"
    SYSTEM_CONSTANT "TEGMOD_TEMPEG_RES" "128"
    SYSTEM_CONSTANT "TEGMOD_TEMPTRBN_INTER_RES" "10485.76"
    SYSTEM_CONSTANT "TEGMOD_TEMPTRBN_RES" "9424.77796077"
    SYSTEM_CONSTANT "TEGRCLRDS_PHYSRNGCHK_SY" "0"
    SYSTEM_CONSTANT "TEMP01C_RSA_RB_OFFSET" "2331"
    SYSTEM_CONSTANT "TEMPCELS_FINE_RES" "0.001"
    SYSTEM_CONSTANT "TEMPCELS_FINE_RES_REV" "1000"
    SYSTEM_CONSTANT "TEMPC_RSA_1200" "1200"
    SYSTEM_CONSTANT "TEMP_20_CELS" "20"
    SYSTEM_CONSTANT "TEMP_CELS_1200" "1200"
    SYSTEM_CONSTANT "TEMP_CELS_150" "150"
    SYSTEM_CONSTANT "TEMP_CELS_1500" "1500"
    SYSTEM_CONSTANT "TEMP_CELS_M_100" "-100"
    SYSTEM_CONSTANT "TEMP_CELS_M_200" "-200"
    SYSTEM_CONSTANT "TEMP_CELS_RES" "0.1"
    SYSTEM_CONSTANT "TEMP_CELS_ZERO" "0"
    SYSTEM_CONSTANT "TEMP_ETCTL_SY" "25"
    SYSTEM_CONSTANT "TEMP_HIGH_RES" "0.01"
    SYSTEM_CONSTANT "TEMP_KELV_1200" "1200"
    SYSTEM_CONSTANT "TEMP_KELV_M_200" "-200"
    SYSTEM_CONSTANT "TEMP_KELV_SEC_CTT_MON_RES" "0"
    SYSTEM_CONSTANT "TEMP_KELV_SEC_CTT_MON_RES_REV" "40960"
    SYSTEM_CONSTANT "TEMP_LOW_RES" "1"
    SYSTEM_CONSTANT "TEMP_LOW_RES_REV" "1"
    SYSTEM_CONSTANT "TEMP_NULL_C" "-273.14"
    SYSTEM_CONSTANT "TEMP_NULL_C_FL" "-273.14"
    SYSTEM_CONSTANT "TEMP_NULL_F" "-459.652"
    SYSTEM_CONSTANT "TEMP_PA_MAX" "180"
    SYSTEM_CONSTANT "TEMP_PA_MIN" "-40"
    SYSTEM_CONSTANT "TEMP_PA_ZERO" "0"
    SYSTEM_CONSTANT "TEMP_RES" "0.1"
    SYSTEM_CONSTANT "TEMP_RES1" "0.01"
    SYSTEM_CONSTANT "TEMP_RES_FL" "0.1"
    SYSTEM_CONSTANT "TEMP_RES_INV" "10"
    SYSTEM_CONSTANT "TEMP_RES_INV_FL" "10"
    SYSTEM_CONSTANT "TEMP_RES_REV" "10"
    SYSTEM_CONSTANT "TEMP_WVCOR_MAX" "140"
    SYSTEM_CONSTANT "TEMP_WVCOR_MIN" "-40"
    SYSTEM_CONSTANT "TEMP_ZERO" "-273.14"
    SYSTEM_CONSTANT "TEMP_ZERO_KELV" "0"
    SYSTEM_CONSTANT "TEN_THOUSAND" "10000"
    SYSTEM_CONSTANT "THERMAL_COEFF_RES" "0.1"
    SYSTEM_CONSTANT "THMCND_RES" "0.001"
    SYSTEM_CONSTANT "THMCND_RES_FL" "0.001"
    SYSTEM_CONSTANT "THOUSAND" "1000"
    SYSTEM_CONSTANT "THRCPTY_RES" "1"
    SYSTEM_CONSTANT "THRVLV_RCNV_CUR_X" "25"
    SYSTEM_CONSTANT "THRVLV_RTRANSF_CUR_X" "25"
    SYSTEM_CONSTANT "THRVLV_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "THRVLV_TYPTWINFLW_SY" "0"
    SYSTEM_CONSTANT "TI10MS_RSA_RES" "10"
    SYSTEM_CONSTANT "TI10MS_RSA_RES_REV" "0.1"
    SYSTEM_CONSTANT "TI3US2_RSA_RES" "0.0032"
    SYSTEM_CONSTANT "TI3US2_RSA_RES_REV" "312.5"
    SYSTEM_CONSTANT "TIME100HRS_ENG_ON_RES" "1"
    SYSTEM_CONSTANT "TIMEDELAY_MAX" "4294"
    SYSTEM_CONSTANT "TIMEDELAY_MIN" "0.001"
    SYSTEM_CONSTANT "TIMEDELAY_S_2_MIN" "0.001"
    SYSTEM_CONSTANT "TIMEDELAY_S_2_NRM" "8"
    SYSTEM_CONSTANT "TIMEDELAY_S_LIN_16_MAX" "5"
    SYSTEM_CONSTANT "TIMEDELAY_S_LIN_16_MAX_ASDDC" "1.5"
    SYSTEM_CONSTANT "TIMEDELAY_S_LIN_16_MAX_ASDRF" "1.5"
    SYSTEM_CONSTANT "TIMEDELAY_S_LIN_16_REC_RES" "4294.967296"
    SYSTEM_CONSTANT "TIMEDELAY_S_LIN_16_RES" "0.000152592547379986"
    SYSTEM_CONSTANT "TIMEDT_RES" "1e-006"
    SYSTEM_CONSTANT "TIMEDT_RES_REV" "1000000"
    SYSTEM_CONSTANT "TIMEENGON_RES_REV" "1"
    SYSTEM_CONSTANT "TIMEHRS_ENG_ON_RES" "100"
    SYSTEM_CONSTANT "TIME_1S_RES" "1"
    SYSTEM_CONSTANT "TIME_20ms_CYCLE" "20000"
    SYSTEM_CONSTANT "TIME_CONV_KGH2GS" "3.6"
    SYSTEM_CONSTANT "TIME_DEB_10MS" "10000"
    SYSTEM_CONSTANT "TIME_DEB_NULL" "0"
    SYSTEM_CONSTANT "TIME_DEB_RES" "10"
    SYSTEM_CONSTANT "TIME_DEB_ZERO" "0"
    SYSTEM_CONSTANT "TIME_DT_1000MS" "1000000"
    SYSTEM_CONSTANT "TIME_DT_100MS" "100000"
    SYSTEM_CONSTANT "TIME_DT_10MS" "10000"
    SYSTEM_CONSTANT "TIME_DT_1MS" "1000"
    SYSTEM_CONSTANT "TIME_DT_1S" "1000000"
    SYSTEM_CONSTANT "TIME_DT_200MS" "200000"
    SYSTEM_CONSTANT "TIME_DT_20MS" "20000"
    SYSTEM_CONSTANT "TIME_DT_2MS" "2000"
    SYSTEM_CONSTANT "TIME_DT_50MS" "50000"
    SYSTEM_CONSTANT "TIME_DT_5MS" "5000"
    SYSTEM_CONSTANT "TIME_DT_RES" "1"
    SYSTEM_CONSTANT "TIME_DT_RES_FL" "1"
    SYSTEM_CONSTANT "TIME_DT_S" "1000000"
    SYSTEM_CONSTANT "TIME_ENGONOBD_RES" "1"
    SYSTEM_CONSTANT "TIME_ENG_ON_RES" "1"
    SYSTEM_CONSTANT "TIME_GPTA_CLOCK_50ns" "0.05"
    SYSTEM_CONSTANT "TIME_GT0_CLOCK_400ns" "0.0004"
    SYSTEM_CONSTANT "TIME_HR2SEC" "3600"
    SYSTEM_CONSTANT "TIME_HR_MAX" "16383"
    SYSTEM_CONSTANT "TIME_HR_MIN" "0"
    SYSTEM_CONSTANT "TIME_HR_RES" "0.5"
    SYSTEM_CONSTANT "TIME_HR_RES_REV" "2"
    SYSTEM_CONSTANT "TIME_MS_10MS" "10"
    SYSTEM_CONSTANT "TIME_MS_MAX" "327460"
    SYSTEM_CONSTANT "TIME_MS_MAXS32" "214748364.7"
    SYSTEM_CONSTANT "TIME_MS_SMAX" "327460"
    SYSTEM_CONSTANT "TIME_MS_ZERO" "0"
    SYSTEM_CONSTANT "TIME_PWM_HIGH_RES" "5e-008"
    SYSTEM_CONSTANT "TIME_PZOCHRGPSE_MAX" "20"
    SYSTEM_CONSTANT "TIME_PZOCHRGPSE_MIN" "2"
    SYSTEM_CONSTANT "TIME_PZOCHRGPSE_RES" "0.01"
    SYSTEM_CONSTANT "TIME_PZOCHRGPSE_ZERO" "0"
    SYSTEM_CONSTANT "TIME_PZOMEAS_RES" "0.0546"
    SYSTEM_CONSTANT "TIME_RED_MAX" "3600"
    SYSTEM_CONSTANT "TIME_RED_NRM" "4"
    SYSTEM_CONSTANT "TIME_RED_RES" "0.16"
    SYSTEM_CONSTANT "TIME_RED_RES_REV" "6.25"
    SYSTEM_CONSTANT "TIME_RED_ZERO" "0"
    SYSTEM_CONSTANT "TIME_RES_FL" "1e-006"
    SYSTEM_CONSTANT "TIME_RMP_RES" "53687091.2"
    SYSTEM_CONSTANT "TIME_SEC2HR" "1800"
    SYSTEM_CONSTANT "TIME_SEC_PER_HOUR" "3600"
    SYSTEM_CONSTANT "TIME_SEC_RES_RSA" "0.01"
    SYSTEM_CONSTANT "TIME_S_12000" "12000"
    SYSTEM_CONSTANT "TIME_S_1_RES" "0.001"
    SYSTEM_CONSTANT "Time_s_LORES_RES" "1"
    SYSTEM_CONSTANT "Time_s_LORES_RES_REV" "1"
    SYSTEM_CONSTANT "TIME_S_MAX" "327.46"
    SYSTEM_CONSTANT "TIME_S_NSCRGN_MAX" "327.66"
    SYSTEM_CONSTANT "TIME_S_ONE" "1"
    SYSTEM_CONSTANT "TIME_S_RES_REV" "100"
    SYSTEM_CONSTANT "TIME_S_TIACTRGN" "0.01"
    SYSTEM_CONSTANT "TIME_S_ZERO" "0"
    SYSTEM_CONSTANT "TIME_TICK" "10"
    SYSTEM_CONSTANT "TIME_TICK_S" "0.01"
    SYSTEM_CONSTANT "TIME_TICK_SEC_INV" "100"
    SYSTEM_CONSTANT "TIME_US_400NS_RES" "400"
    SYSTEM_CONSTANT "TIME_US_RES" "1"
    SYSTEM_CONSTANT "TIME_US_ZERO" "0"
    SYSTEM_CONSTANT "TIME_WLVLPWM_RES" "5e-005"
    SYSTEM_CONSTANT "TI_DIFF_HYD_MAX" "5000"
    SYSTEM_CONSTANT "TI_DIFF_HYD_MIN" "-5000"
    SYSTEM_CONSTANT "TI_PII_EARL_REL" "13000"
    SYSTEM_CONSTANT "TI_POI1_DIFF_MAX" "3000"
    SYSTEM_CONSTANT "TI_POI2_LATE_REL" "-13000"
    SYSTEM_CONSTANT "TI_RMPSLP_MAX" "40"
    SYSTEM_CONSTANT "TI_RMPSLP_MIN" "1"
    SYSTEM_CONSTANT "TOXICATUS_ATS_SY" "1"
    SYSTEM_CONSTANT "TOXICMOD_HEATFLOWHCCNV_RES" "10"
    SYSTEM_CONSTANT "TOXICMOD_HEATFLOW_RES" "36"
    SYSTEM_CONSTANT "TOXICMOD_INTER2_RES" "10"
    SYSTEM_CONSTANT "TOXICMOD_INTER3_RES" "36"
    SYSTEM_CONSTANT "TOXICMOD_REMOXY_RES" "335600"
    SYSTEM_CONSTANT "TOXICMOD_UNBRNFL_RES" "100"
    SYSTEM_CONSTANT "TPFLTUS_ATS_SY" "1"
    SYSTEM_CONSTANT "TRANS_R_MAX" "32767"
    SYSTEM_CONSTANT "TRANS_R_ONE" "1"
    SYSTEM_CONSTANT "TRANS_R_RES" "0.01"
    SYSTEM_CONSTANT "TRANS_R_RES_REV" "100"
    SYSTEM_CONSTANT "TRAPRT_OVRDS_DCS" "0"
    SYSTEM_CONSTANT "TRATYPE_MT_SY" "0"
    SYSTEM_CONSTANT "TRA_AST" "2"
    SYSTEM_CONSTANT "TRA_AT" "1"
    SYSTEM_CONSTANT "TRA_CVT" "3"
    SYSTEM_CONSTANT "TRA_DCT" "4"
    SYSTEM_CONSTANT "TRA_MT" "0"
    SYSTEM_CONSTANT "TRBCHCMPR_HP" "0"
    SYSTEM_CONSTANT "TRBCHCMPR_HPLP" "1"
    SYSTEM_CONSTANT "TRBCHCMPR_TYP_SY" "0"
    SYSTEM_CONSTANT "TRBCHPMP_FRQ_RES" "0.01"
    SYSTEM_CONSTANT "TRBCHPMP_FRQ_RES_REV" "100"
    SYSTEM_CONSTANT "TRBCHPMP_FRQ_RSA_RES" "0.01"
    SYSTEM_CONSTANT "TRBCHPMP_FRQ_RSA_RES_REV" "100"
    SYSTEM_CONSTANT "TRBCHPMP_PER_RES" "0.01"
    SYSTEM_CONSTANT "TRBCHPMP_TIMETOFRQ" "10000000"
    SYSTEM_CONSTANT "TRBCHPMP_USTOMS" "10"
    SYSTEM_CONSTANT "TRBCH_3_ACTR" "3"
    SYSTEM_CONSTANT "TRBCH_ATSINTVMOD_SY" "0"
    SYSTEM_CONSTANT "TRBCH_HP" "0"
    SYSTEM_CONSTANT "TRBCH_HPLP" "1"
    SYSTEM_CONSTANT "TRBCH_OFSLRNACTV_SY" "1"
    SYSTEM_CONSTANT "TRBCH_RLSMONACTV_SY" "1"
    SYSTEM_CONSTANT "TRBCH_RLSPOSGOVACTV_SY" "1"
    SYSTEM_CONSTANT "TRBCH_TYP_SY" "0"
    SYSTEM_CONSTANT "TRQ132_RSA_OFS" "400"
    SYSTEM_CONSTANT "TRQ132_RSA_OFS_CODE" "400"
    SYSTEM_CONSTANT "TRQ132_RSA_RES" "0.03125"
    SYSTEM_CONSTANT "TRQ132_RSA_RES_REV" "32"
    SYSTEM_CONSTANT "TRQINRCTL_FACKDNRM16" "16"
    SYSTEM_CONSTANT "TRQINRCTL_FACKINRM8" "8"
    SYSTEM_CONSTANT "TRQINRCTL_FACKPNRM128" "128"
    SYSTEM_CONSTANT "TRQINRFACT_EXP" "8"
    SYSTEM_CONSTANT "TRQINRFACT_RES" "256"
    SYSTEM_CONSTANT "TRQINRKD_RES" "1.52587890625e-006"
    SYSTEM_CONSTANT "TRQINRKD_RES_16" "2.44140625e-005"
    SYSTEM_CONSTANT "TRQINRKI_RES" "4.65661287307739e-005"
    SYSTEM_CONSTANT "TRQINRKI_RES_8" "0.000372529029846191"
    SYSTEM_CONSTANT "TRQINRKP_RES" "3.0517578125e-006"
    SYSTEM_CONSTANT "TRQINRKP_RES_128" "0.000390625"
    SYSTEM_CONSTANT "TRQPRPHIGH_MAX" "50000"
    SYSTEM_CONSTANT "TRQPRPHIGH_MIN" "-50000"
    SYSTEM_CONSTANT "TRQPRPHIGH_RES" "0.1"
    SYSTEM_CONSTANT "TRQPRPHIGH_ZERO" "0"
    SYSTEM_CONSTANT "TRQPRP_NRM" "4"
    SYSTEM_CONSTANT "TRQPRP_RES" "1.6"
    SYSTEM_CONSTANT "TRQPRP_ZERO" "0"
    SYSTEM_CONSTANT "TRQSEL_SY" "1"
    SYSTEM_CONSTANT "TRQTONSQR_RES" "1e-007"
    SYSTEM_CONSTANT "TRQWHL_ZERO" "0"
    SYSTEM_CONSTANT "TRQ_FRC_INI" "-50"
    SYSTEM_CONSTANT "TRQ_MAX" "1000"
    SYSTEM_CONSTANT "TRQ_MIN" "-500"
    SYSTEM_CONSTANT "TRQ_RES" "0.1"
    SYSTEM_CONSTANT "TRQ_RES_REV" "10"
    SYSTEM_CONSTANT "TRQ_WOTRAINTV_SY" "1"
    SYSTEM_CONSTANT "TRQ_ZERO" "0"
    SYSTEM_CONSTANT "TSCDEC_OVRDS_DCS" "0"
    SYSTEM_CONSTANT "TSCINC_OVRDS_DFFTLPRT" "0"
    SYSTEM_CONSTANT "TSCINC_OVRDS_TCS" "0"
    SYSTEM_CONSTANT "TS_RES_REV" "1"
    SYSTEM_CONSTANT "TURBODN_RES" "500"
    SYSTEM_CONSTANT "TURBON_RES" "10"
    SYSTEM_CONSTANT "TVACD_DCYCCONV_CUR_X" "25"
    SYSTEM_CONSTANT "TVAVSADIA_FRQ_RES" "0.1"
    SYSTEM_CONSTANT "TVAVSADIA_FRQ_RES_REV" "10"
    SYSTEM_CONSTANT "TWO_EXP_16" "65536"
    SYSTEM_CONSTANT "TWO_POW_NRM_EXP_RES_TRIGO_FUNC" "4096"
    SYSTEM_CONSTANT "TX_ECM_CANHS_RNR_01_FRM_SIZE" "7"
    SYSTEM_CONSTANT "TX_ECM_CANHS_RNR_02_FRM_SIZE" "7"
    SYSTEM_CONSTANT "TX_ECM_VERLOG_FRM_SIZE" "7"
    SYSTEM_CONSTANT "TX_FORCE_ECM_CANHS_R_01_FRM_SIZE" "8"
    SYSTEM_CONSTANT "TX_MMI_ECM_CANHS_RNR_01_FRM_SIZE" "6"
    SYSTEM_CONSTANT "TX_TORQUE_ECM_CANHS_RNR_01_FRM_SIZE" "7"
    SYSTEM_CONSTANT "TX_TORQUE_ECM_CANHS_RNR_02_FRM_SIZE" "6"
    SYSTEM_CONSTANT "TX_TORQUE_ECM_CANHS_R_01_FRM_SIZE" "5"
    SYSTEM_CONSTANT "T_1SEC_RESO_SY" "1000000"
    SYSTEM_CONSTANT "T_AIR_MAX" "199.86"
    SYSTEM_CONSTANT "T_AIR_MIN" "-50.14"
    SYSTEM_CONSTANT "T_CLNT_MAX" "149.86"
    SYSTEM_CONSTANT "T_CLNT_MIN" "-50.14"
    SYSTEM_CONSTANT "T_CLNT_MIN1" "-50.14"
    SYSTEM_CONSTANT "T_EGAS_MAX" "1273"
    SYSTEM_CONSTANT "T_EGAS_MIN" "223"
    SYSTEM_CONSTANT "T_EGR_MIN" "-50"
    SYSTEM_CONSTANT "T_EGTGOV" "25"
    SYSTEM_CONSTANT "T_EGT_CORMAX_C" "0.5"
    SYSTEM_CONSTANT "T_EGT_CORMIN_C" "0"
    SYSTEM_CONSTANT "T_EGT_WINNEG" "-1000"
    SYSTEM_CONSTANT "T_EGT_WINPOS" "1000"
    SYSTEM_CONSTANT "T_ENG_MAX" "199.86"
    SYSTEM_CONSTANT "T_ENG_MIN" "-50.14"
    SYSTEM_CONSTANT "T_ETCTL_WINNEG_MAX" "100"
    SYSTEM_CONSTANT "T_ETCTL_WINNEG_MIN" "-1000"
    SYSTEM_CONSTANT "T_ETCTL_WINPOS_MAX" "1000"
    SYSTEM_CONSTANT "T_ETCTL_WINPOS_MIN" "-100"
    SYSTEM_CONSTANT "T_EXHGS_MAX" "1050"
    SYSTEM_CONSTANT "T_EXHGS_MIN" "-45"
    SYSTEM_CONSTANT "T_FUEL_MAX" "149.86"
    SYSTEM_CONSTANT "T_FUEL_MIN" "-50.14"
    SYSTEM_CONSTANT "T_GOVIO_MAX" "1500"
    SYSTEM_CONSTANT "T_GOVIO_MIN" "-100"
    SYSTEM_CONSTANT "T_GOV_MAX" "1500"
    SYSTEM_CONSTANT "T_GOV_MIN" "-100"
    SYSTEM_CONSTANT "T_INRCORMAX_MAX" "1500"
    SYSTEM_CONSTANT "T_INRCORMAX_MIN" "-100"
    SYSTEM_CONSTANT "T_INRCORMIN_MAX" "0"
    SYSTEM_CONSTANT "T_INRCORMIN_MIN" "-1500"
    SYSTEM_CONSTANT "T_LAMBDA_MAX" "1300"
    SYSTEM_CONSTANT "T_LAMBDA_MIN" "100"
    SYSTEM_CONSTANT "T_SURF_MAX" "800"
    SYSTEM_CONSTANT "T_SURF_MIN" "100"
    SYSTEM_CONSTANT "T_TEMPDIFF_NULL" "0"
    SYSTEM_CONSTANT "T_TEMP_NORM" "298"
    SYSTEM_CONSTANT "UBATT_ADC_REF" "20000"
    SYSTEM_CONSTANT "UBATT_MAX" "20782"
    SYSTEM_CONSTANT "UDOSVLV_ATSINTVMOD_SY" "1"
    SYSTEM_CONSTANT "UINT2CHG_PA_FAC" "80"
    SYSTEM_CONSTANT "UI_CURR_ADCMAX" "30000"
    SYSTEM_CONSTANT "UI_CURR_HWOFF" "34000"
    SYSTEM_CONSTANT "UPMPMOT_ATSINTVMOD_SY" "1"
    SYSTEM_CONSTANT "USEC2MSEC" "1000"
    SYSTEM_CONSTANT "U_ADC_MAX" "5200"
    SYSTEM_CONSTANT "U_ADC_MIN" "0"
    SYSTEM_CONSTANT "U_ADC_REF" "5000"
    SYSTEM_CONSTANT "U_GCVOLT_REF" "5000"
    SYSTEM_CONSTANT "U_INTEGADJ_FAC" "5"
    SYSTEM_CONSTANT "U_MAX" "5200"
    SYSTEM_CONSTANT "U_MIN" "0"
    SYSTEM_CONSTANT "U_RATED" "14000"
    SYSTEM_CONSTANT "U_RATED_PASS" "14000"
    SYSTEM_CONSTANT "U_RATED_TRUCK" "28000"
    SYSTEM_CONSTANT "U_TO_RESIST_RES" "0.001"
    SYSTEM_CONSTANT "U_TO_RESIST_REV_RES" "1000"
    SYSTEM_CONSTANT "V2N_NORM" "2000"
    SYSTEM_CONSTANT "V2N_RES" "1e-005"
    SYSTEM_CONSTANT "V2N_ZERO" "0"
    SYSTEM_CONSTANT "VEHMOT_PI" "3.14159562"
    SYSTEM_CONSTANT "VELOCITY_RES" "0.0056"
    SYSTEM_CONSTANT "VELOCITY_RES_FL" "0.0056"
    SYSTEM_CONSTANT "VEL_KMH_0" "0"
    SYSTEM_CONSTANT "VEL_KMH_300" "300"
    SYSTEM_CONSTANT "VEL_KMH_M_300" "-300"
    SYSTEM_CONSTANT "VEL_MAX" "300"
    SYSTEM_CONSTANT "VEL_MIN" "0"
    SYSTEM_CONSTANT "VEL_RES" "0.01"
    SYSTEM_CONSTANT "VEL_RES_REV" "100"
    SYSTEM_CONSTANT "VEL_RES_SI" "0.00277777777777778"
    SYSTEM_CONSTANT "VEL_ZERO" "0"
    SYSTEM_CONSTANT "VLTG_PA_MAX" "250"
    SYSTEM_CONSTANT "VLTG_PA_MIN" "-250"
    SYSTEM_CONSTANT "VLTG_PA_RES" "0.01"
    SYSTEM_CONSTANT "VLTG_PA_ZERO" "0"
    SYSTEM_CONSTANT "VLV_VEL_RES" "0.1"
    SYSTEM_CONSTANT "VMSLMTSWT_ATS_SY" "1"
    SYSTEM_CONSTANT "VN_K_RES_RSA" "100"
    SYSTEM_CONSTANT "VOLADD_ML_FINE_RES" "0.001"
    SYSTEM_CONSTANT "VOLADD_ML_FINE_RES_REV" "1000"
    SYSTEM_CONSTANT "VOLENGCAP_RES" "1e-006"
    SYSTEM_CONSTANT "VOLFINE_RES" "0.0001"
    SYSTEM_CONSTANT "VOLFINE_RES_FL" "0.0001"
    SYSTEM_CONSTANT "VOLTPRES_HIRES" "0.01"
    SYSTEM_CONSTANT "VOLTPRES_RES" "0.1"
    SYSTEM_CONSTANT "VOLTPRES_RES_REV" "10"
    SYSTEM_CONSTANT "VOLTSQ_HIRES" "0.1"
    SYSTEM_CONSTANT "VOLT_ADC_RES" "0.2"
    SYSTEM_CONSTANT "VOLT_ADC_RES_REV" "5"
    SYSTEM_CONSTANT "VOLT_ADC_RES_RSA" "0.2"
    SYSTEM_CONSTANT "VOLT_BATT_RES" "20"
    SYSTEM_CONSTANT "VOLT_BATT_RES_REV" "0.05"
    SYSTEM_CONSTANT "VOLT_BATT_RES_RSA" "1"
    SYSTEM_CONSTANT "VOLT_FNRESO1" "0.1"
    SYSTEM_CONSTANT "VOLT_FNRESO1_REV" "10"
    SYSTEM_CONSTANT "VOLT_FNRESO2" "0.001"
    SYSTEM_CONSTANT "VOLT_PER_PRES" "0.001"
    SYSTEM_CONSTANT "VOLT_Q0P002_RES" "0.002"
    SYSTEM_CONSTANT "VOLT_ZERO" "0"
    SYSTEM_CONSTANT "VOL_ADD_RES" "0.1"
    SYSTEM_CONSTANT "VOL_FILGLVL_RES" "1"
    SYSTEM_CONSTANT "VOL_FILGLVL_RES_REV" "1"
    SYSTEM_CONSTANT "VOL_FL_L_TO_FL_2" "1000"
    SYSTEM_CONSTANT "VOL_MAX" "100"
    SYSTEM_CONSTANT "VOL_MIN" "0"
    SYSTEM_CONSTANT "VOL_NSC_RES" "0.0001"
    SYSTEM_CONSTANT "VOL_NSC_RES_FL" "0.0001"
    SYSTEM_CONSTANT "VOL_NSC_RES_REV" "10000"
    SYSTEM_CONSTANT "VOL_PFLT_MAX" "100"
    SYSTEM_CONSTANT "VOL_PFLT_MIN" "0.01"
    SYSTEM_CONSTANT "VOL_RES" "0.01"
    SYSTEM_CONSTANT "VOL_ZERO" "0"
    SYSTEM_CONSTANT "VSACD_DCYCCONV_CUR_X" "25"
    SYSTEM_CONSTANT "VSLIMLMP_ATSINTVMOD_SY" "1"
    SYSTEM_CONSTANT "VSWCTL_FACENGTEMPCTLCOR_CUR_X" "12"
    SYSTEM_CONSTANT "VSWCTL_FACENVPRESCTLCOREOM_CUR_X" "25"
    SYSTEM_CONSTANT "VSWCTL_FACENVPRESCTLCOR_CUR_X" "25"
    SYSTEM_CONSTANT "VSWCTL_FACRMPVALCTLCOR_CUR_X" "13"
    SYSTEM_CONSTANT "VSWCTL_RCTLBASEOM_MAP_X" "16"
    SYSTEM_CONSTANT "VSWCTL_RCTLBASEOM_MAP_Y" "16"
    SYSTEM_CONSTANT "VSWCTL_RCTLBASHIALTDEOM_MAP_X" "16"
    SYSTEM_CONSTANT "VSWCTL_RCTLBASHIALTDEOM_MAP_Y" "16"
    SYSTEM_CONSTANT "VSWCTL_RCTLBASHIALTD_MAP_X" "16"
    SYSTEM_CONSTANT "VSWCTL_RCTLBASHIALTD_MAP_Y" "16"
    SYSTEM_CONSTANT "VSWCTL_RCTLBAS_MAP_X" "16"
    SYSTEM_CONSTANT "VSWCTL_RCTLBAS_MAP_Y" "16"
    SYSTEM_CONSTANT "VSWCTL_RENGTEMPCORBAS_MAP_X" "8"
    SYSTEM_CONSTANT "VSWCTL_RENGTEMPCORBAS_MAP_Y" "8"
    SYSTEM_CONSTANT "VSWVLV_TYPAVL_SY" "0"
    SYSTEM_CONSTANT "VSWVLV_TYPTWINFLW_SY" "0"
    SYSTEM_CONSTANT "V_025_RSA_RES" "0.25"
    SYSTEM_CONSTANT "V_CAM_RES_REV" "256"
    SYSTEM_CONSTANT "WAHT_NUM_HTRS" "3"
    SYSTEM_CONSTANT "WAHT_NUM_PS" "3"
    SYSTEM_CONSTANT "WNTR_SY" "0"
    SYSTEM_CONSTANT "W_PA_MAX" "100"
    SYSTEM_CONSTANT "W_PA_RES" "0.01"
    SYSTEM_CONSTANT "W_PA_ZERO" "0"
    SYSTEM_CONSTANT "W_PER_S_40_RSA" "40"
    SYSTEM_CONSTANT "W_RES_RSA" "10"
    SYSTEM_CONSTANT "ZERO" "0"
    SYSTEM_CONSTANT "ZERO_FL" "0"
    SYSTEM_CONSTANT "ZFC_ACTV" "1"
    SYSTEM_CONSTANT "ZFC_BPFACINV_RES" "546.116666666667"
    SYSTEM_CONSTANT "ZFC_BPFAC_MAX" "30"
    SYSTEM_CONSTANT "ZFC_BPFAC_MIN" "-30"
    SYSTEM_CONSTANT "ZFC_BPFAC_RES" "0.00183111056855983"
    SYSTEM_CONSTANT "ZFC_BPFAC_RES_FL" "0.00183111056855983"
    SYSTEM_CONSTANT "ZFC_INACTV" "0"
    SYSTEM_CONSTANT "ZFC_NFBCVAL_AXISX" "7"
    SYSTEM_CONSTANT "ZFC_PHISET_CURX" "16"
    SYSTEM_CONSTANT "ZFC_SWTCLBACTV_TYPE" "2"
    SYSTEM_CONSTANT "ZFC_SWTCLBACTV_VAL" "1"
    SYSTEM_CONSTANT "ZFC_TICLDCHAM_CURX" "12"
    
  /end MOD_PAR

  /begin MOD_COMMON ""
    BYTE_ORDER MSB_LAST
    ALIGNMENT_BYTE 1
    ALIGNMENT_WORD 2
    ALIGNMENT_LONG 4
    ALIGNMENT_FLOAT32_IEEE 4
  /end MOD_COMMON

    /begin IF_DATA ASAP1B_Bypass 
		/begin TP_BLOB 
		  0x100		/* Bypass version */ 
		  0x100		/* Blob version */ 
		/end TP_BLOB 
    /end IF_DATA 
	
  /begin IF_DATA ASAP1B_CCP
    /begin SOURCE
      /* daq name        */ "segment synchronous"
      /* period unit CSE */ 103
      /* repetition rate */ 1
      /begin QP_BLOB
        /* daq number    */ 0
        LENGTH              10
        CAN_ID_FIXED        0x330
        FIRST_PID           0
        RASTER              0
      /end QP_BLOB
    /end SOURCE
    
    /begin SOURCE
      /* daq name        */ "10ms time synchronous"
      /* period unit CSE */ 4
      /* repetition rate */ 1
      /begin QP_BLOB
        /* daq number    */ 1
        LENGTH              60
        CAN_ID_FIXED        0x340
        FIRST_PID           10
        RASTER              1
      /end QP_BLOB
    /end SOURCE
    
    /begin SOURCE
      /* daq name        */ "100ms time synchronous"
      /* period unit CSE */ 4
      /* repetition rate */ 10
      /begin QP_BLOB
        /* daq number    */ 2
        LENGTH              20
        CAN_ID_FIXED        0x350
        FIRST_PID           25
        RASTER              2
      /end QP_BLOB
    /end SOURCE
    
    /begin RASTER
      /* event name       */ "segment synchronous"
      /* event short name */ "seg_sync"
      /* event number     */ 0
      /* scaling unit CSE */ 103
      /* sample rate      */ 1
    /end RASTER
    
    /begin RASTER
      /* event name       */ "10ms time synchronous"
      /* event short name */ "10_ms"
      /* event number     */ 1
      /* scaling unit CSE */ 4
      /* sample rate      */ 1
    /end RASTER
    
    /begin RASTER
      /* event name       */ "100ms time synchronous"
      /* event short name */ "100_ms"
      /* event number     */ 2
      /* scaling unit CSE */ 4
      /* sample rate      */ 10
    /end RASTER
    
    /begin SEED_KEY
      /* seed&key dll for CAL */ ""
      /* seed&key dll for DAQ */ ""
      /* seed&key dll for PGM */ ""
    /end SEED_KEY
    
    /begin TP_BLOB
      /* CCP version     */ 0x201
      /* Blob version    */ 0x204
      /* CAN msg ID-send */ 0x310
      /* CAN msg ID-recv */ 0x320
      /* station address */ 0xAD01
      /* byte order      */ 2
      
      BAUDRATE           1000000 /* in Hz */
      SAMPLE_POINT       60 /* in % */
      SAMPLE_RATE        1 /* 1 or 3 */
      BTL_CYCLES         19
      SJW                3
      SYNC_EDGE          SINGLE /* SINGLE or DUAL */
      
      DAQ_MODE           BURST
      CONSISTENCY        DAQ
      
      /begin CHECKSUM_PARAM 
        /* algorithm */      0xC001
        /* limit     */      0xFFFFFFFF
        CHECKSUM_CALCULATION ACTIVE_PAGE
      /end CHECKSUM_PARAM 
      
      /begin DEFINED_PAGES
        /* page number    */ 1
        /* page name      */ "reference page"
        /* address ext.   */ 0x0
        /* base address   */ 0x80040000
        /* page length    */ 0x3FC00
        ROM
        
        
        
      /end DEFINED_PAGES
      
      /begin DEFINED_PAGES
        /* page number    */ 2
        /* page name      */ "working page"
        /* address ext.   */ 0x0
        /* base address   */ 0x40000
        /* page length    */ 0x3FC00
        RAM
        RAM_INIT_BY_ECU
        
        
      /end DEFINED_PAGES
      
      OPTIONAL_CMD 0x11  /* SELECT_CAL_PAGE */
      OPTIONAL_CMD 0xE  /* BUILD_CHKSUM */
      OPTIONAL_CMD 0x19  /* MOVE */
      OPTIONAL_CMD 0x9  /* GET_ACTIVE_CAL_PAGE */
      OPTIONAL_CMD 0xC  /* SET_S_STATUS */
      OPTIONAL_CMD 0xD  /* GET_S_STATUS */
      OPTIONAL_CMD 0x12  /* GET_SEED */
      OPTIONAL_CMD 0x13  /* UNLOCK */
      OPTIONAL_CMD 0x23  /* DNLOAD_6 */
      OPTIONAL_CMD 0x8  /* START_STOP_ALL */
      OPTIONAL_CMD 0x20  /* DIAG_SERVICE */
    /end TP_BLOB
  /end IF_DATA
  
/begin IF_DATA ETK
    
    /begin SOURCE
      /* daq name        */ "bypass segment synchronous"
      /* period unit CSE */ 103
      /* repetition rate */ 1
      QP_BLOB
     /* QP BLOB version                       */ 0x101
     /* hardware trigger                      */ 15
     /* trigger type                          */ INDIRECT
     /* raster priority [1..32]               */ 32
     /* assignment measurement/bypass         */ BYPASS
     /* trigger flag only indirect triggering */ 0x8FF20F04
     /* display table max bytes               */ 200
     /* address of display table              */ 0x8FF20184
     /* address of display table values       */ 0x8FF20B1C
     /* max. size of bypass receive table     */ 100
     /* address of bypass table               */ 0x0
     /* address of bypass table values        */ 0x8FF2031C
     /* worst case raster time [us]           */ 1500
     /* maximum read variables                */ 100
     /* maximum write variables               */ 100
    /end SOURCE

    
    /begin SOURCE
      /* daq name        */ "segment synchronous"
      /* period unit CSE */ 103
      /* repetition rate */ 1
      QP_BLOB
     /* QP BLOB version                       */ 0x101
     /* hardware trigger                      */ 15
     /* trigger type                          */ INDIRECT
     /* raster priority [1..32]               */ 31
     /* assignment measurement/bypass         */ MEASUREMENT
     /* trigger flag only indirect triggering */ 0x8FF20F08
     /* display table max bytes               */ 200
     /* address of display table              */ 0x8FF203EC
     /* address of display table values       */ 0x8FF20BE4
     /* max. size of bypass receive table     */ 0
     /* address of bypass table               */ 0x0
     /* address of bypass table values        */ 0x0
     /* worst case raster time [us]           */ 1500
     /* maximum read variables                */ 100
     /* maximum write variables               */ 0
    /end SOURCE

    
    /begin SOURCE
      /* daq name        */ "bypass 10ms time synchronous"
      /* period unit CSE */ 4
      /* repetition rate */ 1
      QP_BLOB
     /* QP BLOB version                       */ 0x101
     /* hardware trigger                      */ 16
     /* trigger type                          */ INDIRECT
     /* raster priority [1..32]               */ 30
     /* assignment measurement/bypass         */ BYPASS
     /* trigger flag only indirect triggering */ 0x8FF20F0C
     /* display table max bytes               */ 200
     /* address of display table              */ 0x8FF20584
     /* address of display table values       */ 0x8FF20CAC
     /* max. size of bypass receive table     */ 100
     /* address of bypass table               */ 0x0
     /* address of bypass table values        */ 0x8FF2071C
     /* worst case raster time [us]           */ 9000
     /* maximum read variables                */ 100
     /* maximum write variables               */ 100
    /end SOURCE

    
    /begin SOURCE
      /* daq name        */ "10ms time synchronous"
      /* period unit CSE */ 4
      /* repetition rate */ 1
      QP_BLOB
     /* QP BLOB version                       */ 0x101
     /* hardware trigger                      */ 16
     /* trigger type                          */ INDIRECT
     /* raster priority [1..32]               */ 29
     /* assignment measurement/bypass         */ MEASUREMENT
     /* trigger flag only indirect triggering */ 0x8FF20F10
     /* display table max bytes               */ 200
     /* address of display table              */ 0x8FF207EC
     /* address of display table values       */ 0x8FF20D74
     /* max. size of bypass receive table     */ 0
     /* address of bypass table               */ 0x0
     /* address of bypass table values        */ 0x0
     /* worst case raster time [us]           */ 9000
     /* maximum read variables                */ 100
     /* maximum write variables               */ 0
    /end SOURCE

    
    /begin SOURCE
      /* daq name        */ "100ms time synchronous"
      /* period unit CSE */ 5
      /* repetition rate */ 1
      QP_BLOB
     /* QP BLOB version                       */ 0x101
     /* hardware trigger                      */ 16
     /* trigger type                          */ INDIRECT
     /* raster priority [1..32]               */ 28
     /* assignment measurement/bypass         */ MEASUREMENT
     /* trigger flag only indirect triggering */ 0x8FF20F14
     /* display table max bytes               */ 200
     /* address of display table              */ 0x8FF20984
     /* address of display table values       */ 0x8FF20E3C
     /* max. size of bypass receive table     */ 0
     /* address of bypass table               */ 0x0
     /* address of bypass table values        */ 0x0
     /* worst case raster time [us]           */ 90000
     /* maximum read variables                */ 100
     /* maximum write variables               */ 0
    /end SOURCE


    /begin TP_BLOB
       /* version                */ 0x1000103
       /* interface speed        */ INTERFACE_SPEED_100MBIT
       /* reset_cfg - only MPC   */ 0x7FFFFF07 /* not used for TriCore */

       DISTAB_CFG
         /* Distab Type          */ 13
         /* Distab Data type     */ 0x122
         /* ByteOrder 1=LSB last */ 0x2

         /* Trigger Segment Adr  */ 0x0
         /* Trigger Configuration*/ 0x01010100
                  TRG_MOD /*Id:*/ 0x0   /*trg_mod:*/0xFF 0x0 0x0 0x0


         ETK_CFG  0x10 0x13 0x61 0x01 0x00 0xFF 0xFF 0x63 0x88 0x64 0x0B 0x65 0x8C 0x66 0xA0 0x67 0x91 0x68 0x9E

         RESERVED_DISTAB_MEMORY
           /* start_addr  */ 0x80040078
           /* length      */ 0x0
           /* location    */ EXTERN
           /* application */ MEASUREMENT
           /* usage       */ CHECKSUM_EXCLUDE_ONLY
           /* mirrors     */ 0xFFFFFFFF 0xFFFFFFFF 0xFFFFFFFF 0xFFFFFFFF 0xFFFFFFFF

    /begin COLDSTART_HANDSHAKE
      /* Address of ETKS coldstart pattern */    0x8FF20098

      WAIT
        /* Dyn. length for wait pattern    */    0xE5 0xAD 0xEC 0x4D

      READY
        /* Dyn. length for ready pattern    */   0xDE 0xC0 0xED 0xFE

    /end COLDSTART_HANDSHAKE

      CAL_WAKEUP
        /* 1 = wake up enabled, 0=disabled */ CAL_WAKEUP_PIN 1
        CAL_TOOL_PRESENT
          /* address for the pattern       */ 0x8FF2008C
          /* CAL_TOOL_PRESENT_PATTERN      */ 0x12345678
          /* ECU timeout for shutdown in s */ 2

        PAGE_SWITCH_METHOD
        1                      /* version                              */
        MAILBOX
            1           /* MBX_Version                                 */
                        /* Version of mailbox                          */
            200          /* MBX_PageSetupTime                           */
                        /* max time the ECU needs to set up page in ms */
            0x8FF200A0  /* MBX_StartAddress                            */
                        /* Start address of table                      */

        AUTOSTART_BEHAVIOR    LAST_ACTIVE_PAGE  /* Table to be filled by INCA with info */
                                                /* for the current active page          */

        OCT_WORKINGPAGE
            0x400     /* OCT_Type         Type of table                  */
            0x8FF200A8  /* OCT_StartAddress Start address of table         */
            0xDC   /* OCT_Length       max Length of table in byte    */

    /end TP_BLOB
  /end IF_DATA

   /begin IF_DATA ASAP1B_KWP2000
      /begin SOURCE
         /* Name        */ "10ms time synchronous"
         /* CSE-units   */ 4
         /* min periode */ 1
         QP_BLOB
            /* Physical layer          */ KLINE_AND_CAN
            /* Measurement mode        */ BLOCKMODE
            /* Block mode local ID     */ 0xF0
            /* max. no of signals      */ 20
            /* max. no of bytes        */ 40
            /* CAN-ID for EUDTP        */ 0x0 /* don't care if not CAN */
            /* Raster ID for EUDTP     */ 0          /* and FREERUNNINGMODE   */
      /end SOURCE

      /begin TP_BLOB
         /* Blob version               */ 0x200
         /* KWP Version                */ VDA_1996
         /* byte order                 */ MSB_LAST
         K_LINE
            /* ECU stimulation mode    */ WuP
            /* ECU address on k line   */ 0x11
            /* requ. tester address    */ 0xF1
         /begin CAN
            /* Baudrate [Hz]           */ 1000000
            /* Sample point            */ 60
            /* samples per bit         */ 1
            /* BTL_CYCLES              */ 19
            /* SJW                     */ 3
            /* SYNC_EDGEGE             */ 0
            /begin ADDRESS
               /* CAN_ID ECU           */ 0x611
               /* CAN_ID INCA          */ 0x6F0
               /* Extended address ECU */ /* TGT_ECU  0x10 not used with normal addressing */
               /* Extended address INCA*/ /* TGT_INCA 0xF1 not used with normal addressing */
            /end ADDRESS
            NETWORK_LIMITS
               /* WFT_MAX              */ 10
               /* XDL_MAX              */ 0xFFF
         /end CAN

         DATA_ACCESS
            /* Flash address */ 0x0
            /* RAM address   */ 0x0
            /* Data Read     */ 1
            /* Code Verify   */ 0
            /* Code Read     */ 0
            /* Load mode     */ 1

         /begin CHECKSUM
            /* Checksum Type           */ 0x10201
            /* only at active Page     */ 1
            /* loc Routine Id Checksum */ 1
            /* result delivered by     */ RequestRoutineResults
            RNC_RESULT 0x23
         /end CHECKSUM

         /begin COPY
            /* mode copy Flash to RAM  */ RAM_InitByECU
            /* DiagModeCopyFlashToRam  */ 0xFA
         /end COPY

         /begin FLASH
            /* mode copy RAM to Flash  */ NOFLASHBACK
            /* loc Routine Id flashing */ 3
            /* result delivered by     */ RequestRoutineResults
            COPY_FRAME 1
            RNC_RESULT 0x23 0xFB 0xFC
         /end FLASH

         /begin DIAG_BAUD
            /* BaudRate */ 10400
            /* DiagMode */ 0xFA
            BD_PARA 0x14
         /end DIAG_BAUD

         /begin DIAG_BAUD
            /* BaudRate */ 41600
            /* DiagMode */ 0xFA
            BD_PARA 0x54
         /end DIAG_BAUD

         /begin DIAG_BAUD
            /* BaudRate */ 62400
            /* DiagMode */ 0xFA
            BD_PARA 0x67
         /end DIAG_BAUD

         /begin DIAG_BAUD
            /* BaudRate */ 83200
            /* DiagMode */ 0xFA
            BD_PARA 0x74
         /end DIAG_BAUD

         /begin DIAG_BAUD
            /* BaudRate */ 125000
            /* DiagMode */ 0xFA
            BD_PARA 0x87
         /end DIAG_BAUD

         /begin TIME_DEF
            /* Timing Parameter: p1Max  p2Min  p2Max  p3Min  p3Max  p4Min  in ms */
            KWP_TIMING 20  0  50  3  512  0
            KWP_TIMING 20  25  50  55  5000  5
            KWP_TIMING 20  0  2000  0  5000  65440

            /* Timing Parameter: As     Bs     Cr  in ms                         */
        USDTP_TIMING 8192  256  256
        USDTP_TIMING 4096  256  256
         /end TIME_DEF

         /* Seed&Key Parameter: AccMode  CalcMethod  Delay */
         /* SECURITY_ACCESS        9          1        0   */

         /begin PAGE_SWITCH
            /* mode for page switch */ ESCAPE_CODE
            ESCAPE_CODE_PARA_SET 0x90
            ESCAPE_CODE_PARA_GET 0x91
            PAGE_CODE 0x0 0x1
         /end PAGE_SWITCH

      /end TP_BLOB
   /end IF_DATA

/begin CHARACTERISTIC

    ACC_CANHS_R_01_CA
    "ACC_CANHS_R_01_Msg data calibration"
    VAL_BLK
    0x8006CE58
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AC_trqMaxAC_C
    ""
    VALUE
    0x80072EE2
    Val_Ws16
    6553.500
    Trq
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxAirCClntIA_C
    "Signal source index for ADC software signal Adc_idxAirCClntIA_C"
    VALUE
    0x8006BE48
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxCEngDsTIA_C
    "Signal source index for ADC software signal Adc_idxCEngDsTIA_C"
    VALUE
    0x8006BE4A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxCrCPanIA_C
    ""
    VALUE
    0x8006BE4C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxdummyIABPS_C
    ""
    VALUE
    0x8006BE4E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxdummyIAEGRCWTS_C
    ""
    VALUE
    0x8006BE50
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxdummyIAFLPS_C
    ""
    VALUE
    0x8006BE52
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxdummyTCACDsIA_C
    ""
    VALUE
    0x8006BE54
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxdummy_C
    "Signal source index for ADC software signal Adc_idxdummy_C"
    VALUE
    0x8006BE56
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxEGRVlvIA_C
    "Automatically generated calibration parameter for routing the EGRVlv_I_A Adc signal from HWE port"
    VALUE
    0x8006BE58
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxFuelTIA_C
    "Signal source index for ADC software signal Adc_idxFuelTIA_C"
    VALUE
    0x8006BE5A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxOilTIA_C
    "Signal source index for ADC software signal Adc_idxOilTIA_C"
    VALUE
    0x8006BE5C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxPCACDsIA_C
    "Signal source index for ADC software signal Adc_idxPCACDsIA_C"
    VALUE
    0x8006BE5E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxPPFltUsIA_C
    "Signal source index for ADC software signal Adc_idxPPFltUsIA_C"
    VALUE
    0x8006BE60
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxPTrbnUsIA_C
    "Signal source index for ADC software signal Adc_idxPTrbnUsIA_C"
    VALUE
    0x8006BE62
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTAFSIA_C
    "Signal source index for ADC software signal Adc_idxTAFSIA_C"
    VALUE
    0x8006BE64
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTEGRClrDsIA_C
    "Signal source index for ADC software signal Adc_idxTEGRClrDsIA_C"
    VALUE
    0x8006BE66
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxThrVlvIA_C
    "Signal source index for ADC software signal Adc_idxThrVlvIA_C"
    VALUE
    0x8006BE68
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTOxiCatDsIA_C
    "Signal source index for ADC software signal Adc_idxTOxiCatDsIA_C"
    VALUE
    0x8006BE6A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTOxiCatUsIA_C
    "Signal source index for ADC software signal Adc_idxTOxiCatUsIA_C"
    VALUE
    0x8006BE6C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTPFltDsIA_C
    "Signal source index for ADC software signal Adc_idxTPFltDsIA_C"
    VALUE
    0x8006BE6E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTPFltUsIA_C
    "Signal source index for ADC software signal Adc_idxTPFltUsIA_C"
    VALUE
    0x8006BE70
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTrbChIA_C
    "Signal source index for ADC software signal Adc_idxTrbChIA_C"
    VALUE
    0x8006BE72
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxTTrbnUsIA_C
    "Signal source index for ADC software signal Adc_idxTTrbnUsIA_C"
    VALUE
    0x8006BE74
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Adc_idxVDD5A_C
    "Signal source index for ADC software signal Adc_idxVDD5A_C"
    VALUE
    0x8006BE76
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_dmTransf_CUR
    "Transformation curve to convert the electrical AFS signal to physical air flow signal"
    CURVE
    0x8006B55C
    Cur_Xs16Ws16
    2000.000
    AirMassPerTime
    -1000.000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        AFS_tiTransfCrvIn_mp
        Time_PwmHigh
        57
        -1638.40000000
        1638.35000000

        FORMAT "%13.8"
        EXTENDED_LIMITS -1638.40000000 1638.35000000
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_facPerCor_C
    "Air-mass signal correction factor in case of HFM-temperature sensor error"
    VALUE
    0x8006B642
    Val_Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_nAvrgThrHiSRCLoB2_C
    "Upper engine speed threshold to release SRC low for AFS on Bank2"
    VALUE
    0x8006B644
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_nAvrgThrHiSRCLo_C
    "Upper engine speed threshold to release SRC low"
    VALUE
    0x8006B646
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_nAvrgThrLoSRCLo_C
    "Lower engine speed threshold to release SRC low"
    VALUE
    0x8006B648
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_qAirmThrSRCHiActv_CUR
    "Curve to calculate the quanity threshold for SRC high release"
    CURVE
    0x8006B64A
    Cur_Xs16Ws16
    100.0000
    InjMass
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        25
        0.00
        6000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_swtOffTstSel_C
    "Switch to decide whether the offset drift test is done in START or in the AFTERRUN state of the engine"
    VALUE
    0x8006B6B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_swtOscSel_C
    "Swicth to indicate Oscillator HFM"
    VALUE
    0x8006B6B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiCorSRCHi_C
    "Upper threshold for the corrected air mass period in HFM6"
    VALUE
    0x8006B6B4
    Val_Ws32
    214748364.750
    Time_PwmHigh
    -107374182.400
    107374182.350

    FORMAT "%13.3"
    EXTENDED_LIMITS -107374182.400 107374182.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiCorSRCLo_C
    "Lower threshold for the corrected air mass period in HFM6"
    VALUE
    0x8006B6B8
    Val_Ws32
    214748364.750
    Time_PwmHigh
    -107374182.400
    107374182.350

    FORMAT "%13.3"
    EXTENDED_LIMITS -107374182.400 107374182.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiDlyActvSRCHiAirm_C
    "Time delay for the quantity threshold release condition for SRC high"
    VALUE
    0x8006B6BC
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiLPFiltPT1_C
    "Time constant to filter the air flow signal"
    VALUE
    0x8006B6C0
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiOffsDrftTstDly_C
    "Time delay before the start of offset drift test"
    VALUE
    0x8006B6C4
    Val_Ws16
    15000.00
    Time_ms
    0.00
    15000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiOffsDrftTstLim_C
    "Maximum time for offset drift test"
    VALUE
    0x8006B6C6
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiPerHFM6_C
    "Reference period of air temperature for HFM6 sensor"
    VALUE
    0x8006B6C8
    Val_Ws32
    214748.364750
    Time_Period_HFM6
    -107374.182400
    107374.182350

    FORMAT "%13.6"
    EXTENDED_LIMITS -107374.182400 107374.182350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiRawSRCHi_C
    "Upper threshold for air-mass SRC-high detection"
    VALUE
    0x8006B6CC
    Val_Ws32
    214748364.750
    Time_PwmHigh
    -107374182.400
    107374182.350

    FORMAT "%13.3"
    EXTENDED_LIMITS -107374182.400 107374182.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiRawSRCLo_C
    "Lower threshold for air-mass SRC-high detection"
    VALUE
    0x8006B6D0
    Val_Ws32
    214748364.750
    Time_PwmHigh
    -107374182.400
    107374182.350

    FORMAT "%13.3"
    EXTENDED_LIMITS -107374182.400 107374182.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiThrHiPlOffsDrft_C
    "Upper threshold for offset drift check"
    VALUE
    0x8006B6D4
    Val_Ws32
    214748364.750
    Time_PwmHigh
    -107374182.400
    107374182.350

    FORMAT "%13.3"
    EXTENDED_LIMITS -107374182.400 107374182.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AFS_tiThrLoPlOffsDrft_C
    "Lower threshold for offset drift check"
    VALUE
    0x8006B6D8
    Val_Ws32
    214748364.750
    Time_PwmHigh
    -107374182.400
    107374182.350

    FORMAT "%13.3"
    EXTENDED_LIMITS -107374182.400 107374182.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AIRBAGCrash_CA
    "AIRBAGCrash_Msg data calibration"
    VAL_BLK
    0x8006CE60
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmprRedTrq_ATS.LimitTypeMsk_C
    "Actuator test AirCCmprRedTrq_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BD4C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmprRedTrq_ATS.CnvNorm_C
    "Actuator test AirCCmprRedTrq_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BD4D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmprRedTrq_ATS.LowLim_C
    "Actuator test AirCCmprRedTrq_ATS / Lower limit for monitoring"
    VALUE
    0x8006BD4E
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmprRedTrq_ATS.UpLim_C
    "Actuator test AirCCmprRedTrq_ATS / Upper limit for monitoring"
    VALUE
    0x8006BD50
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmprRedTrq_ATS.CnvFac_C
    "Actuator test AirCCmprRedTrq_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BD54
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmprRedTrq_ATS.CnvOfs_C
    "Actuator test AirCCmprRedTrq_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BD58
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmprRedTrq_ATS.DfltVal_C
    "Actuator test AirCCmprRedTrq_ATS / Default value for standbytest"
    VALUE
    0x8006BD5A
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmpr_ATS.LimitTypeMsk_C
    "Actuator test AirCCmpr_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BD5C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmpr_ATS.CnvNorm_C
    "Actuator test AirCCmpr_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BD5D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmpr_ATS.LowLim_C
    "Actuator test AirCCmpr_ATS / Lower limit for monitoring"
    VALUE
    0x8006BD5E
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmpr_ATS.UpLim_C
    "Actuator test AirCCmpr_ATS / Upper limit for monitoring"
    VALUE
    0x8006BD60
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmpr_ATS.CnvFac_C
    "Actuator test AirCCmpr_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BD64
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmpr_ATS.CnvOfs_C
    "Actuator test AirCCmpr_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BD68
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCCmpr_ATS.DfltVal_C
    "Actuator test AirCCmpr_ATS / Default value for standbytest"
    VALUE
    0x8006BD6A
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirCtl_stAirCtlBits_C
    ""
    VALUE
    0x8006C114
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_DigOutCmpr.tiBtwTstSCB_C
    "Structure containing parameters for Digital output power stage error handling for the compressor control signal / Time between tests for SCB error"
    VALUE
    0x8006B546
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_DigOutCmpr.tiBtwTstOT_C
    "Structure containing parameters for Digital output power stage error handling for the compressor control signal / Time between tests for OT error"
    VALUE
    0x8006B548
    Kw_Ws16
    1000.000
    Time_s
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_DigOutCmpr.numTstMax_C
    "Structure containing parameters for Digital output power stage error handling for the compressor control signal / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006B54A
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_DigOutRedTrq.tiBtwTstSCB_C
    "Structure containing parameters for Digital output power stage error handling for reduced torque signal / Time between tests for SCB error"
    VALUE
    0x8006B54C
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_DigOutRedTrq.tiBtwTstOT_C
    "Structure containing parameters for Digital output power stage error handling for reduced torque signal / Time between tests for OT error"
    VALUE
    0x8006B54E
    Kw_Ws16
    1000.000
    Time_s
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_DigOutRedTrq.numTstMax_C
    "Structure containing parameters for Digital output power stage error handling for reduced torque signal / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006B550
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_pDfl_C
    ""
    VALUE
    0x8006F248
    Kw_Ws16
    131070.0
    PresAC_hPa
    -65536.00
    65534.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -65536.00 65534.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_stCmprPsDiaDisbl_C
    "Status for deactivation of the powerstage diagnostics"
    VALUE
    0x8006B552
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_stCmprPsDisbl_C
    "Status for activation of the powerstage"
    VALUE
    0x8006B553
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_stCmprTyp_CW
    "Code word for the selection of compressor type"
    VALUE
    0x8006B554
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_stRedTrqPsDiaDisbl_C
    "Status for deactivation of the powerstage diagnostics for reduce torque instruction output"
    VALUE
    0x8006B555
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_stRedTrqPsDisbl_C
    "Status for activation of the powerstage for reduce torque instruction output"
    VALUE
    0x8006B556
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_trqCmprMax_C
    "Maximum value of compressor torque allowed"
    VALUE
    0x8006B558
    Val_Ws16
    1500.000
    Trq
    -500.0000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    AirC_trqCmprMin_C
    "Minimum value of the compressor torque."
    VALUE
    0x8006B55A
    Val_Ws16
    1500.000
    Trq
    -500.0000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_SRCPCACDs.uMin_C
    " / Threshold for SRC -Min detection"
    VALUE
    0x8006BEF8
    Kw_Ws16
    3500.000
    Volt
    0.00
    3500.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_SRCPCACDs.uMax_C
    " / Threshold for SRC -Max detection"
    VALUE
    0x8006BEFA
    Kw_Ws16
    5000.000
    Volt
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_SRCTAFS.uMin_C
    " / Threshold for SRC -Min detection"
    VALUE
    0x8006BF0A
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_SRCTAFS.uMax_C
    " / Threshold for SRC -Max detection"
    VALUE
    0x8006BF0C
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_SRCTEGRClrDs.uMin_C
    "Structure containing thresholds for Signal Range Check of EGR cooler down stream temperature sensor / Threshold for SRC -Min detection"
    VALUE
    0x80072FB6
    Kw_Ws16
    1000.000
    Volt
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_SRCTEGRClrDs.uMax_C
    "Structure containing thresholds for Signal Range Check of EGR cooler down stream temperature sensor / Threshold for SRC -Max detection"
    VALUE
    0x80072FB8
    Kw_Ws16
    2000.000
    Volt
    3000.000
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_swtSensPrsTEGRClrDs_C
    "Switch to decide whether EGR cooler down stream temperature sensor is present or not"
    VALUE
    0x80072FBA
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_tTransfTAFS_CUR
    ""
    CURVE
    0x8006BF0E
    Cur_Xs16Ws16
    240.0000
    Temp_Cels
    -40.04000
    199.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_uRawTAFS_mp
        Volt
        25
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Air_tTransfTEGRClrDs_CUR
    "Transformation curve to convert raw voltage value from adc to the sensed temperature value of EGR cooler at the down stream."
    CURVE
    0x80072FBC
    Cur_Xs16Ws16
    250.0000
    Temp_Cels
    -50.04000
    199.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_uRawTEGRClrDs
        Volt
        16
        0.00
        5000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    APP_uAPP1RawMin_C
    ""
    VALUE
    0x8006C184
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    APP_uAPP2RawMin_C
    ""
    VALUE
    0x8006C186
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_cndHtOfs_C
    "Offset value for thermal conductivity"
    VALUE
    0x8006BA0E
    Val_Ws16
    0.009033203
    Fact
    0.0009765625
    0.01000977

    FORMAT "%10.8"
    EXTENDED_LIMITS -4.000000 3.999878
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_cpGs_C
    "Specific thermal capacity, gas"
    VALUE
    0x8006BC78
    Val_Ws32
    2.00000000000
    SpecificHeat
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS -214748.364800 214748.364700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_cpPipeSlw_CA
    "Thermal capacity of the tube"
    VAL_BLK
    0x8006BBF4
    ValA_Ws32
    2999.90000000
    HeatCapacity
    0.100000000000
    3000.00000000

    FORMAT "%13.8"
    EXTENDED_LIMITS -214748364.800 214748364.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_cpPipe_CA
    "Thermal capacity of the tube"
    VAL_BLK
    0x8006BBC4
    ValA_Ws32
    2999.90000000
    HeatCapacity
    0.100000000000
    3000.00000000

    FORMAT "%13.8"
    EXTENDED_LIMITS -214748364.800 214748364.700
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_dmAir_MAP
    ""
    MAP
    0x8006B6E6
    Map_Xs16Ys16Ws16
    6553.500
    AirMassPerTime
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_nEng
        EngN
        8
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_qInjCmb
        InjMass
        8
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_dmEGMinVal_C
    ""
    VALUE
    0x8006B78A
    Val_Ws16
    6553.500
    AirMassPerTime
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_dmExhMnfUsDfl_C
    ""
    VALUE
    0x8006B78C
    Val_Ws16
    6553.500
    AirMassPerTime
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_etaTrbCh_MAP
    "Map for the turbocharger overall efficiency"
    MAP
    0x8006BC7C
    Map_Xs16Ys16Ws16
    0.9998779
    Fact
    0.0001220703
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_dmAFSCor
        AirMassPerTime
        8
        0.00
        1000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -3276.800 3276.700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_rPresCmpr_mp
        Fact
        8
        0.5000000
        3.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -4.000000 3.999878
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facAirMass_CUR
    ""
    CURVE
    0x8006B78E
    Cur_Xs16Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_rAirPerTime_mp
        RatAirMass
        8
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facCndHtSlp_C
    "Gradient value for thermal conductivity"
    VALUE
    0x8006BA10
    Val_Ws16
    0.00002000000
    Fact8
    0.00006000000
    0.00008000000

    FORMAT "%13.11"
    EXTENDED_LIMITS -0.0003276800 0.0003276700
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facCorrCldEng_CUR
    ""
    CURVE
    0x8006B7B0
    Cur_Xs16Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_tDiffCldEng_mp
        Temp_Cels
        8
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facGeoEGPipe_CA
    "Array of the geometric factors for the calculation of the pressure in the exhaust system"
    VAL_BLK
    0x8006BA5E
    ValA_Ws16
    100.0000
    Fact1
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facIAT_CUR
    ""
    CURVE
    0x8006B7D2
    Cur_Xs16Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_tDiffIAT_mp
        Temp_Cels
        8
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facPowEGPipe_CUR
    "Power function for the pressure calculation in the exhaust system"
    CURVE
    0x8006BA60
    Cur_Xs16Ws16
    250.0000
    Fact1
    0.00
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    READ_ONLY

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_dVolEGPipe1_mp
        AirVolPerTime
        11
        0.00
        3200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -3276.800 3276.700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facRhoEtaEGPipe_MAP
    "Temperature-dependent density and viscosity factor for the calculation of the pressure in the exhaust system"
    MAP
    0x8006BA8E
    Map_Xs16Ys16Ws16
    10.00000
    Fact_2pwr11
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -16.00000 15.99951
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_tEGPresPipe_mp
        Temp_Cels
        9
        -40.04000
        799.9600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_pEGPresPipe_mp
        Pres_hPa
        2
        1000.000
        3000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facStrtDlv_CUR
    ""
    CURVE
    0x8006B7F4
    Cur_Xs16Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_phiDiffStrt_mp
        AngleCrS
        8
        -720.0000
        719.9780

        FORMAT "%8.4"
        EXTENDED_LIMITS -720.0000 719.9780
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facTempClg_CUR
    "Cooling curve of the exhaust-gas ducting components"
    CURVE
    0x8006BC18
    Cur_Xs16Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_rTempClgCrvIn_mp
        Fact1
        8
        0.00
        8.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -256.0000 255.9922
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facTimeClg_CUR
    "Inverted cooling curve, engine"
    CURVE
    0x8006BC3A
    Cur_Xs16Ws16
    255.0000
    Fact1
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_rTempClnt_mp
        Fact
        8
        0.00
        1.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -4.000000 3.999878
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facVscDynSlp_C
    "Gradient value for dynamic viscosity"
    VALUE
    0x8006BA12
    Val_Ws16
    0.0001700000
    Fact7
    0.00003000000
    0.0002000000

    FORMAT "%12.10"
    EXTENDED_LIMITS -0.003276800 0.003276700
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_facVscKinSlp_C
    "Gradient value for kinematic viscosity"
    VALUE
    0x8006BA14
    Val_Ws16
    0.0000001200000
    Fact10
    0.00000008000000
    0.0000002000000

    FORMAT "%15.13"
    EXTENDED_LIMITS -0.000003276800 0.000003276700
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_htcFreeCnvtPipeSlw_CA
    "Heat-transfer coefficient due to free convection"
    VAL_BLK
    0x8006BBF8
    ValA_Ws16
    999.9000
    ThermalCoEff
    0.1000000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_htcFreeCnvtPipe_CA
    "Heat-transfer coefficient due to free convection"
    VAL_BLK
    0x8006BBCC
    ValA_Ws16
    999.9000
    ThermalCoEff
    0.1000000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_lDiamPipeSlw_CA
    "Tube diameter"
    VAL_BLK
    0x8006BBFA
    ValA_Ws16
    0.09375000
    Length1
    0.007812500
    0.1015625

    FORMAT "%9.7"
    EXTENDED_LIMITS -256.0000 255.9922
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_lDiamPipe_CA
    "Tube diameter"
    VAL_BLK
    0x8006BBD0
    ValA_Ws16
    0.09375000
    Length1
    0.007812500
    0.1015625

    FORMAT "%9.7"
    EXTENDED_LIMITS -256.0000 255.9922
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_lLngthPipeSlw_CA
    "Tube length"
    VAL_BLK
    0x8006BBFC
    ValA_Ws16
    2.992188
    Length1
    0.007812500
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -256.0000 255.9922
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_lLngthPipe_CA
    "Tube length"
    VAL_BLK
    0x8006BBD4
    ValA_Ws16
    2.992188
    Length1
    0.007812500
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -256.0000 255.9922
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_nThresDwn_C
    "Engine speed threshold value for the detection of engine standstill"
    VALUE
    0x8006B6DC
    Val_Ws16
    900.0000
    EngN
    0.00
    900.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numAirTempStrt_C
    "Index for the selection of the desired air temperature"
    VALUE
    0x8006BC5C
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numAirTempTrbn_C
    "Index for the selection of the air temperature"
    VALUE
    0x8006BD20
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numBnk_C
    "Number of engine banks"
    VALUE
    0x8006B816
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numEngTempStrt_C
    "Index for the selection of the desired engine temperature"
    VALUE
    0x8006BC5D
    Val_Wu8
    2.00000000000
    EngTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numEngTemp_C
    ""
    VALUE
    0x8006B818
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numEnvPres_C
    "Index for the selection of the environmental pressure from the pressure field"
    VALUE
    0x8006B6DE
    Val_Ws16
    2.000000
    OneToOne
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numExhMnf_C
    ""
    VALUE
    0x8006B81A
    Val_Ws16
    2.000000
    OneToOne
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numIATS_C
    ""
    VALUE
    0x8006B81C
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numTrbnDs_C
    "Index for the selection of the tube model downstream of the turbocharger"
    VALUE
    0x8006B6E0
    Val_Ws16
    2.000000
    OneToOne
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_numTrbn_C
    "Index for the selection of the tube model for the temperature model of the turbocharger"
    VALUE
    0x8006B6E2
    Val_Ws16
    2.000000
    OneToOne
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_nuPipeEnv_CUR
    "Nusselt number between tube wall and environment"
    CURVE
    0x8006BA16
    Cur_Xs16Ws16
    5309.000
    OneToOne
    0.00
    5309.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    READ_ONLY

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_rePipeEnv1_mp
        ReynoldsNum1
        8
        0.00
        3750000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -32768000. 32767000.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_nuPipe_CUR
    "Nusselt number in the tube"
    CURVE
    0x8006BA38
    Cur_Xs16Ws16
    1130.000
    OneToOne
    0.00
    1130.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    READ_ONLY

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_rePipe1_mp
        ReynoldsNum
        8
        0.00
        800000.0

        FORMAT "%8.1"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_pDiffPipe0_MAP
    "Map for exhaust-gas back-pressure"
    MAP
    0x8006BACC
    Map_Xs16Ys16Ws16
    400.0000
    Pres_hPa
    0.00
    400.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        10
        800.0000
        4000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_qPresPipe_mp
        InjMass
        10
        0.00
        50.00000

        FORMAT "%8.5"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_phiStrtDlv_MAP
    ""
    MAP
    0x8006B81E
    Map_Xs16Ys16Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_nEng
        EngN
        8
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_qInjCmb
        InjMass
        8
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_rArPipeSlw_CA
    "Share of the tube surface exposed to the airstream"
    VAL_BLK
    0x8006BBFE
    ValA_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_rArPipe_CA
    "Share of the tube surface exposed to the airstream"
    VAL_BLK
    0x8006BBD8
    ValA_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_rTempAdbt_CUR
    "Curve for the adiabatic state change of the temperature"
    CURVE
    0x8006BD22
    Cur_Xs16Ws16
    0.4000244
    Fact
    1.000000
    1.400024

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    READ_ONLY

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_rPresCmpr_mp
        Fact
        8
        0.5000000
        3.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -4.000000 3.999878
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_swtCalcQntInjCmb_C
    "switch for selcection of combusted injection quantity"
    VALUE
    0x8006B6E4
    Val_Ws16
    3.000000
    OneToOne
    0.00
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_swtPresCalc_C
    "Selection switch for the pressure calculation in the exhaust system (map model or simulation)"
    VAL_BLK
    0x8006BBC0
    ValA_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeI.Ki_C
    "Parameter for the I-element in the temperature model for the tubes / Ki_C factor within the window"
    VALUE
    0x8006BBDC
    Kw_Ws32
    4.00003045797
    Ki_Kelv_Sec
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -10000000.0000 9999999.99534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeI.KiPos_C
    "Parameter for the I-element in the temperature model for the tubes / Ki_C factor above the window"
    VALUE
    0x8006BBE0
    Kw_Ws32
    4.00003045797
    Ki_Kelv_Sec
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -10000000.0000 9999999.99534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeI.KiNeg_C
    "Parameter for the I-element in the temperature model for the tubes / Ki_C factor below the window"
    VALUE
    0x8006BBE4
    Kw_Ws32
    4.00003045797
    Ki_Kelv_Sec
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -10000000.0000 9999999.99534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeI.WinPos_C
    "Parameter for the I-element in the temperature model for the tubes / Upper border of the window"
    VALUE
    0x8006BBE8
    Kw_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeI.WinNeg_C
    "Parameter for the I-element in the temperature model for the tubes / Lower border of the window"
    VALUE
    0x8006BBEC
    Kw_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeSlwI.Ki_C
    "Parameter for the I-element in the temperature model for the tubes / Ki_C factor within the window"
    VALUE
    0x8006BC00
    Kw_Ws32
    4.00003045797
    Ki_Kelv_Sec
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -10000000.0000 9999999.99534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeSlwI.KiPos_C
    "Parameter for the I-element in the temperature model for the tubes / Ki_C factor above the window"
    VALUE
    0x8006BC04
    Kw_Ws32
    4.00003045797
    Ki_Kelv_Sec
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -10000000.0000 9999999.99534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeSlwI.KiNeg_C
    "Parameter for the I-element in the temperature model for the tubes / Ki_C factor below the window"
    VALUE
    0x8006BC08
    Kw_Ws32
    4.00003045797
    Ki_Kelv_Sec
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -10000000.0000 9999999.99534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeSlwI.WinPos_C
    "Parameter for the I-element in the temperature model for the tubes / Upper border of the window"
    VALUE
    0x8006BC0C
    Kw_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_TempPipeSlwI.WinNeg_C
    "Parameter for the I-element in the temperature model for the tubes / Lower border of the window"
    VALUE
    0x8006BC10
    Kw_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tEngStat_C
    ""
    VALUE
    0x8006B8C2
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tExhMnfUsDfl_C
    ""
    VALUE
    0x8006B8C4
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tIAT_MAP
    ""
    MAP
    0x8006B8C6
    Map_Xs16Ys16Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_nEng
        EngN
        8
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_qInjCmb
        InjMass
        8
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tiCalcIniTempOn_C
    "minimum time duration for initialisation of temperature models since K15 on"
    VALUE
    0x8006BC5E
    Val_Ws16
    120.0000
    Time_s
    0.00
    120.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tiClgOfs_C
    "Correction of the cooling time due to heat accumulation effects"
    VALUE
    0x8006BC60
    Val_Ws32
    21474836.4700
    Time_s
    0.00
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tiHaValClnt_C
    "Cooling half-live period of the engine"
    VALUE
    0x8006BC64
    Val_Ws32
    21474836.4700
    Time_s
    0.00
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tiHaValPipe_CA
    "Cooling half-live period of the exhaust pipes"
    VAL_BLK
    0x8006BC68
    ValA_Ws32
    21474836.4700
    Time_s
    0.00
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tInit_C
    "Temperature for the temperature initialization"
    VALUE
    0x8006BC74
    Val_Ws16
    130.0000
    Temp_Cels
    -40.04000
    89.96000

    FORMAT "%8.5"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tiTrbnPT1_C
    "Fixed time constant PT1 filter"
    VALUE
    0x8006BD44
    Val_Ws32
    4294.9662960
    TimeDelay_s
    0.0010000000689
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tMnfStat_MAP
    ""
    MAP
    0x8006B96A
    Map_Xs16Ys16Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_nEng
        EngN
        8
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        ASMod_qInjCmb
        InjMass
        8
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tPipeDflSlw_C
    "Substitute value of the calculated temperature in the event of an error"
    VALUE
    0x8006BC14
    Val_Ws16
    1030.000
    Temp_Cels
    -30.04000
    999.9600

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tPipeDfl_C
    "Substitute value of the calculated temperature in the event of an error"
    VALUE
    0x8006BBF0
    Val_Ws16
    1030.000
    Temp_Cels
    -30.04000
    999.9600

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tStrtDfl_C
    "Substitute value for the initialization temperatures in the event of an error"
    VALUE
    0x8006BC76
    Val_Ws16
    1040.000
    Temp_Cels
    -40.04000
    999.9600

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tTrbnDsRawDfl_C
    "Substitute value for the raw exhaust-gas temperature value downstream of the turbocharger in the event of an error"
    VALUE
    0x8006BD48
    Val_Ws16
    1030.000
    Temp_Cels
    -30.04000
    999.9600

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tWallPipeDflSlw_C
    "Substitute value of the calculated tube wall temperature in the event of an error"
    VALUE
    0x8006BC16
    Val_Ws16
    1030.000
    Temp_Cels
    -30.04000
    999.9600

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_tWallPipeDfl_C
    "Substitute value of the calculated tube wall temperature in the event of an error"
    VALUE
    0x8006BBF2
    Val_Ws16
    1030.000
    Temp_Cels
    -30.04000
    999.9600

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_vscDynOfs_C
    "Offset value for dynamic viscosity"
    VALUE
    0x8006BA5A
    Val_Ws16
    0.05004883
    Fact
    -0.03002930
    0.02001953

    FORMAT "%10.8"
    EXTENDED_LIMITS -4.000000 3.999878
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ASMod_vscKinOfs_C
    "Offset value for kinematic viscosity"
    VALUE
    0x8006BA5C
    Val_Ws16
    0.00005300000
    Fact8
    -0.00006000000
    -0.000007000000

    FORMAT "%13.11"
    EXTENDED_LIMITS -0.0003276800 0.0003276700
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_Standby_Disabled_C
    "Activate or deactivate Standbytest"
    VALUE
    0x8006BD6C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_tiTstDemHeal_C
    "Minimum time without actuator test for re-release after time"
    VALUE
    0x8006BD6E
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_tiTstDemMax_C
    "Maximum permissible actuator test time"
    VALUE
    0x8006BD70
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_TmrBehaviour_C
    "Time limit response for new tester demands"
    VALUE
    0x8006BD72
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_TstDemMaxEngN_C
    "Maximum permissible engine speed for actuator test"
    VALUE
    0x8006BD73
    Val_Wu8
    10200.
    EngN_LRes
    0.00
    10200.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 10200.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ATS_TstDemMaxVSSCDV_C
    "Maximum permissible vehicle speed for actuator test"
    VALUE
    0x8006BD74
    Val_Ws16
    655.3500
    Vel
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BattU_swtRated_C
    ""
    VALUE
    0x80072EE4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BattU_uNrm_C
    ""
    VALUE
    0x8006F24E
    Val_Ws16
    655340.0
    Volt_Batt
    0.00
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BattU_uSRCMax_C
    ""
    VALUE
    0x8006C18E
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BattU_uSRCMin_C
    ""
    VALUE
    0x8006C190
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BattU_uTransf_CUR
    ""
    CURVE
    0x8006C192
    Cur_Xs16Ws16
    28600.00
    Volt_Batt
    0.00
    28600.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        BattU_uRaw
        Volt
        4
        0.00
        5199.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BCM_CANHS_RNr_01_CA
    "BCM_CANHS_RNr_01_Msg data calibration"
    VAL_BLK
    0x8006CE62
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BCM_CANHS_RNr_02_CA
    "BCM_CANHS_RNr_02_Msg data calibration"
    VAL_BLK
    0x8006CE6A
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BCM_VERLOG_CA
    "BCM_VERLOG_Msg data calibration"
    VAL_BLK
    0x8006CE72
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BRAKE_CANHS_RNr_01_CA
    "BRAKE_CANHS_RNr_01_Msg data calibration"
    VAL_BLK
    0x8006CE77
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BRAKE_CANHS_RNr_02_CA
    "BRAKE_CANHS_RNr_02_Msg data calibration"
    VAL_BLK
    0x8006CE7E
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BRAKE_CANHS_RNr_03_CA
    "BRAKE_CANHS_RNr_03_Msg data calibration"
    VAL_BLK
    0x8006CE84
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BRAKE_CANHS_RNr_04_CA
    "BRAKE_CANHS_RNr_04_Msg data calibration"
    VAL_BLK
    0x8006CE8A
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    BRAKE_CANHS_R_01_CA
    "BRAKE_CANHS_R_01_Msg data calibration"
    VAL_BLK
    0x8006CE92
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Brk_stDflVal_C
    ""
    VALUE
    0x8006F246
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Calwup_swtWakeupEnaCpl_C
    "enable (complement) Calibration Wake-Up by 90 only allowed for sample ECU's"
    VALUE
    0x8006C1B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Calwup_swtWakeupEna_C
    "enable Calibration Wake-Up by 165 only allowed for sample ECU's"
    VALUE
    0x8006C1B3
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbs_mil_flsh_req
    ""
    VALUE
    0x80072F0C
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_emtv_vb_cor_ena
    ""
    VALUE
    0x8006C1A4
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_fms_dwk_cor_main_cfg
    ""
    VALUE
    0x8006F242
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_gear_cge_tqe_sp_lim
    ""
    VALUE
    0x80072F0D
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_it_vb_cor_ena
    ""
    VALUE
    0x8006C1A6
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_l_pwl_conf
    ""
    VALUE
    0x8006F250
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_n_rams_lim_spc_act_1
    ""
    VALUE
    0x80072F0E
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_n_rams_lim_spc_act_2
    ""
    VALUE
    0x80072F0F
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_ovt_ena
    ""
    VALUE
    0x80072F10
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_prs_actr_pres_cfm
    ""
    VALUE
    0x8006DDCC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_pwst_prs_stt
    ""
    VALUE
    0x80072F11
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_rest_aftr_crsh_ena
    ""
    VALUE
    0x8007312C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cbx_sens_pbt_frz_cfm
    ""
    VALUE
    0x8006BF7E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CEngDsT_SRC.uMin_C
    " / Threshold for SRC -Min detection"
    VALUE
    0x8006C11A
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CEngDsT_SRC.uMax_C
    " / Threshold for SRC -Max detection"
    VALUE
    0x8006C11C
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CEngDsT_tTransf_CUR
    ""
    CURVE
    0x8006C11E
    Cur_Xs16Ws16
    240.0000
    Temp_Cels
    -40.04000
    199.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        CEngDsT_uRaw_mp
        Volt
        25
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CLIM_CANHS_R_01_CA
    "CLIM_CANHS_R_01_Msg data calibration"
    VAL_BLK
    0x8006CE99
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Clth_stDflVal_C
    "Default value for the Clutch signal."
    VALUE
    0x8006F247
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CLUSTER_CANHS_RNr_01_CA
    "CLUSTER_CANHS_RNr_01_Msg data calibration"
    VAL_BLK
    0x8006CE9F
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CLUSTER_CANHS_R_01_CA
    "CLUSTER_CANHS_R_01_Msg data calibration"
    VAL_BLK
    0x8006CEA4
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cmp_pbt_frz_v_apl_thd
    ""
    MAP
    0x8006BF80
    MapG_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_n_mv_pbtxxsr_mp
        Rpm025_RSA
        8
        0.00
        16383.75

        FORMAT "%8.2"
        EXTENDED_LIMITS 0.00 16383.75

        AXIS_PTS_REF Ctb_pbt_frz_n_thd

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_tqi_raw_pbtxxsr_mp
        Trq132_no_Offs_RSA
        8
        0.00
        2047.969

        FORMAT "%8.3"
        EXTENDED_LIMITS 0.00 2047.969

        AXIS_PTS_REF Ctb_pbt_frz_tqi_thd

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_AftRunShOff_C
    ""
    VALUE
    0x8006C1BC
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_nSoftShOffMax_C
    ""
    VALUE
    0x8006C1C0
    Val_Wu16
    32767.50
    EngN
    0.00
    32767.50

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 32767.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_nSoftShOffMin_C
    ""
    VALUE
    0x8006C1C2
    Val_Wu16
    32767.50
    EngN
    0.00
    32767.50

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 32767.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_nThresCranking_C
    ""
    VALUE
    0x8006C1F8
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_nThresNrml2Strt_C
    "Engine speed threshold for engine state transition from NORMAL to START"
    VALUE
    0x8006C1FA
    Val_Ws16
    8000.000
    EngN
    0.00
    8000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_qSoftShOffMax_C
    ""
    VALUE
    0x8006C1C4
    Val_Wu16
    655.3500
    InjMass
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_stShutOffInit_C
    ""
    VALUE
    0x8006C1C8
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_stShutOffRSA_C
    ""
    VALUE
    0x80073130
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_stSoftShOff_C
    ""
    VALUE
    0x8006C1CC
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_stStopEna_C
    ""
    VALUE
    0x8006C200
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_stStrtEna_C
    ""
    VALUE
    0x8006C201
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_tiNrml2Strt_C
    "Debounce time for engine state transition from NORMAL to START"
    VALUE
    0x8006C1FC
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_tiPwrStgDiaRdy_C
    "delay time to diagnose turned off actuators while engine state afterrun is active"
    VALUE
    0x8006C1FE
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_tiSoftShOff_CUR
    ""
    CURVE
    0x8006C1D0
    Cur_Xs16Ws16
    800.0000
    Time_ms
    0.00
    800.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        9
        0.00
        800.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoEng_vSoftShOffMax_C
    ""
    VALUE
    0x8006C1F6
    Val_Wu16
    655.3500
    Vel
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoES_MskDewDet_C
    "Mask for Activation of AVS-functionality in DewDet"
    VALUE
    0x8006C1B4
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoES_MskFMA_C
    "Mask for Activation of AVS-functionality in FMA"
    VALUE
    0x8006C1B5
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoES_MskLSU_C
    "Mask for Activation of AVS-functionality in LSU (DE)"
    VALUE
    0x8006C1B6
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoES_stFuncSel_C
    "function selector in adjustment mode of value saving"
    VALUE
    0x8006C1B7
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoES_swtAdjMod_C
    "Switch for activation of adjustment mode for value saving"
    VALUE
    0x8006C1B8
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    CoTemp_rClgDes_CUR
    ""
    CURVE
    0x8006C202
    Cur_Xs16Ws16
    2000.000
    Prc
    -1000.000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EngDa_tEng
        Temp_Cels
        5
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cpu_swtClrEnvRAMVals_C
    ""
    VALUE
    0x8006C218
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Csx_brk_pdl_clos
    ""
    VALUE
    0x80072F12
    Val_Wu8
    1.00000000000
    brk_states
    0.00
    1.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 1.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Csx_epm_ctcyl_err
    ""
    VALUE
    0x8006C110
    Val_Ws8
    6.000
    OneToOne
    -3.000
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS -128.0 127.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Csx_inj_ecu_vld
    ""
    VALUE
    0x80072F13
    Val_Wu8
    1.00000000000
    vld_states
    0.00
    1.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 1.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin AXIS_PTS

    Ctb_pbt_frz_n_thd
    ""
    0x8006C000
    Vxx_n_mv_pbtxxsr_mp
    Axis_Xu16
    16383.75
    Rpm025_RSA
    8
    0.00
    16383.75

    
    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 16383.75
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    Ctb_pbt_frz_tqi_thd
    ""
    0x8006C012
    Vxx_tqi_raw_pbtxxsr_mp
    Axis_Xu16
    2047.969
    Trq132_no_Offs_RSA
    8
    0.00
    2047.969

    
    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 2047.969
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    Ctb_sens_doc1_utp_v
    ""
    0x8006C04A
    Vxx_sens_doc1_utp_v_mv
    Axis_Xu16
    6553.500
    V02_RSA
    16
    0.00
    6553.500

    
    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 6553.500
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    Ctb_sens_pft_utp_v
    ""
    0x8006C08C
    Vxx_sens_pft_utp_v_mv
    Axis_Xs16
    6553.500
    V02_RSA
    16
    0.00
    6553.500

    
    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    Ctb_sens_tbt_v
    ""
    0x8006C0CE
    Vxx_sens_tbt_v_mv
    Axis_Xs16
    13107.00
    Volt_RSA
    16
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    Ctb_x_map_v_map
    ""
    0x8006BEFC
    Vxx_sens_map_v_avr
    Axis_Xs16
    25000.00
    V1_RSA
    2
    0.00
    25000.00

    
    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    Ctb_x_pbt_v_pbt
    ""
    0x8006C024
    Vxx_sens_pbt_v_avr
    Axis_Xs16
    65535.00
    V1_RSA
    2
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    Ctb_x_rup_v_rup
    ""
    0x8006C038
    Vxx_sens_rup_v_avr
    Axis_Xs16
    25000.00
    V1_RSA
    2
    0.00
    25000.00

    
    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    Ctp_map_v_map
    ""
    CURVE
    0x8006BF02
    CurG_Ws16
    20000.00
    hPa_RSA
    0.00
    20000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_sens_map_v_avr
        V1_RSA
        2
        0.00
        25000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00

        AXIS_PTS_REF Ctb_x_map_v_map

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Ctp_pbt_v_pbt
    ""
    CURVE
    0x8006C02A
    CurG_Ws16
    65535.00
    Pres_hPa
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_sens_pbt_v_avr
        V1_RSA
        2
        -32768.00
        32767.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00

        AXIS_PTS_REF Ctb_x_pbt_v_pbt

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Ctp_rup_v_rup
    ""
    CURVE
    0x8006C03E
    CurG_Ws16
    20000.00
    Pres_hPa
    -10000.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_sens_rup_v_avr
        V1_RSA
        2
        0.00
        25000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00

        AXIS_PTS_REF Ctb_x_rup_v_rup

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Ctp_sens_doc1_utp
    ""
    CURVE
    0x8006C06C
    CurG_Wu16
    1240.000
    TempC_RSA
    -40.00000
    1200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -40.00000 6513.500
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_sens_doc1_utp_v_mv
        V02_RSA
        16
        0.00
        6553.500

        FORMAT "%8.3"
        EXTENDED_LIMITS 0.00 6553.500

        AXIS_PTS_REF Ctb_sens_doc1_utp_v

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Ctp_sens_pft_utp
    ""
    CURVE
    0x8006C0AE
    CurG_Ws16
    1240.000
    TempC_RSA
    -40.00000
    1200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3316.800 3236.700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_sens_pft_utp_v_mv
        V02_RSA
        16
        0.00
        6553.500

        FORMAT "%8.3"
        EXTENDED_LIMITS -3276.800 3276.700

        AXIS_PTS_REF Ctb_sens_pft_utp_v

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Ctp_sens_tbt
    ""
    CURVE
    0x8006C0F0
    CurG_Ws16
    1240.000
    TempC_RSA
    -40.00000
    1200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3316.800 3236.700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Vxx_sens_tbt_v_mv
        Volt_RSA
        16
        -6553.600
        6553.400

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400

        AXIS_PTS_REF Ctb_sens_tbt_v

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxs_ovt_smk_appl
    ""
    VALUE
    0x80072F14
    Val_Wu16
    100.0000
    InjMass_RSA
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxs_ovt_tq_appl
    ""
    VALUE
    0x80072F16
    Val_Wu16
    2048.000
    Trq132_no_Offs_RSA
    0.00
    2048.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 2047.969
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_ACC_CANHS_R_01_RB_id
    "ACC_CANHS_R_01_id_Msg ID calibration"
    VALUE
    0x8006B3D0
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_AIRBAGCrash_RB_id
    "AIRBAGCrash_Msg ID calibration"
    VALUE
    0x8006B3CC
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BCM_CANHS_RNr_01_RB_id
    "BCM_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B3C8
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BCM_CANHS_RNr_02_RB_id
    "BCM_CANHS_RNr_02_Msg ID calibration"
    VALUE
    0x8006B3C4
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BCM_VERLOG_RB_id
    "BCM_VERLOG_Msg ID calibration"
    VALUE
    0x8006B3C0
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BRAKE_CANHS_RNr_01_RB_id
    "BRAKE_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B3BC
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BRAKE_CANHS_RNr_02_RB_id
    "BRAKE_CANHS_RNr_02_Msg ID calibration"
    VALUE
    0x8006B3B8
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BRAKE_CANHS_RNr_03_RB_id
    "BRAKE_CANHS_RNr_03_Msg ID calibration"
    VALUE
    0x8006B3B4
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BRAKE_CANHS_RNr_04_RB_id
    "BRAKE_CANHS_RNr_04_Msg ID calibration"
    VALUE
    0x8006B3B0
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_BRAKE_CANHS_R_01_RB_id
    "BRAKE_CANHS_R_01_Msg ID calibration"
    VALUE
    0x8006B3AC
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_CLIM_CANHS_R_01_RB_id
    "CLIM_CANHS_R_01_Msg ID calibration"
    VALUE
    0x8006B3A8
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_CLUSTER_CANHS_RNr_01_RB_id
    "CLUSTER_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B3A4
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_CLUSTER_CANHS_R_01_RB_id
    "CLUSTER_CANHS_R_01_Msg ID calibration"
    VALUE
    0x8006B3A0
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_DDCM_CANLSFT_R_01_RB_id
    "DDCM_CANLSFT_R_01_Msg ID calibration"
    VALUE
    0x8006B39C
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_actr_rly_oc
    ""
    VALUE
    0x8006F252
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_actr_rly_scg
    ""
    VALUE
    0x8006F254
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_actr_rly_scw
    ""
    VALUE
    0x8006F256
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_ecm_mon_secu_1
    ""
    VALUE
    0x8006C4B8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_ecm_mon_secu_2
    ""
    VALUE
    0x8006C4BA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_sens_wfl_oc
    ""
    VALUE
    0x8006DDBC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_sfty_tq_chr
    ""
    VALUE
    0x8006B4D2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_sfty_tq_clc_chr
    ""
    VALUE
    0x8006B4D4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_sfty_tq_fail
    ""
    VALUE
    0x8006B4D6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfdec_sfty_tq_supl
    ""
    VALUE
    0x8006B4D8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_actr_rly_oc
    ""
    VALUE
    0x8006F258
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_actr_rly_scg
    ""
    VALUE
    0x8006F25A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_actr_rly_scw
    ""
    VALUE
    0x8006F25C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_ecm_mon_secu_1
    ""
    VALUE
    0x8006C4BC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_ecm_mon_secu_2
    ""
    VALUE
    0x8006C4BE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_sens_wfl_oc
    ""
    VALUE
    0x8006DDBE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_sfty_tq_chr
    ""
    VALUE
    0x8006B4DA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_sfty_tq_clc_chr
    ""
    VALUE
    0x8006B4DC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_sfty_tq_fail
    ""
    VALUE
    0x8006B4DE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_dfinc_sfty_tq_supl
    ""
    VALUE
    0x8006B4E0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_diag_ena_LSU_active
    ""
    VALUE
    0x8006C118
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_diag_ena_sens_maf_vb_h
    ""
    VALUE
    0x8006BE8A
    Val_Wu16
    60.00000
    V01_RSA
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_diag_ena_sens_maf_vb_l
    ""
    VALUE
    0x8006BE8C
    Val_Wu16
    60.00000
    V01_RSA
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_ECM_CANHS_RNr_01_RB_id
    "ECM_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B398
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_ECM_CANHS_RNr_02_RB_id
    "ECM_CANHS_RNr_02_Msg ID calibration"
    VALUE
    0x8006B394
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_ECM_VERLOG_RB_id
    ""
    VALUE
    0x8006B390
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_egb_n_lim
    ""
    VALUE
    0x80072F18
    Val_Wu16
    16383.75
    Rpm025_RSA
    0.00
    16383.75

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 16383.75
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_emtv_sens_pws_nok
    ""
    VALUE
    0x8006BE84
    Val_Wu16
    6000.000
    V1_RSA
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_emtv_sens_pws_over
    ""
    VALUE
    0x8006BE86
    Val_Wu16
    6000.000
    V1_RSA
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_emtv_sens_pws_under
    ""
    VALUE
    0x8006BE88
    Val_Wu16
    6000.000
    V1_RSA
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_emtv_vb_cor
    ""
    VALUE
    0x8006C1A5
    Val_Ws8
    200.0
    OneToOne
    -100.0
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS -128.0 127.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_eng_stop_req_airb2_lvl1
    ""
    VALUE
    0x80073134
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_eng_stop_req_airb2_lvl2
    ""
    VALUE
    0x80073135
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_eng_stop_req_ccu
    ""
    VALUE
    0x80073136
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_eng_stop_req_rgb
    ""
    VALUE
    0x80073137
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_eng_stop_req_ssg
    ""
    VALUE
    0x80073138
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_ffit_vb_min
    ""
    VALUE
    0x8006C1A8
    Val_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_fms_nLpos
    ""
    VALUE
    0x8006F243
    Val_Wu8
    2.000
    OneToOne
    2.000
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_FORCE_ECM_CANHS_R_01_RB_id
    ""
    VALUE
    0x8006B38C
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_gear_cge_fmt
    ""
    VALUE
    0x80072F1A
    Val_Wu16
    1.000000
    R01_RSA
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_it_sens_pws_nok
    ""
    VALUE
    0x8006BF74
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_it_sens_pws_over
    ""
    VALUE
    0x8006BF76
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_it_sens_pws_under
    ""
    VALUE
    0x8006BF78
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_it_vb_cor
    ""
    VALUE
    0x8006C1A7
    Val_Ws8
    200.0
    OneToOne
    -100.0
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS -128.0 127.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_lsu_dcyc_diag_ena
    ""
    VALUE
    0x8006C1AA
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_map_raw_flt
    ""
    VALUE
    0x8006BF06
    Val_Wu16
    65.53500
    WU001_RSA
    0.00
    65.53500

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 65.53500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_map_raw_init
    ""
    VALUE
    0x8006BF08
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_mat
    ""
    VALUE
    0x80072F1C
    Val_Wu16
    240.0000
    TempC_RSA
    -40.00000
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -40.00000 6513.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_min_fuel_dly
    ""
    VALUE
    0x8006DDB8
    Val_Wu16
    655.3500
    sec_001_RSA
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_min_pwl_dly
    ""
    VALUE
    0x8006F25E
    Val_Wu16
    6553.500
    Time_sec_1
    0.00
    6553.500

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 6553.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_MMI_ECM_CANHS_RNr_01_RB_id
    "MMI_ECM_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B388
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_NC_CAN_RX_FCT_id
    ""
    VALUE
    0x8006B384
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_NC_CAN_RX_PHYS_id
    ""
    VALUE
    0x8006B380
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_NC_CAN_TX_id
    ""
    VALUE
    0x8006B37C
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_no_min_fuel_dly
    ""
    VALUE
    0x8006DDBA
    Val_Wu16
    655.3500
    sec_001_RSA
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_n_min_wfl_diag
    ""
    VALUE
    0x8006DDC0
    Val_Wu16
    16383.75
    Rpm025_RSA
    0.00
    16383.75

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 16383.75
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_off_crk_dly
    ""
    VALUE
    0x8006C188
    Val_Wu16
    65535.00
    OneToOne_ms
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pbt_frz_dfdec
    ""
    VALUE
    0x8006C02E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pbt_frz_dfinc
    ""
    VALUE
    0x8006C030
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pbt_frz_tia_max
    ""
    VALUE
    0x8006C032
    Val_Wu16
    6553.500
    TempC_RSA
    -40.00000
    6513.500

    FORMAT "%8.3"
    EXTENDED_LIMITS -40.00000 6513.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pbt_raw_flt
    ""
    VALUE
    0x8006C034
    Val_Wu16
    1.000000
    Fact1000
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 65.53500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pbt_raw_init
    ""
    VALUE
    0x8006C036
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pwl_dly
    ""
    VALUE
    0x8006F260
    Val_Wu16
    6553.500
    Time_sec_1
    0.00
    6553.500

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 6553.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pwl_dly_pws_max
    ""
    VALUE
    0x8006F262
    Val_Wu16
    6553.500
    Time_sec_1
    0.00
    6553.500

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 6553.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pwl_dly_secu
    ""
    VALUE
    0x8006F264
    Val_Wu16
    6553.500
    Time_sec_1
    0.00
    6553.500

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 6553.500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pws_1
    ""
    VALUE
    0x8006C1AE
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pws_2
    ""
    VALUE
    0x8006C1B0
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_pws_3
    ""
    VALUE
    0x8006C1AC
    Val_Wu16
    25000.00
    V1_RSA
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_rest_aftr_crsh_dly
    ""
    VALUE
    0x8007313A
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_rup_raw_flt
    ""
    VALUE
    0x8006C042
    Val_Wu16
    65.53500
    WU1_RSA
    0.00
    65.53500

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 65.53500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_rup_raw_init
    ""
    VALUE
    0x8006C044
    Val_Wu16
    65535.00
    V1_RSA
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sens_prop_down_v
    ""
    VALUE
    0x80072F1E
    Val_Wu16
    5.000000
    V000122_RSA
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 7.994998
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_acel_pdl_off_sens_thd
    ""
    VALUE
    0x8006B4C0
    Val_Wu16
    25000.00
    Mo_u_mV_q1p0
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_acel_pdl_off_t_thd
    ""
    VALUE
    0x8006B4C2
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_aftr_rst_ajs_cut_t
    ""
    VALUE
    0x8006B4C4
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_aftr_rst_tq_req_t
    ""
    VALUE
    0x8006B4C5
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_asr_tqe_sp_msr_raw
    ""
    VALUE
    0x8006B4B0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_aut_eng_n_thd_h
    ""
    VALUE
    0x8006B4E2
    Val_Wu8
    8160.
    Mo_n_rpm_q32p0
    0.00
    8160.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 8160.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_aut_eng_n_thd_l
    ""
    VALUE
    0x8006B4E3
    Val_Wu8
    8160.
    Mo_n_rpm_q32p0
    0.00
    8160.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 8160.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_bch_mod_1
    ""
    VALUE
    0x8006B4E4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_bch_mod_2
    ""
    VALUE
    0x8006B4E6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_cru_brk_nok_t
    ""
    VALUE
    0x8006B4B6
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_cru_brk_tout_1
    ""
    VALUE
    0x8006B4B7
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_cru_brk_tout_2
    ""
    VALUE
    0x8006B4B8
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_cru_brk_tout_long
    ""
    VALUE
    0x8006B4B9
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_cru_rest_max_v
    ""
    VALUE
    0x8006B4BA
    Val_Wu16
    25000.00
    Mo_u_mV_q1p0
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_cru_rest_min_v
    ""
    VALUE
    0x8006B4BC
    Val_Wu16
    25000.00
    Mo_u_mV_q1p0
    0.00
    25000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_cru_tq_req_t
    ""
    VALUE
    0x8006B4BE
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_diag_ena_eng_dly
    ""
    VALUE
    0x8006B4E8
    Val_Wu8
    255.0
    Mo_ti_s_q1p0
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_efy_no_nul_thd
    ""
    VALUE
    0x8006B4CA
    Val_Wu8
    2.550
    Mo_fac_q0p01
    0.00
    2.550

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 2.550
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_ext_ctrl_bch_vs_thd
    ""
    VALUE
    0x8006B4E9
    Val_Wu8
    255.0
    Mo_v_kmh_q1p0
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_ext_ctrl_t
    ""
    VALUE
    0x8006B4EA
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_fms_fim_no_nul_thd
    ""
    VALUE
    0x8006B4CC
    Val_Wu16
    655.3500
    Mo_inj_mass_q0p01
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_fms_fim_nul_thd
    ""
    VALUE
    0x8006B4CE
    Val_Wu16
    655.3500
    Mo_inj_mass_q0p01
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_mux_agb_tqe_nok_raw
    ""
    VALUE
    0x8006B4B2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_mux_asr_tqe_nok_raw
    ""
    VALUE
    0x8006B4B4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_n_lim_max_thd
    ""
    VALUE
    0x8006B4EB
    Val_Wu8
    8160.
    Mo_n_rpm_q32p0
    0.00
    8160.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 8160.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_rst_t
    ""
    VALUE
    0x8006B4EC
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_stop_req_igk_rst_t
    ""
    VALUE
    0x8006B4ED
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_stop_req_t
    ""
    VALUE
    0x8006B4EE
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_tlp1_min
    ""
    VALUE
    0x8006B4D0
    Val_Ws16
    1310.700
    Mo_ang_crk_q0p02
    -655.3600
    655.3400

    FORMAT "%8.4"
    EXTENDED_LIMITS -655.3600 655.3400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_tq_mon_t
    ""
    VALUE
    0x8006B4EF
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_tq_req_ajs_cut_min_n
    ""
    VALUE
    0x8006B4C6
    Val_Wu8
    8160.
    Mo_n_rpm_q32p0
    0.00
    8160.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 8160.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_tq_req_ajs_cut_t
    ""
    VALUE
    0x8006B4C7
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_tq_req_min_n
    ""
    VALUE
    0x8006B4C8
    Val_Wu8
    8160.
    Mo_n_rpm_q32p0
    0.00
    8160.

    FORMAT "%5.0"
    EXTENDED_LIMITS 0.00 8160.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_sfty_tq_req_t
    ""
    VALUE
    0x8006B4C9
    Val_Wu8
    10.20
    Mo_ti_s_q0p04
    0.00
    10.20

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 10.20
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_SWA_CANHS_RNr_01_RB_id
    "SWA_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B378
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_TORQUE_AT_CANHS_RNr_01_RB_id
    "TORQUE_AT_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B374
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_TORQUE_AT_CANHS_RNr_02_RB_id
    "TORQUE_AT_CANHS_RNr_02_Msg ID calibration"
    VALUE
    0x8006B370
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_TORQUE_ECM_CANHS_RNr_01_RB_id
    "TORQUE_ECM_CANHS_RNr_01_Msg ID calibration"
    VALUE
    0x8006B36C
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_TORQUE_ECM_CANHS_RNr_02_RB_id
    "TORQUE_ECM_CANHS_RNr_02_Msg ID calibration"
    VALUE
    0x8006B368
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_TORQUE_ECM_CANHS_R_01_RB_id
    "TORQUE_ECM_CANHS_R_01_Msg ID calibration"
    VALUE
    0x8006B364
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_USM_CANHS_RNr_01_RB_id
    "USM_CANHS_RNr_01 ID calibration"
    VALUE
    0x8006B360
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_vb_wfl_max
    ""
    VALUE
    0x8006DDC2
    Val_Wu16
    60.00000
    V01_RSA
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_vb_wfl_min
    ""
    VALUE
    0x8006DDC4
    Val_Wu16
    60.00000
    V01_RSA
    0.00
    60.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_vs_min_wfl_diag
    ""
    VALUE
    0x8006DDC6
    Val_Wu16
    655.3500
    v_01_RSA
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_wait_wfl_authorize_conf
    ""
    VALUE
    0x8006DDC8
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Cxx_wait_wfl_auto_conf
    ""
    VALUE
    0x8006DDCA
    Val_Wu16
    65.535000000
    TimeDelay_s_RSA
    0.00
    65.535000000

    FORMAT "%12.9"
    EXTENDED_LIMITS 0.00 65.535000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDCM_CANLSFT_R_01_CA
    "DDCM_CANLSFT_R_01_Msg data calibration"
    VAL_BLK
    0x8006CEAC
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprSCBDebOk_C
    " / "
    VALUE
    0x8007339E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprSCBDebDef_C
    " / "
    VALUE
    0x800733A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgUndrVltgDebOk_C
    " / "
    VALUE
    0x800733A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgUndrVltgDebDef_C
    " / "
    VALUE
    0x800733A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_titExcMaxDebOk_C
    " / "
    VALUE
    0x800733A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_titExcMaxDebDef_C
    " / "
    VALUE
    0x800733A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCInj_tiSCGDebOk_C
    " / "
    VALUE
    0x800733AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCInj_tiSCGDebDef_C
    " / "
    VALUE
    0x800733AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd1DebOk_C
    " / "
    VALUE
    0x800733AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd1DebDef_C
    " / "
    VALUE
    0x800733B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiDebDiaSumDebOk_C
    " / "
    VALUE
    0x800733B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiDebDiaSumDebDef_C
    " / "
    VALUE
    0x800733B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiSCBDebOk_C
    " / "
    VALUE
    0x800733B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiSCBDebDef_C
    " / "
    VALUE
    0x800733B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.TrbCh_tiOLDebOk_C
    " / "
    VALUE
    0x800733BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.TrbCh_tiOLDebDef_C
    " / "
    VALUE
    0x800733BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiOLDebOk_C
    " / "
    VALUE
    0x800733BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiOLDebDef_C
    " / "
    VALUE
    0x800733C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrSigDebOk_C
    " / "
    VALUE
    0x800733C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrSigDebDef_C
    " / "
    VALUE
    0x800733C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiSCGDebOk_C
    " / "
    VALUE
    0x800733C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiSCGDebDef_C
    " / "
    VALUE
    0x800733C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSOLDebOk_C
    " / "
    VALUE
    0x800733CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSOLDebDef_C
    " / "
    VALUE
    0x800733CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.InjVlv_tiPresMinDebOk_C
    " / "
    VALUE
    0x800733CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.InjVlv_tiPresMinDebDef_C
    " / "
    VALUE
    0x800733D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiSCGDebOk_C
    " / "
    VALUE
    0x800733D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiSCGDebDef_C
    " / "
    VALUE
    0x800733D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSCGDebOk_C
    " / "
    VALUE
    0x800733D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSCGDebDef_C
    " / "
    VALUE
    0x800733D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattULoDebOk_C
    " / "
    VALUE
    0x800733DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattULoDebDef_C
    " / "
    VALUE
    0x800733DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiOLDebOk_C
    " / "
    VALUE
    0x800733DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiOLDebDef_C
    " / "
    VALUE
    0x800733E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiCorSRCMaxDebOk_C
    " / "
    VALUE
    0x800733E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiCorSRCMaxDebDef_C
    " / "
    VALUE
    0x800733E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCInj_tiSCBDebOk_C
    " / "
    VALUE
    0x800733E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCInj_tiSCBDebDef_C
    " / "
    VALUE
    0x800733E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiOLDebOk_C
    " / "
    VALUE
    0x800733EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiOLDebDef_C
    " / "
    VALUE
    0x800733EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiSCBDebOk_C
    " / "
    VALUE
    0x800733EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiSCBDebDef_C
    " / "
    VALUE
    0x800733F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirOvrLdDebOk_C
    " / "
    VALUE
    0x800733F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirOvrLdDebDef_C
    " / "
    VALUE
    0x800733F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiOLDebOk_C
    " / "
    VALUE
    0x800733F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiOLDebDef_C
    " / "
    VALUE
    0x800733F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiOvrTempDebOk_C
    " / "
    VALUE
    0x800733FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiOvrTempDebDef_C
    " / "
    VALUE
    0x800733FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrNplDebOk_C
    " / "
    VALUE
    0x800733FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrNplDebDef_C
    " / "
    VALUE
    0x80073400
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgOvrTempDebOk_C
    " / "
    VALUE
    0x80073402
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgOvrTempDebDef_C
    " / "
    VALUE
    0x80073404
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.FuelT_tiMinDebOk_C
    " / "
    VALUE
    0x80073406
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.FuelT_tiMinDebDef_C
    " / "
    VALUE
    0x80073408
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd2DebOk_C
    " / "
    VALUE
    0x8007340A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd2DebDef_C
    " / "
    VALUE
    0x8007340C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiOvrTempDebOk_C
    " / "
    VALUE
    0x8007340E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiOvrTempDebDef_C
    " / "
    VALUE
    0x80073410
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgTempOvrCurrDebOk_C
    " / "
    VALUE
    0x80073412
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgTempOvrCurrDebDef_C
    " / "
    VALUE
    0x80073414
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiSCBDebOk_C
    " / "
    VALUE
    0x80073416
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiSCBDebDef_C
    " / "
    VALUE
    0x80073418
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt1DebOk_C
    " / "
    VALUE
    0x8007341A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt1DebDef_C
    " / "
    VALUE
    0x8007341C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprRedTrqOLDebOk_C
    " / "
    VALUE
    0x8007341E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprRedTrqOLDebDef_C
    " / "
    VALUE
    0x80073420
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSCGDebOk_C
    " / "
    VALUE
    0x80073422
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSCGDebDef_C
    " / "
    VALUE
    0x80073424
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSRCMinDebOk_C
    " / "
    VALUE
    0x80073426
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSRCMinDebDef_C
    " / "
    VALUE
    0x80073428
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.RailP_tiSRCMinDebOk_C
    " / "
    VALUE
    0x8007342A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.RailP_tiSRCMinDebDef_C
    " / "
    VALUE
    0x8007342C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiSCGDebOk_C
    " / "
    VALUE
    0x8007342E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiSCGDebDef_C
    " / "
    VALUE
    0x80073430
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgUndrVltgDebOk_C
    " / "
    VALUE
    0x80073432
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgUndrVltgDebDef_C
    " / "
    VALUE
    0x80073434
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSRCMinDebOk_C
    " / "
    VALUE
    0x80073436
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSRCMinDebDef_C
    " / "
    VALUE
    0x80073438
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgOpnLdDebOk_C
    " / "
    VALUE
    0x8007343A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgOpnLdDebDef_C
    " / "
    VALUE
    0x8007343C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiOvrTempDebOk_C
    " / "
    VALUE
    0x8007343E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiOvrTempDebDef_C
    " / "
    VALUE
    0x80073440
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrMaxDebOk_C
    " / "
    VALUE
    0x80073442
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrMaxDebDef_C
    " / "
    VALUE
    0x80073444
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirOvrLdDebOk_C
    " / "
    VALUE
    0x80073446
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirOvrLdDebDef_C
    " / "
    VALUE
    0x80073448
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiO2MaxDebOk_C
    " / "
    VALUE
    0x8007344A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiO2MaxDebDef_C
    " / "
    VALUE
    0x8007344C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiOvrTempDebOk_C
    " / "
    VALUE
    0x8007344E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiOvrTempDebDef_C
    " / "
    VALUE
    0x80073450
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.TrbCh_tiSCGDebOk_C
    " / "
    VALUE
    0x80073452
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.TrbCh_tiSCGDebDef_C
    " / "
    VALUE
    0x80073454
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRCPmp_tiSCGDebOk_C
    " / "
    VALUE
    0x80073456
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRCPmp_tiSCGDebDef_C
    " / "
    VALUE
    0x80073458
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiOpnLdDebOk_C
    " / "
    VALUE
    0x8007345A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiOpnLdDebDef_C
    " / "
    VALUE
    0x8007345C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprOLDebOk_C
    " / "
    VALUE
    0x8007345E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprOLDebDef_C
    " / "
    VALUE
    0x80073460
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSSCGDebOk_C
    " / "
    VALUE
    0x80073462
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSSCGDebDef_C
    " / "
    VALUE
    0x80073464
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprRedTrqSCGDebOk_C
    " / "
    VALUE
    0x80073466
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprRedTrqSCGDebDef_C
    " / "
    VALUE
    0x80073468
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattUHiDebOk_C
    " / "
    VALUE
    0x8007346A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DevLib_tiBattUHiDebDef_C
    " / "
    VALUE
    0x8007346C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiDebDiaHiDebOk_C
    " / "
    VALUE
    0x8007346E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiDebDiaHiDebDef_C
    " / "
    VALUE
    0x80073470
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiSCBDebOk_C
    " / "
    VALUE
    0x80073472
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiSCBDebDef_C
    " / "
    VALUE
    0x80073474
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.FuelT_tiMaxDebOk_C
    " / "
    VALUE
    0x80073476
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.FuelT_tiMaxDebDef_C
    " / "
    VALUE
    0x80073478
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiDebDiaLoDebOk_C
    " / "
    VALUE
    0x8007347A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiDebDiaLoDebDef_C
    " / "
    VALUE
    0x8007347C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Air_tiSRCMinTEGRClrDsDebOk_C
    " / "
    VALUE
    0x8007347E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Air_tiSRCMinTEGRClrDsDebDef_C
    " / "
    VALUE
    0x80073480
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSSCBDebOk_C
    " / "
    VALUE
    0x80073482
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSSCBDebDef_C
    " / "
    VALUE
    0x80073484
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiOLDebOk_C
    " / "
    VALUE
    0x80073486
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiOLDebDef_C
    " / "
    VALUE
    0x80073488
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSRCMaxDebOk_C
    " / "
    VALUE
    0x8007348A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSRCMaxDebDef_C
    " / "
    VALUE
    0x8007348C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrMinDebOk_C
    " / "
    VALUE
    0x8007348E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiHtrMinDebDef_C
    " / "
    VALUE
    0x80073490
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCVlv_tiSCBDebOk_C
    " / "
    VALUE
    0x80073492
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCVlv_tiSCBDebDef_C
    " / "
    VALUE
    0x80073494
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgTempOvrCurrDebOk_C
    " / "
    VALUE
    0x80073496
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgTempOvrCurrDebDef_C
    " / "
    VALUE
    0x80073498
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiShCirDebOk_C
    " / "
    VALUE
    0x8007349A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiShCirDebDef_C
    " / "
    VALUE
    0x8007349C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRCPmp_tiSCBDebOk_C
    " / "
    VALUE
    0x8007349E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRCPmp_tiSCBDebDef_C
    " / "
    VALUE
    0x800734A0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt2DebOk_C
    " / "
    VALUE
    0x800734A2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt2DebDef_C
    " / "
    VALUE
    0x800734A4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiOTDebOk_C
    " / "
    VALUE
    0x800734A6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiOTDebDef_C
    " / "
    VALUE
    0x800734A8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSRCMaxDebOk_C
    " / "
    VALUE
    0x800734AA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSRCMaxDebDef_C
    " / "
    VALUE
    0x800734AC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgOvrTempDebOk_C
    " / "
    VALUE
    0x800734AE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgOvrTempDebDef_C
    " / "
    VALUE
    0x800734B0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiOffsDrftMaxDebOk_C
    " / "
    VALUE
    0x800734B2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiOffsDrftMaxDebDef_C
    " / "
    VALUE
    0x800734B4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSCBDebOk_C
    " / "
    VALUE
    0x800734B6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiSCBDebDef_C
    " / "
    VALUE
    0x800734B8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiOLDebOk_C
    " / "
    VALUE
    0x800734BA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ECBVlv_tiOLDebDef_C
    " / "
    VALUE
    0x800734BC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSOvrTempDebOk_C
    " / "
    VALUE
    0x800734BE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiLVSOvrTempDebDef_C
    " / "
    VALUE
    0x800734C0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgOvrCurrDebOk_C
    " / "
    VALUE
    0x800734C2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgOvrCurrDebDef_C
    " / "
    VALUE
    0x800734C4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiOvrTempDebOk_C
    " / "
    VALUE
    0x800734C6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiOvrTempDebDef_C
    " / "
    VALUE
    0x800734C8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiOLDebOk_C
    " / "
    VALUE
    0x800734CA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiOLDebDef_C
    " / "
    VALUE
    0x800734CC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiRawSRCMinDebOk_C
    " / "
    VALUE
    0x800734CE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiRawSRCMinDebDef_C
    " / "
    VALUE
    0x800734D0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiOffsDrftMinDebOk_C
    " / "
    VALUE
    0x800734D2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiOffsDrftMinDebDef_C
    " / "
    VALUE
    0x800734D4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Air_tiSRCMaxTEGRClrDsDebOk_C
    " / "
    VALUE
    0x800734D6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Air_tiSRCMaxTEGRClrDsDebDef_C
    " / "
    VALUE
    0x800734D8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiO2MinDebOk_C
    " / "
    VALUE
    0x800734DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiO2MinDebDef_C
    " / "
    VALUE
    0x800734DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRCPmp_tiOLDebOk_C
    " / "
    VALUE
    0x800734DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRCPmp_tiOLDebDef_C
    " / "
    VALUE
    0x800734E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt2DebOk_C
    " / "
    VALUE
    0x800734E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt2DebDef_C
    " / "
    VALUE
    0x800734E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt1DebOk_C
    " / "
    VALUE
    0x800734E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt1DebDef_C
    " / "
    VALUE
    0x800734E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd2DebOk_C
    " / "
    VALUE
    0x800734EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd2DebDef_C
    " / "
    VALUE
    0x800734EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiSCGDebOk_C
    " / "
    VALUE
    0x800734EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.WaHtEl_tiSCGDebDef_C
    " / "
    VALUE
    0x800734F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSCBDebOk_C
    " / "
    VALUE
    0x800734F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MeUn_tiSCBDebDef_C
    " / "
    VALUE
    0x800734F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd1DebOk_C
    " / "
    VALUE
    0x800734F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd1DebDef_C
    " / "
    VALUE
    0x800734F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprRedTrqSCBDebOk_C
    " / "
    VALUE
    0x800734FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprRedTrqSCBDebDef_C
    " / "
    VALUE
    0x800734FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCInj_tiOLDebOk_C
    " / "
    VALUE
    0x800734FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCInj_tiOLDebDef_C
    " / "
    VALUE
    0x80073500
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiCorSRCMinDebOk_C
    " / "
    VALUE
    0x80073502
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiCorSRCMinDebDef_C
    " / "
    VALUE
    0x80073504
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgOvrCurrDebOk_C
    " / "
    VALUE
    0x80073506
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgOvrCurrDebDef_C
    " / "
    VALUE
    0x80073508
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiOTDebOk_C
    " / "
    VALUE
    0x8007350A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_tiOTDebDef_C
    " / "
    VALUE
    0x8007350C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiCircPmpCurSigDebOk_C
    " / "
    VALUE
    0x8007350E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiCircPmpCurSigDebDef_C
    " / "
    VALUE
    0x80073510
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCVlv_tiOLDebOk_C
    " / "
    VALUE
    0x80073512
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCVlv_tiOLDebDef_C
    " / "
    VALUE
    0x80073514
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiRawSRCMaxDebOk_C
    " / "
    VALUE
    0x80073516
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AFS_tiRawSRCMaxDebDef_C
    " / "
    VALUE
    0x80073518
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiSCGDebOk_C
    " / "
    VALUE
    0x8007351A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiSCGDebDef_C
    " / "
    VALUE
    0x8007351C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCVlv_tiSCGDebOk_C
    " / "
    VALUE
    0x8007351E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.HCVlv_tiSCGDebDef_C
    " / "
    VALUE
    0x80073520
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiSCBDebOk_C
    " / "
    VALUE
    0x80073522
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.GlwPlg_tiSCBDebDef_C
    " / "
    VALUE
    0x80073524
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DSMTst_ExampleDebOk_C
    " / "
    VALUE
    0x80073526
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.DSMTst_ExampleDebDef_C
    " / "
    VALUE
    0x80073528
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_titExcMinDebOk_C
    " / "
    VALUE
    0x8007352A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_titExcMinDebDef_C
    " / "
    VALUE
    0x8007352C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiSPIBattLowMinDebOk_C
    " / "
    VALUE
    0x8007352E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_tiSPIBattLowMinDebDef_C
    " / "
    VALUE
    0x80073530
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprSCGDebOk_C
    " / "
    VALUE
    0x80073532
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.AirC_tiCmprSCGDebDef_C
    " / "
    VALUE
    0x80073534
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgOpnLdDebOk_C
    " / "
    VALUE
    0x80073536
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ThrVlv_tiHBrgOpnLdDebDef_C
    " / "
    VALUE
    0x80073538
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.TrbCh_tiSCBDebOk_C
    " / "
    VALUE
    0x8007353A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.TrbCh_tiSCBDebDef_C
    " / "
    VALUE
    0x8007353C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.RailP_tiSRCMaxDebOk_C
    " / "
    VALUE
    0x8007353E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.RailP_tiSRCMaxDebDef_C
    " / "
    VALUE
    0x80073540
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numEnrgMaxDebOk_C
    " / "
    VALUE
    0x80073542
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numEnrgMaxDebDef_C
    " / "
    VALUE
    0x80073544
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.RailP_numdpDebOk_C
    " / "
    VALUE
    0x80073546
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.RailP_numdpDebDef_C
    " / "
    VALUE
    0x80073548
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylShCirMeasDebOk_C
    " / "
    VALUE
    0x8007354A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylShCirMeasDebDef_C
    " / "
    VALUE
    0x8007354C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numPresCompMinDebOk_C
    " / "
    VALUE
    0x8007354E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numPresCompMinDebDef_C
    " / "
    VALUE
    0x80073550
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numEnrgMinDebOk_C
    " / "
    VALUE
    0x80073552
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numEnrgMinDebDef_C
    " / "
    VALUE
    0x80073554
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVPSply_numStopDCDCDebOk_C
    " / "
    VALUE
    0x80073556
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVPSply_numStopDCDCDebDef_C
    " / "
    VALUE
    0x80073558
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2ClbMaxDebOk_C
    " / "
    VALUE
    0x8007355A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2ClbMaxDebDef_C
    " / "
    VALUE
    0x8007355C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylNoLdDebOk_C
    " / "
    VALUE
    0x8007355E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylNoLdDebDef_C
    " / "
    VALUE
    0x80073560
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numTempCompMaxDebOk_C
    " / "
    VALUE
    0x80073562
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numTempCompMaxDebDef_C
    " / "
    VALUE
    0x80073564
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numVltgSRCMinDebOk_C
    " / "
    VALUE
    0x80073566
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numVltgSRCMinDebDef_C
    " / "
    VALUE
    0x80073568
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numDynChkMinDebOk_C
    " / "
    VALUE
    0x8007356A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numDynChkMinDebDef_C
    " / "
    VALUE
    0x8007356C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numEnrgNplDebOk_C
    " / "
    VALUE
    0x8007356E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numEnrgNplDebDef_C
    " / "
    VALUE
    0x80073570
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMaxFLdDebOk_C
    " / "
    VALUE
    0x80073572
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMaxFLdDebDef_C
    " / "
    VALUE
    0x80073574
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMinPartLdDebOk_C
    " / "
    VALUE
    0x80073576
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMinPartLdDebDef_C
    " / "
    VALUE
    0x80073578
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2ClbMinDebOk_C
    " / "
    VALUE
    0x8007357A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2ClbMinDebDef_C
    " / "
    VALUE
    0x8007357C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numRiClbMinDebOk_C
    " / "
    VALUE
    0x8007357E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numRiClbMinDebDef_C
    " / "
    VALUE
    0x80073580
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylShCirDebOk_C
    " / "
    VALUE
    0x80073582
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylShCirDebDef_C
    " / "
    VALUE
    0x80073584
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numBnkShCirDebOk_C
    " / "
    VALUE
    0x80073586
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numBnkShCirDebDef_C
    " / "
    VALUE
    0x80073588
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVCtl_numTiDiffOBDDebOk_C
    " / "
    VALUE
    0x8007358A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVCtl_numTiDiffOBDDebDef_C
    " / "
    VALUE
    0x8007358C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numUChSRCMaxDebOk_C
    " / "
    VALUE
    0x8007358E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numUChSRCMaxDebDef_C
    " / "
    VALUE
    0x80073590
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMaxPartLdDebOk_C
    " / "
    VALUE
    0x80073592
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMaxPartLdDebDef_C
    " / "
    VALUE
    0x80073594
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVCtl_numUUpOBDDebOk_C
    " / "
    VALUE
    0x80073596
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVCtl_numUUpOBDDebDef_C
    " / "
    VALUE
    0x80073598
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numTempCompMinDebOk_C
    " / "
    VALUE
    0x8007359A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numTempCompMinDebDef_C
    " / "
    VALUE
    0x8007359C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylNoClsDebOk_C
    " / "
    VALUE
    0x8007359E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylNoClsDebDef_C
    " / "
    VALUE
    0x800735A0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numPresCompMaxDebOk_C
    " / "
    VALUE
    0x800735A2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numPresCompMaxDebDef_C
    " / "
    VALUE
    0x800735A4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numVltgSRCMaxDebOk_C
    " / "
    VALUE
    0x800735A6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numVltgSRCMaxDebDef_C
    " / "
    VALUE
    0x800735A8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMaxOvrRunDebOk_C
    " / "
    VALUE
    0x800735AA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMaxOvrRunDebDef_C
    " / "
    VALUE
    0x800735AC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numWireIPSigDebOk_C
    " / "
    VALUE
    0x800735AE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numWireIPSigDebDef_C
    " / "
    VALUE
    0x800735B0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylShCirHSLSDebOk_C
    " / "
    VALUE
    0x800735B2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numCylShCirHSLSDebDef_C
    " / "
    VALUE
    0x800735B4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numDynChkDIUMPRMinDebOk_C
    " / "
    VALUE
    0x800735B6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numDynChkDIUMPRMinDebDef_C
    " / "
    VALUE
    0x800735B8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_numNoStrtDebOk_C
    " / "
    VALUE
    0x800735BA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.PCV_numNoStrtDebDef_C
    " / "
    VALUE
    0x800735BC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numUChSRCMinDebOk_C
    " / "
    VALUE
    0x800735BE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVActr_numUChSRCMinDebDef_C
    " / "
    VALUE
    0x800735C0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMinFLdDebOk_C
    " / "
    VALUE
    0x800735C2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMinFLdDebDef_C
    " / "
    VALUE
    0x800735C4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numBnkShCirChSwtDebOk_C
    " / "
    VALUE
    0x800735C6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numBnkShCirChSwtDebDef_C
    " / "
    VALUE
    0x800735C8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMinOvrRunDebOk_C
    " / "
    VALUE
    0x800735CA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numO2PlausMinOvrRunDebDef_C
    " / "
    VALUE
    0x800735CC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numRiClbMaxDebOk_C
    " / "
    VALUE
    0x800735CE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numRiClbMaxDebDef_C
    " / "
    VALUE
    0x800735D0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVCtl_numUDiffUpOBDDebOk_C
    " / "
    VALUE
    0x800735D2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVCtl_numUDiffUpOBDDebDef_C
    " / "
    VALUE
    0x800735D4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numChpDebOk_C
    " / "
    VALUE
    0x800735D6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.IVDia_numChpDebDef_C
    " / "
    VALUE
    0x800735D8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn2DebOk_C
    " / "
    VALUE
    0x800735DA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn2DebDef_C
    " / "
    VALUE
    0x800735DC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn4DebOk_C
    " / "
    VALUE
    0x800735DE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn4DebDef_C
    " / "
    VALUE
    0x800735E0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.R2S2_tiCommErrorDebOk_C
    " / "
    VALUE
    0x800735E2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.R2S2_tiCommErrorDebDef_C
    " / "
    VALUE
    0x800735E4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn0DebOk_C
    " / "
    VALUE
    0x800735E6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn0DebDef_C
    " / "
    VALUE
    0x800735E8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MonUMaxSupply1DebOk_C
    " / "
    VALUE
    0x800735EA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MonUMaxSupply1DebDef_C
    " / "
    VALUE
    0x800735EC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.SSpMon2DebOk_C
    " / "
    VALUE
    0x800735EE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.SSpMon2DebDef_C
    " / "
    VALUE
    0x800735F0
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn3DebOk_C
    " / "
    VALUE
    0x800735F2
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn3DebDef_C
    " / "
    VALUE
    0x800735F4
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV4DebOk_C
    " / "
    VALUE
    0x800735F6
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV4DebDef_C
    " / "
    VALUE
    0x800735F8
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.SSpMon3DebOk_C
    " / "
    VALUE
    0x800735FA
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.SSpMon3DebDef_C
    " / "
    VALUE
    0x800735FC
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV1DebOk_C
    " / "
    VALUE
    0x800735FE
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV1DebDef_C
    " / "
    VALUE
    0x80073600
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn1DebOk_C
    " / "
    VALUE
    0x80073602
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiMeUn1DebDef_C
    " / "
    VALUE
    0x80073604
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.CY320_tiSpiCommErrorDebOk_C
    " / "
    VALUE
    0x80073606
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.CY320_tiSpiCommErrorDebDef_C
    " / "
    VALUE
    0x80073608
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV3DebOk_C
    " / "
    VALUE
    0x8007360A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV3DebDef_C
    " / "
    VALUE
    0x8007360C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiCPC4DebOk_C
    " / "
    VALUE
    0x8007360E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiCPC4DebDef_C
    " / "
    VALUE
    0x80073610
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV2DebOk_C
    " / "
    VALUE
    0x80073612
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV2DebDef_C
    " / "
    VALUE
    0x80073614
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiCPC3DebOk_C
    " / "
    VALUE
    0x80073616
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiCPC3DebDef_C
    " / "
    VALUE
    0x80073618
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.SSpMon1DebOk_C
    " / "
    VALUE
    0x8007361A
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.SSpMon1DebDef_C
    " / "
    VALUE
    0x8007361C
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV0DebOk_C
    " / "
    VALUE
    0x8007361E
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiPCV0DebDef_C
    " / "
    VALUE
    0x80073620
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MonUMinSupply1DebOk_C
    " / "
    VALUE
    0x80073622
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.MonUMinSupply1DebDef_C
    " / "
    VALUE
    0x80073624
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiCPC1DebOk_C
    " / "
    VALUE
    0x80073626
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.Rail_tiCPC1DebDef_C
    " / "
    VALUE
    0x80073628
    Val_Wu16
    655350.0
    DDRCTime_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ETClb_numETFltMinDebOk_C
    " / "
    VALUE
    0x8007362A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ETClb_numETFltMinDebDef_C
    " / "
    VALUE
    0x8007362C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ETClb_numETFltMaxDebOk_C
    " / "
    VALUE
    0x8007362E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.ETClb_numETFltMaxDebDef_C
    " / "
    VALUE
    0x80073630
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numHtCoupSigDebOk_C
    " / "
    VALUE
    0x80073632
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DDRC_DurDeb.LSU_numHtCoupSigDebDef_C
    " / "
    VALUE
    0x80073634
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_DigOutDbgSig_C
    ""
    VALUE
    0x8006C344
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_nActrRls_C
    "The minimum engine speed for the actuator release"
    VALUE
    0x8006C340
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facLowHysLo_C
    "Structure for hysterisis check on battery voltage correction factor / Lower hysterisis limit for battery correction factor LOW."
    VALUE
    0x8006C348
    Kw_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facLowHysHi_C
    "Structure for hysterisis check on battery voltage correction factor / Higher hysterisis limit for battery correction factor LOW."
    VALUE
    0x8006C34A
    Kw_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facHighHysLo_C
    "Structure for hysterisis check on battery voltage correction factor / Lower hysterisis limit for battery correction factor HIGH."
    VALUE
    0x8006C34C
    Kw_Ws16
    2.000000
    Fact
    1.000000
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PsDisbl.facHighHysHi_C
    "Structure for hysterisis check on battery voltage correction factor / Higher hysterisis limit for battery correction factor HIGH."
    VALUE
    0x8006C34E
    Kw_Ws16
    2.000000
    Fact
    1.000000
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_PWMOutDbgSig_C
    ""
    VALUE
    0x8006C346
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattLoHysLo_C
    "Parameter structure containing hysterisis check limits for battery voltage check / Lower limit for battery voltage LOW hysterisis check."
    VALUE
    0x8006C350
    Kw_Ws16
    9000.000
    Volt_Batt
    3000.000
    12000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattLoHysHi_C
    "Parameter structure containing hysterisis check limits for battery voltage check / Higher limit for battery voltage LOW hysterisis check"
    VALUE
    0x8006C352
    Kw_Ws16
    9000.000
    Volt_Batt
    3000.000
    12000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattHiHysLo_C
    "Parameter structure containing hysterisis check limits for battery voltage check / Lower limit for battery voltage HIGH hysterisis check"
    VALUE
    0x8006C354
    Kw_Ws16
    24000.00
    Volt_Batt
    12000.00
    36000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Devlib_PwrStg.BattHiHysHi_C
    "Parameter structure containing hysterisis check limits for battery voltage check / Upper limit for battery voltage HIGH hysterisis check"
    VALUE
    0x8006C356
    Kw_Ws16
    24000.00
    Volt_Batt
    12000.00
    36000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DevLib_tiActrPrt_C
    "Actuator protection time"
    VALUE
    0x8006C342
    Val_Ws16
    2000.000
    Time_ms
    0.00
    2000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_cpGs_C
    "Specific thermal capacity of exhaust gas"
    VALUE
    0x8006C358
    Val_Ws16
    2.000000
    SpecificHeat
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -3.276800 3.276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_dmPlsThresLSUSrvTst_CA
    "Minimum mass flow for valid gas pulse in service test mode"
    VAL_BLK
    0x8006C35A
    ValA_Ws16
    1000.000
    AirMassPerTime
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_dmPlsThresLSU_CA
    "Minimum mass flow for valid gas pulse in normal mode"
    VAL_BLK
    0x8006C35C
    ValA_Ws16
    1000.000
    AirMassPerTime
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_facCldStrtLSU0_CUR
    "Characteristic kurve for determination of factor for threshold value increase in case of repeated cold start for sensor 0"
    CURVE
    0x8006C35E
    Cur_Xs16Ws16
    3.989990
    Fact
    0.00
    3.989990

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        DewDet_tPipeMinIdx_mp
        Temp_Cels
        4
        -60.04000
        59.96000

        FORMAT "%8.5"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_facPlsLSUSrvTst_CA
    "Factor for decrease of the heat threshold value for valid gas pulse in service test mode"
    VAL_BLK
    0x8006C370
    ValA_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_facPlsLSU_CA
    "Factor for decrease of the heat threshold value for valid gas pulse in normal mode"
    VAL_BLK
    0x8006C372
    ValA_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_facPlsThresLSU_CA
    "Factor to determine a minimum heat threshold value for activation of gas pulse detection"
    VAL_BLK
    0x8006C374
    ValA_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_facThresNoSftyFac_CA
    "Factor to decrease threshold value in service test mode"
    VAL_BLK
    0x8006C376
    ValA_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_numEngTempStrt_C
    "Application parameter for selecting temperature from Engine temperature Field EngDa_tFld"
    VALUE
    0x8006C378
    Val_Wu8
    2.00000000000
    EngTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_numLSU_CA
    "Application parameter field for selecting exhaust gas and wall temperature from temperature fields ASMod_tEGFld and ASMod_tWallFld"
    VAL_BLK
    0x8006C379
    ValA_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_numMaxCldStrt_CA
    "Maximum number of cold starts to be counted"
    VAL_BLK
    0x8006C37A
    ValA_Wu8
    10.00
    OneToOne
    0.00
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_numPipeIdx1_CA
    "the number of pipe from ASMod_TempStrtCalc Model"
    VAL_BLK
    0x8006C37B
    ValA_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_numPipeIdx2_CA
    "the number of pipe from ASMod_TempStrtCalc-Model"
    VAL_BLK
    0x8006C37C
    ValA_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_numPlsSrvTst_CA
    "number of gas pulses for shortened time of heating activation"
    VAL_BLK
    0x8006C37D
    ValA_Wu8
    10.00
    OneToOne
    0.00
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_swtDewDetShOff_CA
    "switch to release the dew point detection shut off"
    VAL_BLK
    0x8006C37E
    ValA_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tiDebLSU_CA
    "Debounce time for enable lambda sensor heating 0"
    VAL_BLK
    0x8006C380
    ValA_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tiDebRunTransOk_C
    "Debounce time after Start until input-temperatures are valid"
    VALUE
    0x8006C382
    Val_Ws16
    1000.000
    TimeDeb
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tiHtgDelLSU_CA
    "Delay of heating release in the event of an error"
    VAL_BLK
    0x8006C384
    ValA_Ws32
    600.000000000
    Time_s
    0.00
    600.000000000

    FORMAT "%13.9"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tIntegIniSrvTst_CA
    "Temperature threshold value for the heat quantity integrator activation in normal mode"
    VAL_BLK
    0x8006C388
    ValA_Ws16
    100.0000
    Temp_Cels
    -0.04000000
    99.96000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tIntegIni_CA
    "Temperature threshold value for the heat quantity integrator activation in normal mode"
    VAL_BLK
    0x8006C38A
    ValA_Ws16
    100.0000
    Temp_Cels
    -0.04000000
    99.96000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tiPlsLSUSrvTst_CA
    "Minimum duration for valid gas pulse in service test mode"
    VAL_BLK
    0x8006C38C
    ValA_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tiPlsLSU_CA
    "Minimum duration for valid gas pulse in normal mode"
    VAL_BLK
    0x8006C38E
    ValA_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tThresLSUActSrvTst_CA
    "Temperature threshold value for LSU sensor heating activation in normal mode"
    VAL_BLK
    0x8006C390
    ValA_Ws16
    100.0000
    Temp_Cels
    -0.04000000
    99.96000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tThresLSUAct_CA
    "temperature threshold value for LSU sensor heating activation in normal mode"
    VAL_BLK
    0x8006C392
    ValA_Ws16
    100.0000
    Temp_Cels
    -0.04000000
    99.96000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_tWtEquiv_CA
    "equivalent water temperatur at evaporation"
    VAL_BLK
    0x8006C394
    ValA_Ws16
    1095.000
    Temp_Cels
    -45.04000
    1049.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_wLSUIKi_CA
    "I-governor gain"
    VAL_BLK
    0x8006C396
    ValA_Ws16
    5.000000
    OneToOne
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DewDet_wThresLSU0_MAP
    "Basic heat thresholds map lambda sensor 0"
    MAP
    0x8006C398
    Map_Xs16Ys16Ws16
    6000.000
    Energy
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        DewDet_tWallLSUInpCrv0_mp
        Temp_Cels
        10
        -45.04000
        1049.960

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        DewDet_tEngStrt_mp
        Temp_Cels
        10
        -45.04000
        1049.960

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dMRP_CA
    " / "
    VAL_BLK
    0x8007363A
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dDIC_CA
    " / "
    VAL_BLK
    0x8007363F
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dSuppITG_CA
    " / "
    VAL_BLK
    0x80073640
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dHWNo_CA
    " / "
    VAL_BLK
    0x80073643
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 5

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dSWNo_CA
    " / "
    VAL_BLK
    0x80073648
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dEdNo_CA
    " / "
    VAL_BLK
    0x8007364A
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dCalNo_CA
    " / "
    VAL_BLK
    0x8007364C
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_ECUId.dOthSys_CA
    " / "
    VAL_BLK
    0x8007364E
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_tPrgThres_C
    ""
    VALUE
    0x80073636
    Val_Wu16
    240.0000
    Temp_Cels
    -40.04000
    199.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -273.1400 6280.360
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DiagApplInf_vPrgThres_C
    ""
    VALUE
    0x80073638
    Val_Ws16
    655.3500
    Speed_km_h_001_RSA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Diag_stOBDPtcol_C
    "to select OBD protocol"
    VALUE
    0x8006C4C0
    Val_Wu8
    3.00000000000
    Diag_OBDPtcol_Val
    0.00
    3.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 3.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InhibitAlways_CA
    " / "
    VAL_BLK
    0x80073652
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoordALS_CA
    " / "
    VAL_BLK
    0x8007365A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoordFBC_CA
    " / "
    VAL_BLK
    0x80073662
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoordTAA_CA
    " / "
    VAL_BLK
    0x8007366A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoordZFC_CA
    " / "
    VAL_BLK
    0x80073672
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVPlausRunUpTstActv_CA
    " / "
    VAL_BLK
    0x8007367A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailHpTstActv_CA
    " / "
    VAL_BLK
    0x80073682
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_AFSPlOffsDrft_CA
    " / "
    VAL_BLK
    0x8007368A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_AFSSRC_CA
    " / "
    VAL_BLK
    0x80073692
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_AFSTPer_CA
    " / "
    VAL_BLK
    0x8007369A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_APP1SigPath_CA
    " / "
    VAL_BLK
    0x800736A2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_APP2SigPath_CA
    " / "
    VAL_BLK
    0x800736AA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ASModPipe_CA
    " / "
    VAL_BLK
    0x800736B2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ASModPipeSlw_CA
    " / "
    VAL_BLK
    0x800736BA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ASModPresCalc_CA
    " / "
    VAL_BLK
    0x800736C2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ASModStrt_CA
    " / "
    VAL_BLK
    0x800736CA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ASModSwtOffEng_CA
    " / "
    VAL_BLK
    0x800736D2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ASModTrbn_CA
    " / "
    VAL_BLK
    0x800736DA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_AdcIADC0_CA
    " / "
    VAL_BLK
    0x800736E2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_Cic751Dev1_CA
    " / "
    VAL_BLK
    0x800736EA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngNrml2Strt_CA
    " / "
    VAL_BLK
    0x800736F2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthClsEGR_CA
    " / "
    VAL_BLK
    0x800736FA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthClsThr_CA
    " / "
    VAL_BLK
    0x80073702
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthCylOff_CA
    " / "
    VAL_BLK
    0x8007370A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthETZr_CA
    " / "
    VAL_BLK
    0x80073712
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthFlQnt_CA
    " / "
    VAL_BLK
    0x8007371A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthInjVlvOff_CA
    " / "
    VAL_BLK
    0x80073722
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthLpSysOff_CA
    " / "
    VAL_BLK
    0x8007372A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthRPMin_CA
    " / "
    VAL_BLK
    0x80073732
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngPthTrqZr_CA
    " / "
    VAL_BLK
    0x8007373A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_CoEngSoftShOff_CA
    " / "
    VAL_BLK
    0x80073742
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_DevLibActrPrt_CA
    " / "
    VAL_BLK
    0x8007374A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_DewDetHtgDel_CA
    " / "
    VAL_BLK
    0x80073752
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_DewDetstSrvTstDem_CA
    " / "
    VAL_BLK
    0x8007375A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EGRVlvJamVlv_CA
    " / "
    VAL_BLK
    0x80073762
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ETClbCorActv_CA
    " / "
    VAL_BLK
    0x8007376A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmBCr_CA
    " / "
    VAL_BLK
    0x80073772
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmCaSAdapCaSI1_CA
    " / "
    VAL_BLK
    0x8007377A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmCaSDiag_CA
    " / "
    VAL_BLK
    0x80073782
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmCaSOfsDiagCaSI1_CA
    " / "
    VAL_BLK
    0x8007378A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmCaSOfsErrCaSI1_CA
    " / "
    VAL_BLK
    0x80073792
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmCaSSegCor_CA
    " / "
    VAL_BLK
    0x8007379A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmCrSDiag_CA
    " / "
    VAL_BLK
    0x800737A2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmCrSDiagVeh_CA
    " / "
    VAL_BLK
    0x800737AA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_EpmOpMode_InjLock_CA
    " / "
    VAL_BLK
    0x800737B2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FBC_CA
    " / "
    VAL_BLK
    0x800737BA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FMALamO2Valid_CA
    " / "
    VAL_BLK
    0x800737C2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FMASwtOff1_CA
    " / "
    VAL_BLK
    0x800737CA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FMASwtOff3_CA
    " / "
    VAL_BLK
    0x800737D2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FlSysDens_CA
    " / "
    VAL_BLK
    0x800737DA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FlSysTnkLoEEP_CA
    " / "
    VAL_BLK
    0x800737E2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FlSysTnkLoInfo_CA
    " / "
    VAL_BLK
    0x800737EA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FuelTCTS_CA
    " / "
    VAL_BLK
    0x800737F2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FuelTFlSys_CA
    " / "
    VAL_BLK
    0x800737FA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FuelTFrzVal_CA
    " / "
    VAL_BLK
    0x80073802
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FuelTFrzValB1_CA
    " / "
    VAL_BLK
    0x8007380A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_FuelTReplVal_CA
    " / "
    VAL_BLK
    0x80073812
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_GlwCtl1_CA
    " / "
    VAL_BLK
    0x8007381A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_GlwCtl2_CA
    " / "
    VAL_BLK
    0x80073822
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_GlwCtl3_CA
    " / "
    VAL_BLK
    0x8007382A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_GlwPlgCod_CA
    " / "
    VAL_BLK
    0x80073832
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_GlwPlgGCUTDia_CA
    " / "
    VAL_BLK
    0x8007383A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVActrTempRplVal_CA
    " / "
    VAL_BLK
    0x80073842
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVAdjNVCEna_CA
    " / "
    VAL_BLK
    0x8007384A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVDiaCylOKTst_CA
    " / "
    VAL_BLK
    0x80073852
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVDiaTst_CA
    " / "
    VAL_BLK
    0x8007385A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVPSplyDCDCOff_CA
    " / "
    VAL_BLK
    0x80073862
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVPlausComprTst_CA
    " / "
    VAL_BLK
    0x8007386A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_IVPlausRunUpTst_CA
    " / "
    VAL_BLK
    0x80073872
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InhibitNever_CA
    " / "
    VAL_BLK
    0x8007387A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjUnStrtPlsBlk_CA
    " / "
    VAL_BLK
    0x80073882
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvBnk0ShutOff_CA
    " / "
    VAL_BLK
    0x8007388A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvCyl0ShutOff_CA
    " / "
    VAL_BLK
    0x80073892
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvCyl1ShutOff_CA
    " / "
    VAL_BLK
    0x8007389A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvCyl2ShutOff_CA
    " / "
    VAL_BLK
    0x800738A2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvCyl3ShutOff_CA
    " / "
    VAL_BLK
    0x800738AA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvCyl4ShutOff_CA
    " / "
    VAL_BLK
    0x800738B2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvCyl5ShutOff_CA
    " / "
    VAL_BLK
    0x800738BA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvPrep_CA
    " / "
    VAL_BLK
    0x800738C2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvPresMin_CA
    " / "
    VAL_BLK
    0x800738CA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvPresMinRun_CA
    " / "
    VAL_BLK
    0x800738D2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_InjVlvPresMinStrt_CA
    " / "
    VAL_BLK
    0x800738DA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUAdap0_CA
    " / "
    VAL_BLK
    0x800738E2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUClbSched_CA
    " / "
    VAL_BLK
    0x800738EA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUCmpChk0_CA
    " / "
    VAL_BLK
    0x800738F2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUCtl0_CA
    " / "
    VAL_BLK
    0x800738FA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUDewRls0_CA
    " / "
    VAL_BLK
    0x80073902
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUDynChk0_CA
    " / "
    VAL_BLK
    0x8007390A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUHtCoup0_CA
    " / "
    VAL_BLK
    0x80073912
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUHtrPS0_CA
    " / "
    VAL_BLK
    0x8007391A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUIPOpnLdTst0_CA
    " / "
    VAL_BLK
    0x80073922
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUIsolChk0_CA
    " / "
    VAL_BLK
    0x8007392A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSULoBatt0_CA
    " / "
    VAL_BLK
    0x80073932
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUMon0_CA
    " / "
    VAL_BLK
    0x8007393A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUO20_CA
    " / "
    VAL_BLK
    0x80073942
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUO2Clb0_CA
    " / "
    VAL_BLK
    0x8007394A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUO2SRC0_CA
    " / "
    VAL_BLK
    0x80073952
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUPlausChk0_CA
    " / "
    VAL_BLK
    0x8007395A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUPresComp0_CA
    " / "
    VAL_BLK
    0x80073962
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUPresCompAdap0_CA
    " / "
    VAL_BLK
    0x8007396A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSURi0_CA
    " / "
    VAL_BLK
    0x80073972
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSURiClb0_CA
    " / "
    VAL_BLK
    0x8007397A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUShCir0_CA
    " / "
    VAL_BLK
    0x80073982
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUUNVGOpnLdTst0_CA
    " / "
    VAL_BLK
    0x8007398A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_LSUlsu0_CA
    " / "
    VAL_BLK
    0x80073992
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_MeUnActrTst_CA
    " / "
    VAL_BLK
    0x8007399A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_MeUnFrzI_CA
    " / "
    VAL_BLK
    0x800739A2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_MeUnRot_CA
    " / "
    VAL_BLK
    0x800739AA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_MeUnSetPTst_CA
    " / "
    VAL_BLK
    0x800739B2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_PCVActrTst_CA
    " / "
    VAL_BLK
    0x800739BA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_PCVFrzI_CA
    " / "
    VAL_BLK
    0x800739C2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_PCVNoStrt_CA
    " / "
    VAL_BLK
    0x800739CA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_PCVPwrStgTst_CA
    " / "
    VAL_BLK
    0x800739D2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_PCVSetPTst_CA
    " / "
    VAL_BLK
    0x800739DA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_QWCCTSDef_CA
    " / "
    VAL_BLK
    0x800739E2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_QWCFTSDef_CA
    " / "
    VAL_BLK
    0x800739EA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_QWCOff_CA
    " / "
    VAL_BLK
    0x800739F2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailCPCtlMeUnMode_CA
    " / "
    VAL_BLK
    0x800739FA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailCPCtlPCVMode_CA
    " / "
    VAL_BLK
    0x80073A02
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailCtlMode_CA
    " / "
    VAL_BLK
    0x80073A0A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailHpTst_CA
    " / "
    VAL_BLK
    0x80073A12
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn0Blk_CA
    " / "
    VAL_BLK
    0x80073A1A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn0Rls_CA
    " / "
    VAL_BLK
    0x80073A22
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn1Blk_CA
    " / "
    VAL_BLK
    0x80073A2A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn1Rls_CA
    " / "
    VAL_BLK
    0x80073A32
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn22Rls_CA
    " / "
    VAL_BLK
    0x80073A3A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn2Blk_CA
    " / "
    VAL_BLK
    0x80073A42
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn2Rls_CA
    " / "
    VAL_BLK
    0x80073A4A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn3Blk_CA
    " / "
    VAL_BLK
    0x80073A52
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn3Rls_CA
    " / "
    VAL_BLK
    0x80073A5A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn4Blk_CA
    " / "
    VAL_BLK
    0x80073A62
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUn4Rls_CA
    " / "
    VAL_BLK
    0x80073A6A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUnClsdShutOff_CA
    " / "
    VAL_BLK
    0x80073A72
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUnCtlMode_CA
    " / "
    VAL_BLK
    0x80073A7A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailMeUnCtlUpLim_CA
    " / "
    VAL_BLK
    0x80073A82
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV0Blk_CA
    " / "
    VAL_BLK
    0x80073A8A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV0Rls_CA
    " / "
    VAL_BLK
    0x80073A92
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV1Blk_CA
    " / "
    VAL_BLK
    0x80073A9A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV1Rls_CA
    " / "
    VAL_BLK
    0x80073AA2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV2Blk_CA
    " / "
    VAL_BLK
    0x80073AAA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV2Rls_CA
    " / "
    VAL_BLK
    0x80073AB2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV3Blk_CA
    " / "
    VAL_BLK
    0x80073ABA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV3Rls_CA
    " / "
    VAL_BLK
    0x80073AC2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV4Blk_CA
    " / "
    VAL_BLK
    0x80073ACA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCV4Rls_CA
    " / "
    VAL_BLK
    0x80073AD2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCVCtlMode_CA
    " / "
    VAL_BLK
    0x80073ADA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPCVCtlUpLim_CA
    " / "
    VAL_BLK
    0x80073AE2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPSS_CA
    " / "
    VAL_BLK
    0x80073AEA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailPSubsVal_CA
    " / "
    VAL_BLK
    0x80073AF2
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailSetPointLim_CA
    " / "
    VAL_BLK
    0x80073AFA
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailSetPointRed_CA
    " / "
    VAL_BLK
    0x80073B02
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailSetPointTst_CA
    " / "
    VAL_BLK
    0x80073B0A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_RailTnkLo_CA
    " / "
    VAL_BLK
    0x80073B12
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_SSTEGRClrDs_CA
    " / "
    VAL_BLK
    0x80073B1A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_TAA_CA
    " / "
    VAL_BLK
    0x80073B22
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_TEGRClrDsFrzVal_CA
    " / "
    VAL_BLK
    0x80073B2A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_TEGRClrDsRplVal_CA
    " / "
    VAL_BLK
    0x80073B32
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ThrVlvOpnLd_CA
    " / "
    VAL_BLK
    0x80073B3A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_TrbChPmp_CA
    " / "
    VAL_BLK
    0x80073B42
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ZFCClbActv_CA
    " / "
    VAL_BLK
    0x80073B4A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ZFCCldCmbCham_CA
    " / "
    VAL_BLK
    0x80073B52
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_ZFCPCLClbActv_CA
    " / "
    VAL_BLK
    0x80073B5A
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_DSQ.FId_stAVSCoESLSU_CA
    " / "
    VAL_BLK
    0x80073B62
    ValA_Wu16
    339.
    DINH_DSQVerb
    0.00
    339.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 339.
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InhibitAlways_CA
    " / "
    VAL_BLK
    0x80073B6A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoordALS_CA
    " / "
    VAL_BLK
    0x80073B76
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoordFBC_CA
    " / "
    VAL_BLK
    0x80073B82
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoordTAA_CA
    " / "
    VAL_BLK
    0x80073B98
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoordZFC_CA
    " / "
    VAL_BLK
    0x80073BA4
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVPlausRunUpTstActv_CA
    " / "
    VAL_BLK
    0x80073BB0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailHpTstActv_CA
    " / "
    VAL_BLK
    0x80073BBC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_AFSPlOffsDrft_CA
    " / "
    VAL_BLK
    0x80073BC8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_AFSSRC_CA
    " / "
    VAL_BLK
    0x80073BD4
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_AFSTPer_CA
    " / "
    VAL_BLK
    0x80073BE0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_APP1SigPath_CA
    " / "
    VAL_BLK
    0x80073BEC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_APP2SigPath_CA
    " / "
    VAL_BLK
    0x80073BF8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ASModPipe_CA
    " / "
    VAL_BLK
    0x80073C04
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ASModPipeSlw_CA
    " / "
    VAL_BLK
    0x80073C10
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ASModPresCalc_CA
    " / "
    VAL_BLK
    0x80073C1C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ASModStrt_CA
    " / "
    VAL_BLK
    0x80073C28
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ASModSwtOffEng_CA
    " / "
    VAL_BLK
    0x80073C3A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ASModTrbn_CA
    " / "
    VAL_BLK
    0x80073C46
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_AdcIADC0_CA
    " / "
    VAL_BLK
    0x80073C54
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_Cic751Dev1_CA
    " / "
    VAL_BLK
    0x80073C60
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngNrml2Strt_CA
    " / "
    VAL_BLK
    0x80073C6C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthClsEGR_CA
    " / "
    VAL_BLK
    0x80073C78
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthClsThr_CA
    " / "
    VAL_BLK
    0x80073C84
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthCylOff_CA
    " / "
    VAL_BLK
    0x80073C90
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthETZr_CA
    " / "
    VAL_BLK
    0x80073C9C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 21

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthFlQnt_CA
    " / "
    VAL_BLK
    0x80073CC6
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 21

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthInjVlvOff_CA
    " / "
    VAL_BLK
    0x80073CF0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 21

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthLpSysOff_CA
    " / "
    VAL_BLK
    0x80073D1A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthRPMin_CA
    " / "
    VAL_BLK
    0x80073D30
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 21

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngPthTrqZr_CA
    " / "
    VAL_BLK
    0x80073D5A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 21

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_CoEngSoftShOff_CA
    " / "
    VAL_BLK
    0x80073D84
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_DevLibActrPrt_CA
    " / "
    VAL_BLK
    0x80073D90
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_DewDetHtgDel_CA
    " / "
    VAL_BLK
    0x80073DA0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_DewDetstSrvTstDem_CA
    " / "
    VAL_BLK
    0x80073DB2
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EGRVlvJamVlv_CA
    " / "
    VAL_BLK
    0x80073DBE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ETClbCorActv_CA
    " / "
    VAL_BLK
    0x80073DCA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmBCr_CA
    " / "
    VAL_BLK
    0x80073DDC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmCaSAdapCaSI1_CA
    " / "
    VAL_BLK
    0x80073DE8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmCaSDiag_CA
    " / "
    VAL_BLK
    0x80073DFC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmCaSOfsDiagCaSI1_CA
    " / "
    VAL_BLK
    0x80073E0E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmCaSOfsErrCaSI1_CA
    " / "
    VAL_BLK
    0x80073E22
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmCaSSegCor_CA
    " / "
    VAL_BLK
    0x80073E30
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmCrSDiag_CA
    " / "
    VAL_BLK
    0x80073E40
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmCrSDiagVeh_CA
    " / "
    VAL_BLK
    0x80073E4C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_EpmOpMode_InjLock_CA
    " / "
    VAL_BLK
    0x80073E58
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FBC_CA
    " / "
    VAL_BLK
    0x80073E66
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 27

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FMALamO2Valid_CA
    " / "
    VAL_BLK
    0x80073E9C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FMASwtOff1_CA
    " / "
    VAL_BLK
    0x80073EA8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FMASwtOff3_CA
    " / "
    VAL_BLK
    0x80073EB8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FlSysDens_CA
    " / "
    VAL_BLK
    0x80073EC4
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FlSysTnkLoEEP_CA
    " / "
    VAL_BLK
    0x80073ED0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FlSysTnkLoInfo_CA
    " / "
    VAL_BLK
    0x80073EDC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FuelTCTS_CA
    " / "
    VAL_BLK
    0x80073EE8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FuelTFlSys_CA
    " / "
    VAL_BLK
    0x80073EFA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FuelTFrzVal_CA
    " / "
    VAL_BLK
    0x80073F0A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FuelTFrzValB1_CA
    " / "
    VAL_BLK
    0x80073F1A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_FuelTReplVal_CA
    " / "
    VAL_BLK
    0x80073F2E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_GlwCtl1_CA
    " / "
    VAL_BLK
    0x80073F3E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_GlwCtl2_CA
    " / "
    VAL_BLK
    0x80073F50
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_GlwCtl3_CA
    " / "
    VAL_BLK
    0x80073F5C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_GlwPlgCod_CA
    " / "
    VAL_BLK
    0x80073F6C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_GlwPlgGCUTDia_CA
    " / "
    VAL_BLK
    0x80073F78
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVActrTempRplVal_CA
    " / "
    VAL_BLK
    0x80073F84
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVAdjNVCEna_CA
    " / "
    VAL_BLK
    0x80073F96
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVDiaCylOKTst_CA
    " / "
    VAL_BLK
    0x80073FA2
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVDiaTst_CA
    " / "
    VAL_BLK
    0x80073FAE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVPSplyDCDCOff_CA
    " / "
    VAL_BLK
    0x80073FC0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVPlausComprTst_CA
    " / "
    VAL_BLK
    0x80073FCC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_IVPlausRunUpTst_CA
    " / "
    VAL_BLK
    0x80073FD8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InhibitNever_CA
    " / "
    VAL_BLK
    0x80073FEE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjUnStrtPlsBlk_CA
    " / "
    VAL_BLK
    0x80073FFA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvBnk0ShutOff_CA
    " / "
    VAL_BLK
    0x8007400A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 12

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvCyl0ShutOff_CA
    " / "
    VAL_BLK
    0x80074022
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvCyl1ShutOff_CA
    " / "
    VAL_BLK
    0x80074032
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvCyl2ShutOff_CA
    " / "
    VAL_BLK
    0x80074042
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvCyl3ShutOff_CA
    " / "
    VAL_BLK
    0x80074052
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvCyl4ShutOff_CA
    " / "
    VAL_BLK
    0x80074062
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvCyl5ShutOff_CA
    " / "
    VAL_BLK
    0x8007406E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvPrep_CA
    " / "
    VAL_BLK
    0x8007407A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvPresMin_CA
    " / "
    VAL_BLK
    0x8007408C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvPresMinRun_CA
    " / "
    VAL_BLK
    0x80074098
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_InjVlvPresMinStrt_CA
    " / "
    VAL_BLK
    0x800740A4
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUAdap0_CA
    " / "
    VAL_BLK
    0x800740B0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 23

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUClbSched_CA
    " / "
    VAL_BLK
    0x800740DE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUCmpChk0_CA
    " / "
    VAL_BLK
    0x800740EA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 22

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUCtl0_CA
    " / "
    VAL_BLK
    0x80074116
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 12

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUDewRls0_CA
    " / "
    VAL_BLK
    0x8007412E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUDynChk0_CA
    " / "
    VAL_BLK
    0x80074140
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 20

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUHtCoup0_CA
    " / "
    VAL_BLK
    0x80074168
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 21

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUHtrPS0_CA
    " / "
    VAL_BLK
    0x80074192
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUIPOpnLdTst0_CA
    " / "
    VAL_BLK
    0x800741A0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 23

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUIsolChk0_CA
    " / "
    VAL_BLK
    0x800741CE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 20

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSULoBatt0_CA
    " / "
    VAL_BLK
    0x800741F6
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUMon0_CA
    " / "
    VAL_BLK
    0x80074204
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 22

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUO20_CA
    " / "
    VAL_BLK
    0x80074230
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 18

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUO2Clb0_CA
    " / "
    VAL_BLK
    0x80074254
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 12

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUO2SRC0_CA
    " / "
    VAL_BLK
    0x8007426C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 16

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUPlausChk0_CA
    " / "
    VAL_BLK
    0x8007428C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 25

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUPresComp0_CA
    " / "
    VAL_BLK
    0x800742BE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUPresCompAdap0_CA
    " / "
    VAL_BLK
    0x800742CA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSURi0_CA
    " / "
    VAL_BLK
    0x800742D6
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSURiClb0_CA
    " / "
    VAL_BLK
    0x800742EC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUShCir0_CA
    " / "
    VAL_BLK
    0x80074302
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUUNVGOpnLdTst0_CA
    " / "
    VAL_BLK
    0x80074318
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 18

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_LSUlsu0_CA
    " / "
    VAL_BLK
    0x8007433C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_MeUnActrTst_CA
    " / "
    VAL_BLK
    0x8007434C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_MeUnFrzI_CA
    " / "
    VAL_BLK
    0x8007435C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_MeUnRot_CA
    " / "
    VAL_BLK
    0x80074370
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_MeUnSetPTst_CA
    " / "
    VAL_BLK
    0x8007437C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_PCVActrTst_CA
    " / "
    VAL_BLK
    0x80074388
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_PCVFrzI_CA
    " / "
    VAL_BLK
    0x80074398
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_PCVNoStrt_CA
    " / "
    VAL_BLK
    0x800743AA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_PCVPwrStgTst_CA
    " / "
    VAL_BLK
    0x800743B6
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_PCVSetPTst_CA
    " / "
    VAL_BLK
    0x800743C2
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_QWCCTSDef_CA
    " / "
    VAL_BLK
    0x800743CE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_QWCFTSDef_CA
    " / "
    VAL_BLK
    0x800743E0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_QWCOff_CA
    " / "
    VAL_BLK
    0x800743F0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailCPCtlMeUnMode_CA
    " / "
    VAL_BLK
    0x80074402
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailCPCtlPCVMode_CA
    " / "
    VAL_BLK
    0x8007440E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailCtlMode_CA
    " / "
    VAL_BLK
    0x8007441A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailHpTst_CA
    " / "
    VAL_BLK
    0x8007442C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn0Blk_CA
    " / "
    VAL_BLK
    0x80074442
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn0Rls_CA
    " / "
    VAL_BLK
    0x80074458
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn1Blk_CA
    " / "
    VAL_BLK
    0x80074464
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn1Rls_CA
    " / "
    VAL_BLK
    0x80074470
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 12

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn22Rls_CA
    " / "
    VAL_BLK
    0x80074488
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn2Blk_CA
    " / "
    VAL_BLK
    0x80074494
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn2Rls_CA
    " / "
    VAL_BLK
    0x800744A2
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn3Blk_CA
    " / "
    VAL_BLK
    0x800744AE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn3Rls_CA
    " / "
    VAL_BLK
    0x800744BA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn4Blk_CA
    " / "
    VAL_BLK
    0x800744C6
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUn4Rls_CA
    " / "
    VAL_BLK
    0x800744D4
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUnClsdShutOff_CA
    " / "
    VAL_BLK
    0x800744E0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 14

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUnCtlMode_CA
    " / "
    VAL_BLK
    0x800744FC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 13

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailMeUnCtlUpLim_CA
    " / "
    VAL_BLK
    0x80074516
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV0Blk_CA
    " / "
    VAL_BLK
    0x80074522
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 14

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV0Rls_CA
    " / "
    VAL_BLK
    0x8007453E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV1Blk_CA
    " / "
    VAL_BLK
    0x8007454A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV1Rls_CA
    " / "
    VAL_BLK
    0x80074556
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 15

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV2Blk_CA
    " / "
    VAL_BLK
    0x80074574
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV2Rls_CA
    " / "
    VAL_BLK
    0x80074580
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV3Blk_CA
    " / "
    VAL_BLK
    0x8007458C
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV3Rls_CA
    " / "
    VAL_BLK
    0x80074598
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV4Blk_CA
    " / "
    VAL_BLK
    0x800745A4
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCV4Rls_CA
    " / "
    VAL_BLK
    0x800745B0
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCVCtlMode_CA
    " / "
    VAL_BLK
    0x800745BC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 11

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPCVCtlUpLim_CA
    " / "
    VAL_BLK
    0x800745D2
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPSS_CA
    " / "
    VAL_BLK
    0x800745DE
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailPSubsVal_CA
    " / "
    VAL_BLK
    0x800745EA
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailSetPointLim_CA
    " / "
    VAL_BLK
    0x800745FC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 9

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailSetPointRed_CA
    " / "
    VAL_BLK
    0x8007460E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailSetPointTst_CA
    " / "
    VAL_BLK
    0x8007461E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_RailTnkLo_CA
    " / "
    VAL_BLK
    0x8007462A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_SSTEGRClrDs_CA
    " / "
    VAL_BLK
    0x80074636
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_TAA_CA
    " / "
    VAL_BLK
    0x80074642
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_TEGRClrDsFrzVal_CA
    " / "
    VAL_BLK
    0x8007464E
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_TEGRClrDsRplVal_CA
    " / "
    VAL_BLK
    0x8007465A
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ThrVlvOpnLd_CA
    " / "
    VAL_BLK
    0x80074666
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_TrbChPmp_CA
    " / "
    VAL_BLK
    0x80074672
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ZFCClbActv_CA
    " / "
    VAL_BLK
    0x80074686
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 43

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ZFCCldCmbCham_CA
    " / "
    VAL_BLK
    0x800746DC
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_ZFCPCLClbActv_CA
    " / "
    VAL_BLK
    0x800746E8
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DINH_SbxCf.FId_stAVSCoESLSU_CA
    " / "
    VAL_BLK
    0x800746F4
    ValA_Wu16
    65535.
    DINH_SbxCfVerb
    0.00
    65535.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 65535.
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxAirCCmprOD_C
    ""
    VALUE
    0x8006C4C2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxAirCCmprRedTrqOD_C
    ""
    VALUE
    0x8006C4C4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxBrkMnID_C
    ""
    VALUE
    0x8006C4C6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxCATTS1PullOD_C
    ""
    VALUE
    0x8006C4C8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxClthID_C
    ""
    VALUE
    0x8006C4CA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxEGRVlvODDir_C
    ""
    VALUE
    0x8006C4CC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxEGRVlvODDis_C
    ""
    VALUE
    0x8006C4CE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxPFTS1PullOD_C
    ""
    VALUE
    0x8006C4D0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxTEGRPullOD_C
    ""
    VALUE
    0x8006C4D2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxThrVlvODDir_C
    ""
    VALUE
    0x8006C4D4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_idxThrVlvODDis_C
    ""
    VALUE
    0x8006C4D6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_swtPortP1P5OUTInv_C
    ""
    VALUE
    0x8006C4D8
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_swtPortP1P6OUTInv_C
    ""
    VALUE
    0x8006C4DA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_swtPortP4P1OUTInv_C
    ""
    VALUE
    0x8006C4DC
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_swtPortP4P2OUTInv_C
    ""
    VALUE
    0x8006C4DE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dio_swtPortP5P5INInv_C
    ""
    VALUE
    0x8006C4E0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Dme_stOverlayMethodOnly_C
    "Disable all calibration methods but overlay for minimizing runtime influences of calibration if value is not equal zero."
    VALUE
    0x8006B3D4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_AsgnCheck.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C242
    Val_Wu16
    303.
    DFC_Verb
    0.00
    303.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 303.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_AsgnCheck.FId_CoordALS_C
    " / "
    VALUE
    0x8006C244
    Val_Wu16
    303.
    DFC_Verb
    0.00
    303.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 303.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_AsgnCheck.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C246
    Val_Wu16
    303.
    DFC_Verb
    0.00
    303.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 303.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_AsgnCheck.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C248
    Val_Wu16
    303.
    DFC_Verb
    0.00
    303.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 303.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_AsgnCheck.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C24A
    Val_Wu16
    303.
    DFC_Verb
    0.00
    303.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 303.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_AsgnCheck.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C24C
    Val_Wu16
    303.
    DFC_Verb
    0.00
    303.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 303.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_AsgnCheck.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C24E
    Val_Wu16
    303.
    DFC_Verb
    0.00
    303.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 303.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C250
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_CoordALS_C
    " / "
    VALUE
    0x8006C252
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C254
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C256
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C258
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C25A
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_BsPrio.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C25C
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_Excl.FId_InhibitAlways_CA
    " / "
    VAL_BLK
    0x8006C25E
    ValA_Wu16
    7.
    DSCHED_FIdExcVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_Excl.FId_CoordALS_CA
    " / "
    VAL_BLK
    0x8006C26E
    ValA_Wu16
    7.
    DSCHED_FIdExcVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_Excl.FId_CoordFBC_CA
    " / "
    VAL_BLK
    0x8006C27E
    ValA_Wu16
    7.
    DSCHED_FIdExcVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_Excl.FId_CoordTAA_CA
    " / "
    VAL_BLK
    0x8006C28E
    ValA_Wu16
    7.
    DSCHED_FIdExcVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_Excl.FId_CoordZFC_CA
    " / "
    VAL_BLK
    0x8006C29E
    ValA_Wu16
    7.
    DSCHED_FIdExcVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_Excl.FId_IVPlausRunUpTstActv_CA
    " / "
    VAL_BLK
    0x8006C2AE
    ValA_Wu16
    7.
    DSCHED_FIdExcVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_Excl.FId_RailHpTstActv_CA
    " / "
    VAL_BLK
    0x8006C2BE
    ValA_Wu16
    7.
    DSCHED_FIdExcVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C2CE
    Val_Wu8
    255.0000
    DFC_OneToOne
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 255.0000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_CoordALS_C
    " / "
    VALUE
    0x8006C2CF
    Val_Wu8
    255.0000
    DFC_OneToOne
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 255.0000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C2D0
    Val_Wu8
    255.0000
    DFC_OneToOne
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 255.0000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C2D1
    Val_Wu8
    255.0000
    DFC_OneToOne
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 255.0000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C2D2
    Val_Wu8
    255.0000
    DFC_OneToOne
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 255.0000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C2D3
    Val_Wu8
    255.0000
    DFC_OneToOne
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 255.0000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_FacPhys.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C2D4
    Val_Wu8
    255.0000
    DFC_OneToOne
    0.00
    255.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 255.0000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C2D6
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_CoordALS_C
    " / "
    VALUE
    0x8006C2D8
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C2DA
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C2DC
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C2DE
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C2E0
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_JmpActvPrio.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C2E2
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C2E4
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_CoordALS_C
    " / "
    VALUE
    0x8006C2E6
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C2E8
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C2EA
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C2EC
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C2EE
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpIniPrio.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C2F0
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C2F2
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_CoordALS_C
    " / "
    VALUE
    0x8006C2F4
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C2F6
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C2F8
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C2FA
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C2FC
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpActv.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C2FE
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C300
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_CoordALS_C
    " / "
    VALUE
    0x8006C302
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C304
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C306
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C308
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C30A
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpSlpPas.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C30C
    Val_Wu16
    327675.0
    DSCHED_RmpSlp
    0.00
    327675.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 327675.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_InhibitAlways_C
    " / "
    VALUE
    0x8006C30E
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_CoordALS_C
    " / "
    VALUE
    0x8006C310
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_CoordFBC_C
    " / "
    VALUE
    0x8006C312
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_CoordTAA_C
    " / "
    VALUE
    0x8006C314
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_CoordZFC_C
    " / "
    VALUE
    0x8006C316
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_IVPlausRunUpTstActv_C
    " / "
    VALUE
    0x8006C318
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_RmpUpLim.FId_RailHpTstActv_C
    " / "
    VALUE
    0x8006C31A
    Val_Wu16
    65535.00
    DFC_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_valOfsPrioOpMode_C
    ""
    VALUE
    0x8006C240
    Val_Wu16
    65535.00
    DINH_OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSCHED_xSleepFId_CA
    ""
    VAL_BLK
    0x8006C31C
    ValA_Wu8
    7.
    DSCHED_FIdVerb
    0.00
    7.

    FORMAT "%2.0"
    EXTENDED_LIMITS 0.00 7.
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSMRdy_xPId1_C
    ""
    VALUE
    0x8006C328
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_numDFCSet_C
    ""
    VALUE
    0x8006C32C
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_numFIdSet_C
    ""
    VALUE
    0x8006C32E
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_stDebDFCSet_C
    ""
    VALUE
    0x8006C330
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_stDebDfltSet_C
    ""
    VALUE
    0x8006C334
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_stDFCSet_C
    ""
    VALUE
    0x8006C338
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_stFIdSet_C
    ""
    VALUE
    0x8006C33A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_swtCallBkFnInitEna_C
    ""
    VALUE
    0x8006C33B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    DSM_tmrDFCSet_C
    ""
    VALUE
    0x8006C33C
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_ATS.LimitTypeMsk_C
    "Actuator test ECBVlv_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BD78
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_ATS.CnvNorm_C
    "Actuator test ECBVlv_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BD79
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_ATS.LowLim_C
    "Actuator test ECBVlv_ATS / Lower limit for monitoring"
    VALUE
    0x8006BD7A
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_ATS.UpLim_C
    "Actuator test ECBVlv_ATS / Upper limit for monitoring"
    VALUE
    0x8006BD7C
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_ATS.CnvFac_C
    "Actuator test ECBVlv_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BD80
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_ATS.CnvOfs_C
    "Actuator test ECBVlv_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BD84
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_ATS.DfltVal_C
    "Actuator test ECBVlv_ATS / Default value for standbytest"
    VALUE
    0x8006BD86
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_Pwm.tiPer_C
    "Structure containing calibration and conversion data types for ECB valve / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x8006C4E2
    Kw_Ws16
    980.0000
    OneToOne
    20.00000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_Pwm.stLvl_C
    "Structure containing calibration and conversion data types for ECB valve / Reference value for phase relationship in period units"
    VALUE
    0x8006C4E4
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_Pwm.rMaxDty_C
    "Structure containing calibration and conversion data types for ECB valve / Reference value for maximum duty cycle"
    VALUE
    0x8006C4E6
    Kw_Ws16
    10000.00
    OneToOne
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_Pwm.rPerUn_C
    "Structure containing calibration and conversion data types for ECB valve / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x8006C4E8
    Kw_Ws16
    32766.00
    OneToOne
    1.000000
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_Pwm.tiPh_C
    "Structure containing calibration and conversion data types for ECB valve / Active level (0 or 1)"
    VALUE
    0x8006C4EA
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_PwmOut.rMin_C
    "Structure containing parameters for PWM output power stage error handling for ECB valve actuator / Minimum threshold for the duty cycle"
    VALUE
    0x8006C4EC
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_PwmOut.rMax_C
    "Structure containing parameters for PWM output power stage error handling for ECB valve actuator / Maximum threshold for the duty cycle"
    VALUE
    0x8006C4EE
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_PwmOut.tiBtwTstSCB_C
    "Structure containing parameters for PWM output power stage error handling for ECB valve actuator / Time between tests for SCB error"
    VALUE
    0x8006C4F0
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_PwmOut.tiBtwTstOT_C
    "Structure containing parameters for PWM output power stage error handling for ECB valve actuator / Time between tests for OT error"
    VALUE
    0x8006C4F2
    Kw_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_PwmOut.numTstMax_C
    "Structure containing parameters for PWM output power stage error handling for ECB valve actuator / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006C4F4
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_PwmOut.swtBattCor_C
    "Structure containing parameters for PWM output power stage error handling for ECB valve actuator / Switch to enable battery correction"
    VALUE
    0x8006C4F6
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_PwmOut.swtPsInv_C
    "Structure containing parameters for PWM output power stage error handling for ECB valve actuator / Power stage output inversion status"
    VALUE
    0x8006C4F7
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_rCnv_CUR
    "Curve for control value to duty cycle conversion"
    CURVE
    0x8006C4F8
    Cur_Xs16Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        ECBVlv_r
        Prc
        16
        -400.0000
        399.9878

        FORMAT "%8.4"
        EXTENDED_LIMITS -400.0000 399.9878
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_rPsDisbl_C
    "Disable output to power stage"
    VALUE
    0x8006C53A
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_stPsDiaDisbl_C
    "Application parameter to disable diagnosis of power stage for ECB valve actuator under certain battery and engine conditions"
    VALUE
    0x8006C53C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ECBVlv_stPsDisbl_C
    "Application parameter to disable power stage for ECB valve actuator under certain battery and engine conditions"
    VALUE
    0x8006C53D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EEPRdErr_Datalost_CW
    ""
    VALUE
    0x8006C940
    Val_Wu8
    255.0
    default
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EEPRdErr_Redundant_CW
    ""
    VALUE
    0x8006C941
    Val_Wu8
    255.0
    default
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_EnFirstInit_CW
    "Codeword to start a first initialization in EEP"
    VALUE
    0x8006C942
    Val_Wu8
    255.0
    default
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Eep_EnvRamClr_CW
    "Codeword to clear contents of ENVRAM"
    VALUE
    0x8006C943
    Val_Wu8
    255.0
    default
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_ATS.LimitTypeMsk_C
    "Actuator test EGRVlv_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BD88
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_ATS.CnvNorm_C
    "Actuator test EGRVlv_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BD89
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_ATS.LowLim_C
    "Actuator test EGRVlv_ATS / Lower limit for monitoring"
    VALUE
    0x8006BD8A
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_ATS.UpLim_C
    "Actuator test EGRVlv_ATS / Upper limit for monitoring"
    VALUE
    0x8006BD8C
    Val_Ws16
    799.9878
    Prc
    -400.0000
    399.9878

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_ATS.CnvFac_C
    "Actuator test EGRVlv_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BD90
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_ATS.CnvOfs_C
    "Actuator test EGRVlv_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BD94
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_ATS.DfltVal_C
    "Actuator test EGRVlv_ATS / Default value for standbytest"
    VALUE
    0x8006BD96
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_facCorStrt_C
    "correction factor compensation in Start state."
    VALUE
    0x8006C540
    Val_Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_HBrgPar.rTstDtyCyc_C
    "Parmeter structure for H-Bridge Diagnosis / Test Duty cycle in case of ShCirBatt1 / ShCirBatt2 / ShCirGnd1 / ShCirGnd2 / ShCirOvrLd errors."
    VALUE
    0x8006C542
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

