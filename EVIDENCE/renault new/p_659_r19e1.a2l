/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[32]
		"Activation of the identifier 20"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_20_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002715 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[33]
		"Activation of the identifier 21"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_21_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002716 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[37]
		"Activation of the identifier 25"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_25_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000271a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[38]
		"Activation of the identifier 26"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_26_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000271b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[3]
		"Activation of the identifier 03"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_03_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[41]
		"Activation of the identifier 29"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_29_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000271e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[43]
		"Activation of the identifier 2b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_2b_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002720 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[44]
		"Activation of the identifier 2c"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_2c_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002721 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[45]
		"Activation of the identifier 2d"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_2d_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002722 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[48]
		"Activation of the identifier 30"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_30_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002725 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[49]
		"Activation of the identifier 31"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_31_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002726 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[50]
		"Activation of the identifier 32"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_32_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002727 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[51]
		"Activation of the identifier 33"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_33_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002728 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[52]
		"Activation of the identifier 34"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_34_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002729 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[53]
		"Activation of the identifier 35"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_35_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000272a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[54]
		"Activation of the identifier 36"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_36_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000272b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[55]
		"Activation of the identifier 37"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_37_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000272c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[56]
		"Activation of the identifier 38"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_38_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000272d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[57]
		"Activation of the identifier 39"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_39_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000272e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[58]
		"Activation of the identifier 3a"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_3a_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000272f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[59]
		"Activation of the identifier 3b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_3b_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002730 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[60]
		"Activation of the identifier 3c"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_moni_id_3c_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002731 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[61]
		"Activation of the identifier 3d"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_3d_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002732 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[62]
		"Activation of the identifier 3e"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_3e_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002733 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[64]
		"Activation of the identifier 40"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_40_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002735 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[67]
		"Activation of the identifier 43"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_43_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002738 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[68]
		"Activation of the identifier 44"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_44_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002739 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[6]
		"Activation of the identifier 06"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_06_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026fb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[70]
		"Activation of the identifier 46"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_46_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000273b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[71]
		"Activation of the identifier 47"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_47_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000273c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[72]
		"Activation of the identifier 48"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_48_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000273d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[73]
		"Activation of the identifier 49"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_49_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000273e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[74]
		"Activation of the identifier 4a"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_4a_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000273f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[75]
		"Activation of the identifier 4b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_4b_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002740 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[76]
		"Activation of the identifier 4c"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_4c_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002741 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[81]
		"Activation of the identifier 51"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_51_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002746 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[82]
		"Activation of the identifier 52"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_52_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002747 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[96]
		"Activation of the identifier 60"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_60_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002755 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[97]
		"Activation of the identifier 61"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_61_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002756 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[98]
		"Activation of the identifier 62"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_62_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002757 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_bypmngx_xxxxxx_data.c' */
/* XmlToolChain::L2::FindAddresses : Remove BIT_MASK (No BIT_MASK According to '.debug_info' section in the elf file / Not a boolean value according the the naming convention) */
/begin MEASUREMENT
		Vbx_moni_xx_req[99]
		"Activation of the identifier 63"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vbx_byp_63_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002758 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mpl_fail
		"Multiple failure on fuel flow and pressure regulations"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mpl_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_msr_cdn
		"MSR conditions"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_msr_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_msr_tqe_req_ok
		"Authorized MSR torque request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_msr_tqe_req_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mute_pws_typ_bc
		"Mute power supply type (=1 if type BC, =0 if type AD)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mute_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcabsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_abs_reg
		"ABS in regulation received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_abs_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_acel_is_sp_navl
		"Accelerated engine idle speed setpoint request for air conditionning from CAN not available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_acel_is_sp_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfacxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_clu_req
		"air conditionning compressor request sent from AC ECU to USM (M3 architecture) received from CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_clu_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_mdf1_req
		"Fan 1 activation request from air conditioning ECU received on the CAN network"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_mdf1_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_mdf2_req
		"Fan 2 activation request from air conditioning ECU received on the CAN network"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_mdf2_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026dd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqacxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_pow_navl
		"air conditionning power unavailability"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_pow_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026eb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_req
		"Climate cooling request from CAN network"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_req_ext
		"Climate cooling request from AC ECU (cold loop outside ECM)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_req_ext 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ac_req_int
		"Climate cooling request from CAN ECU when cold loop is in ECM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ac_req_int 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smacsin_stbxxx_data.c' */
/begin MEASUREMENT
		Vbx_mux_acs_acel_is_req
		"Request of idle speed acceleration for accessories received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_acs_acel_is_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ca0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_agb_coup_navl
		"Indicates that the automatic gearbox coupler state received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_agb_coup_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_agb_csm_tq_navl
		"indicates that converter friction Torque received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_agb_csm_tq_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smat1in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_agb_is_acel_req
		"AT Idle speed setpoint acceleration request from CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_agb_is_acel_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ca1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smat2in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_agb_is_acel_sp_navl
		"indicates that AT minimum idle speed is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_agb_is_acel_sp_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_agb_mdf1_req
		"Fan 1 activation request from AGB received on the CAN network"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_agb_mdf1_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_agb_mdf2_req
		"Fan 2 activation request from AGB received on the CAN network"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_agb_mdf2_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqpalin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_alt_pow_navl
		"Alternator power from CAN is not available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_alt_pow_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfadfin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_alt_pwm_navl
		"indicates that alternator load is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_alt_pwm_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ant_crt_slc_navl
		"Indicates that the anticipated current gear shift is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ant_crt_slc_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfpdain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_aod_vs_navl
		"Unavailable value of the accurate odometer"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_aod_vs_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_asr_reg
		"ASR in regulation received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_asr_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ayc_reg
		"AYC in regulation received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ayc_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clbduin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_bdu_ope
		"boolean that indicates BDU opening"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_bdu_ope 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clbduin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_bdu_ope_navl
		"Indicates that the boolean which indicates BDU opening is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_bdu_ope_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcclbin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_bgin_str_clu_cnt_navl
		"indicates that end stroke clutch pedal switch received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_bgin_str_clu_cnt_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcbpkin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_bpk
		"Automatic or manual parking brake detected recieved on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_bpk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcbpkin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_bpk_navl
		"Indicates that the automatic or manual parking brake detected received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_bpk_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcbrkin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_brk_pdl_navl
		"indicates that the brake pedals states switch is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_brk_pdl_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_can_diag
		"Counting and storage of CAN mute/absent failure authorization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_can_diag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_drag_red_agb
		"Drag reduction mode received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_drag_red_agb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_dspl_vs_in_mph
		"The vehicule speed used for CC/SL is in mph"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_dspl_vs_in_mph 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_dspl_vs_navl
		"Displayed vehicle speed received on the CAN network not available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_dspl_vs_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_egb_neut
		"Electronic GearBox in a configuration equivalent to Neutral for a manual gearbox received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_egb_neut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smwixin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_el_bk_wind
		"Electric backlite request from CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_el_bk_wind 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smwixin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_el_wind_is_acel
		"Electric windshield idle speed setpoint acceleration request from CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_el_wind_is_acel 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcclein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_end_str_clu_cnt_navl
		"indicates that end stroke clutch pedal switch received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_end_str_clu_cnt_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_gear_cge
		"Gear change in progress. Boolean transmitted by automatic transmissions."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_gear_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfrwsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_lft_rwhs_navl
		"Indicates that the left right wheel speed received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_lft_rwhs_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgmltin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_mil_tcu_req
		"MIL activation request of transmission control unit received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_mil_tcu_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002af2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbfulin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_min_fuel_raw
		"Raw low level of fuel received on the CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_min_fuel_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcrvnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_neut_cnt_navl
		"Indicates Neutral engaged switch received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_neut_cnt_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctbnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_prim_sha_spd_navl
		"indicates that primary shaft speed received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_prim_sha_spd_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smptcin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ptc_is_acel_req
		"PTC idle speed request from CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ptc_is_acel_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ca2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfptcin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_ptc_pow_navl
		"PTC power from CAN is not available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_ptc_pow_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026f1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_raw_egb_ant_gear_navl
		"Indicates taht target raw gear due to electronic gearbox received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_raw_egb_ant_gear_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_raw_egb_gear_navl
		"Indicates that current raw gear due to electronic gearbox received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_raw_egb_gear_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfpdain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_raw_whl_angl_navl
		"Unavailable value of the steering wheel angle"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_raw_whl_angl_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfrwsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_rgt_rwhs_navl
		"Indicates that the rear right wheel speed received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_rgt_rwhs_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026f3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcrvnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_rvr_cnt_navl
		"indicates that Reverse gear engaged switch received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_rvr_cnt_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tenvxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_tenv_navl
		"Indicates that external temperature is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_tenv_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vftacin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_tra_acel_in_navl
		"Indicates that the transversal acceleration sensor received on the CAN is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_tra_acel_in_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgdtvin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_vh_dist_navl
		"indicates that total vehicle distance is unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_vh_dist_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_vh_key
		"CAN input data indicating if the key vehicle is present (1=vehicle with key)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_vh_key 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_mux_vs_navl
		"Vehicle speed received on the CAN network not available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mux_vs_navl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mv_zon_1_calc_ena
		"Mean value on Zone 1 calculation enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mv_zon_1_calc_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mv_zon_2_calc_ena
		"Mean value on Zone 2 calculation enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mv_zon_2_calc_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mv_zon_3_calc_ena
		"Mean value on Zone 3 calculation enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mv_zon_3_calc_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_mv_zon_4_calc_ena
		"Mean value on Zone 4 calculation enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mv_zon_4_calc_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_n_ac_dsb
		"AC compressor inhibition due to engine over-speed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_n_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_n_ini
		"initialization conditions"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_n_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000280b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nramsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_n_rams_lim_act
		"Activation of safety engine speed limitation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_n_rams_lim_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001e09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_n_rams_lim_act_1
		"Activation of safety engine speed limitation level 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_n_rams_lim_act_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_n_rams_lim_act_2
		"Activation of safety engine speed limitation level 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_n_rams_lim_act_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_n_vs_ac_clu_dsb
		"AC compressor clutching inhibition due to engine over-speed with too small vehicle speed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_n_vs_ac_clu_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_neut_gear_act
		"Neutral gear detected with clutch contactors and software contactor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_neut_gear_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027fb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_neut_psn
		"Neutral position is detected with gearbox contactor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_neut_psn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_no_dly_bfr_nom_stt
		"Boolean variable to authorize direct nominal status after exhaust pressure sensor failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_no_dly_bfr_nom_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_no_driv_pwt_sp
		"no powertrain setpoint requested by real (pedal) and virtual (ACC/CC/SL) drivers"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_no_driv_pwt_sp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000260e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_no_prs_pres
		"Boost and exhaust pressure simultanously unavailable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_no_prs_pres 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002637 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_nox_req
		"Indicates that a Nox Trap regeneration is requested."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_nox_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000288f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asspvcoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asspvcoo_asconpu_stbxxd_data.c' */
/begin MEASUREMENT
		Vbx_npu_mod_sta
		"Actiavtion of the air system Noxtrap structure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_npu_mod_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_mainscx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_nul_efv_inj
		"Null effective injection fuel"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_nul_efv_inj 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000268a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_obd_dc
		"Driving cycle detection status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_obd_dc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_rdnmgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_obd_rdn_cpt
		"Status of the comprehensive component OBD readiness code (0 = test complete)"
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_obd_rdn_cpt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_rdnmgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_obd_rdn_fsys
		"Status of the fuel system OBD readiness code (0 = test complete)"
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_obd_rdn_fsys 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_rdnmgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_obd_rdn_full
		"All readiness codes completion status flag"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_obd_rdn_full 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_rdnmgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_obd_rdn_mis
		"Status of the misfire OBD readiness code (0 = test complete)"
		UBYTE
		nesxhqd_lCemnod_hfytbqc_n__MENM
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_obd_rdn_mis 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_obd_wup
		"Warm-up cycle detection status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_obd_wup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_cond_ok
		"Logic indicating if all conditions are satisfied to start of the OBD DOC monitor"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_cond_ok 
    ECU_ADDRESS 0xd0002ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_ena
		"Logic indicating if all conditions are satisfied to start of the OBD DOC test"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_ena 
    ECU_ADDRESS 0xd0002ba7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_ena_temp_swi
		"Logic indicating if temperature conditions are satisfied to allow the OBD test"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_ena_temp_swi 
    ECU_ADDRESS 0xd0002ba8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_long_idle_det
		"Logic indicating if long idle is detected in diagnosis enabled conditions"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_long_idle_det 
    ECU_ADDRESS 0xd0002ba9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_mdl_err_ok
		"Logic checking that error value is within a predifined value"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_mdl_err_ok 
    ECU_ADDRESS 0xd0002baa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_ofs_ad_done_clr
		"Reinit of logic indicating if offset learning has done at least once"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_ofs_ad_done_clr 
    ECU_ADDRESS 0xd0002bab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_ofs_ad_ok
		"Logic indicating if offset learning has done at least once"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_ofs_ad_ok 
    ECU_ADDRESS 0xd0002bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_ofs_ad_sys_vld_swi
		"Flag indicating if the IVLD are all ok for offset learning operation"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_ofs_ad_sys_vld_swi 
    ECU_ADDRESS 0xd0002bb7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_stab_stt_det
		"Engine speed and torque are in steady state conditions"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_stab_stt_det 
    ECU_ADDRESS 0xd0002bad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_stop_eve
		"Flag indicating that an abort event has occurred"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_stop_eve 
    ECU_ADDRESS 0xd0002bae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_sys_vld_swi
		"Flag indicating if the IVLD are all ok"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_sys_vld_swi 
    ECU_ADDRESS 0xd0002baf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_test_cond_ok
		"Logic indicating if test conditions are satisfied during the criterion calculation"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_test_cond_ok 
    ECU_ADDRESS 0xd0002bb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ocd_test_ok
		"Logic indicating the DOC OBD test validity"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ocd_test_ok 
    ECU_ADDRESS 0xd0002bb1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ofs_ad_cond_ok
		"Logic indicating if offset learning conditions are satisfied"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ofs_ad_cond_ok 
    ECU_ADDRESS 0xd0002bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ofs_ad_long_idle_det
		"Logic indicating if a long idle is detected"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ofs_ad_long_idle_det 
    ECU_ADDRESS 0xd0002bb3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ofs_ad_mdl_err_stab_ok
		"Logic indicating if the error is stable enough to learn offset value"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ofs_ad_mdl_err_stab_ok 
    ECU_ADDRESS 0xd0002bb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ofs_ad_run
		"Offset learning is running"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ofs_ad_run 
    ECU_ADDRESS 0xd0002bb5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_schxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_oil_heat_abst_pres_cho
		"Presence of oil heater vapours conf choice"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_oil_heat_abst_pres_cho 
    ECU_ADDRESS 0xd0002b81 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_oitdiag_stbxxd_data.c' */
/begin MEASUREMENT
		Vbx_oit_open
		"Flag indicating that the ON/OFF IT is considered as open"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_oit_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_oitmonx_stbxxd_data.c' */
/begin MEASUREMENT
		Vbx_oit_pws_req
		"Request to maintain the power latch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_oit_pws_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itpspxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ol_sat_it_cmd_slop_on
		"Open loop or saturation command of the inlet throttle is in combustion mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ol_sat_it_cmd_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_old_igk_cut
		"Flag to detect micro-cut"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_old_igk_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_out_tco
		"Vbx_out_tco"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002dc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ovn_ant_coup
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ovn_ant_coup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimctl_ntspcxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ovn_cut_sp
		"setpoint torque cut for over speed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ovn_cut_sp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ovn_sta_ena
		"specific limitation during startup"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ovn_sta_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_fsncfxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ovn_tq_cor_dft_dsb
		"Soft engine speed limitation disabled due to an engine fault (e.g. limp-home)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ovn_tq_cor_dft_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029d1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nlimxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ovn_tq_cor_ena
		"Enable soft engine speed limitation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ovn_tq_cor_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_schxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_cfm
		"OCS inhibition variable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_cfm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_dil_req_km
		"This bit is set if the oil dilution level is higher than  Cxx_owe_oil_dil_thd"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_dil_req_km 
    ECU_ADDRESS 0xd0002d8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_dil_req_km_1_clc
		"Boolean set if the oil dilution threshold is passed"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_dil_req_km_1_clc 
    ECU_ADDRESS 0xd0002da0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_dil_wea_rmax_ovs
		"Boolean set if the maximal dilution rate is passed"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_dil_wea_rmax_ovs 
    ECU_ADDRESS 0xd0002dac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_drn_req
		"Oil drain requested"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_drn_req 
    ECU_ADDRESS 0xd0002da1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_drn_req_ok_2
		"Equivalent to  Vbx_owe_drn_req_ok_1   plus the initialisation request condition"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_drn_req_ok_2 
    ECU_ADDRESS 0xd0002da2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_drn_req_rst
		"Reset condition of the SR Fip Flop"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_drn_req_rst 
    ECU_ADDRESS 0xd0002da3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_eng_aut
		"Engine in autonomous state"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_eng_aut 
    ECU_ADDRESS 0xd0002eca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_eng_aut_dly
		"Set when the engine is autonomous and the delay is expired"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_eng_aut_dly 
    ECU_ADDRESS 0xd0002ecb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_fac_toil_act
		"Output of the SR_Flip_Flop"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_fac_toil_act 
    ECU_ADDRESS 0xd0002ecc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_schxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_hmi_warn_emb_cho
		"Warning or kilometers alert conf choice"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_hmi_warn_emb_cho 
    ECU_ADDRESS 0xd0002b80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_igk_on_igk_off
		"Rising edge of the ignition key"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_igk_on_igk_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ee6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ini_0_trg
		"Writing trigger for the type of initialisation (asd or not) for EEPROM memorisation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_0_trg 
    ECU_ADDRESS 0xd0002ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ini_1_trg
		"Writing trigger for the type of initialisation (asd or not) for EEPROM memorisation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_1_trg 
    ECU_ADDRESS 0xd0002ec5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ini_2_trg
		"Writing trigger for the type of initialisation (asd or not) for EEPROM memorisation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_2_trg 
    ECU_ADDRESS 0xd0002ec6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ini_3_trg
		"Writing trigger for the type of initialisation (asd or not) for EEPROM memorisation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_3_trg 
    ECU_ADDRESS 0xd0002ec7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owrstcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ini_req_ok
		"Initialisation request (manual or after sale department) accepted"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_req_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ee8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ini_req_tmp
		"Initialisation request (manual or after sale department) accepted rising edge widened"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ini_req_tmp 
    ECU_ADDRESS 0xd0002d96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_mnl_ini_req
		"Manual initialisation request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_mnl_ini_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ee7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clrstin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_owe_mnl_ini_req_mux
		"Input from the can to initialise the strategy as customer init"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_mnl_ini_req_mux 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ecd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owrstcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_mnl_ini_req_ok
		"Manual initialisation request accepted"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_mnl_ini_req_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ee9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_n_drn_req
		"This bit is set when the oxidation level of the oil is to high"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_n_drn_req 
    ECU_ADDRESS 0xd0002da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_off
		"Set if the oil wear estimation is inibited"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_off 
    ECU_ADDRESS 0xd0002ec8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_oil_drn_req_2_clc
		"Oil drain requested by the strategy (level 2)"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req_2_clc 
    ECU_ADDRESS 0xd0002d9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_oil_drn_req_2_mux
		"Oil drain requested by the strategy (level 2) sent on can interface"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req_2_mux 
    ECU_ADDRESS 0xd0002d8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_oil_drn_req_2_mux_raw
		"Oil drain requested by the strategy before replacement value"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req_2_mux_raw 
    ECU_ADDRESS 0xd0002da5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_oil_drn_req_clc
		"Oil drain requested by the strategy"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req_clc 
    ECU_ADDRESS 0xd0002d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_oil_drn_req_mux
		"Oil drain requested by the strategy sent on can interface"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req_mux 
    ECU_ADDRESS 0xd0002d8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_oil_drn_req_mux_raw
		"Oil drain requested by the strategy (level 2) before replacement value"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oil_drn_req_mux_raw 
    ECU_ADDRESS 0xd0002da6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_oxi_dil_comp
		"Bolean set if dilution potential kilometer is smaler or equal than oxidation kilometer"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_oxi_dil_comp 
    ECU_ADDRESS 0xd0002dad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_prg
		"Boolean variable to forbid an OCS event after an ECU reprogrammation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_prg 
    ECU_ADDRESS 0xd0002da7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ref1_upd
		"Rising edge set if the first point is learned"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ref1_upd 
    ECU_ADDRESS 0xd0002dae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ref2_avl_dil
		"Point 2 available for dilution kilometer potential calculation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ref2_avl_dil 
    ECU_ADDRESS 0xd0002daf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ref2_upd
		"Rising edge set when the second point and the folowing are learned"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ref2_upd 
    ECU_ADDRESS 0xd0002db0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ref_2_ok
		"Point 2 learned"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ref_2_ok 
    ECU_ADDRESS 0xd0002d97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmkm_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_ref_2_upd
		"Point 2 up-dated"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_ref_2_upd 
    ECU_ADDRESS 0xd0002d98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_req_km_2_clc
		"Boolean set if the oil dilution threshold is passed"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_req_km_2_clc 
    ECU_ADDRESS 0xd0002d89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_tool_ini_req
		"Boolean sent by the diagnosis tool to initialise the strategy in case of oil drain"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_tool_ini_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_trans_zon
		"Boolean set if the strategy is on smooth mode between dilution and oxidation kilometers"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_trans_zon 
    ECU_ADDRESS 0xd0002db1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_warn_req
		"Set when the pre-alert is requered to memorize the vehicle kilometers."
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_warn_req 
    ECU_ADDRESS 0xd0002d8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owihmpa_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_warn_req_km_clc
		"Set when the pre-alert is requered to memorize the vehicle kilometers. (calculated value)"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_warn_req_km_clc 
    ECU_ADDRESS 0xd0002d9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucloluo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucloluo_owkmdil_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_wea_nul
		"Boolean set if the oil dilution wear is nul during a kilometer interval"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_wea_nul 
    ECU_ADDRESS 0xd0002db2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owzoncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_owe_zon_writ
		"Boolean set when a geographical zon is wroten"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_owe_zon_writ 
    ECU_ADDRESS 0xd0002ec9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ox_cata_diag_done
		"Logic indicating if OBD DOC test has completed"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ox_cata_diag_done 
    ECU_ADDRESS 0xd0002bb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pbt_fmc_tia_cold_cut
		"Flag of exhaust pressure diagnosis shut off in case of cold intake air temperature"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pbt_fmc_tia_cold_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_pdl_use_rtn
		"Inform the driver retains its foot on pedal"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pdl_use_rtn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027fd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_perf_ac_dsb
		"Consolidated air conditioning deactivation request for performance restitution"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_perf_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_perf_acs_dsb
		"Accessories deactivation request for performance restitution"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_perf_acs_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_perf_el_csm_dsb
		"Consolidated electrical consumers deactivation request for performance restitution"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_perf_el_csm_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_agb_req
		"Automatic gearbox request for regeneration help"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_agb_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_lpos_fim_ena
		"Switch of the secondary lpos injection value"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_lpos_fim_ena 
    ECU_ADDRESS 0xd0002bd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_req_lpos_ena
		"Boolean indicating though ASD regeneration request is enable"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_req_lpos_ena 
    ECU_ADDRESS 0xd0002bd3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_rgn_on
		"Boolean indicating that aftersale regeneration is requested by aftersale tools"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_rgn_on 
    ECU_ADDRESS 0xd0002bdb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_temp_thd
		"Boolean indicating if the condition of temperature on the exhaust line before the CSF is ok"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_temp_thd 
    ECU_ADDRESS 0xd0002bd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_trs_cool_cdn
		"Boolean indicating the transition from the regeneration state to the cold state"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_trs_cool_cdn 
    ECU_ADDRESS 0xd0002bd5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_trs_fail_cdn
		"Boolean indicating the transition from the hot state to the failure state"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_trs_fail_cdn 
    ECU_ADDRESS 0xd0002bd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_trs_ok_cdn
		"Boolean indicating the transition from the cold state to the succesful regeneration state"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_trs_ok_cdn 
    ECU_ADDRESS 0xd0002bd7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_trs_rgn_cdn
		"Boolean indicating the transition from the hot state to the regeneration state"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_trs_rgn_cdn 
    ECU_ADDRESS 0xd0002bd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_ttr_thd
		"Boolean indicating if the condition of temperature before turbine is ok"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_ttr_thd 
    ECU_ADDRESS 0xd0002bd9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_asd_utp_thd
		"Boolean indicating if the condition of upstream temperature is ok"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_asd_utp_thd 
    ECU_ADDRESS 0xd0002bda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_clos_rgn
		"Flag indicating conditions close to particulate filter regeneration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_clos_rgn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_cold_cdn
		"Cold regeneration conditions fulfilled."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_cold_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_cold_rgn_ena
		"Boolean indicating that regeneration in cold conditions is enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_cold_rgn_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c53 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_comb_cat_heat_req
		"Request for catalyst heating combustion mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_comb_cat_heat_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_comb_mod_act
		"Boolean indicating if a combustion mode for particulate filter is on (2 or 3)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_comb_mod_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_comb_rgn_req
		"Request for PFT regeneration mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_comb_rgn_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_comb_wait_cdn_req
		"Request for pft protection mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_comb_wait_cdn_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_done
		"Diagnosis of particulate filter at first time done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_ena_stt
		"Enable status of diagnosis for overload particulate filter"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_ena_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_mv_zon_1_calc_done
		"Mean value on Zone 1 calculation done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_mv_zon_1_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bf9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_mv_zon_2_calc_done
		"Mean value on Zone 2 calculation done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_mv_zon_2_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_mv_zon_3_calc_done
		"Mean value on Zone 3 calculation done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_mv_zon_3_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bfb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_mv_zon_4_calc_done
		"Mean value on Zone 4 calculation done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_mv_zon_4_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_rls_stt
		"Release status for diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_rls_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bdf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_rls_stt_lkg
		"Bit that confirm the validity of the overload diagnosis for overload particulate filter"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_rls_stt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c0b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_rls_stt_lkg_1
		"2nd bit of release status for diagnosis : overload diagnosis."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_rls_stt_lkg_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_stt_ovl_out
		"Release status of overloaded CSF diagnosis after the soot mass corrected contribution"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_stt_ovl_out 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_up_prs_obd_max
		"Boolean indicating upstream relative pressure is greater than CSF clogged threshold"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_up_prs_obd_max 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000266c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_up_prs_obd_max_err
		"SRC Max error detected after debouncing"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_up_prs_obd_max_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000266d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_1_calc_done
		"Criterion calculation on Zone 1 done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_1_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bfd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_1_df
		"Detected failure on Zone 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_1_df 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bfe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_2_calc_done
		"Criterion calculation on Zone 2 done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_2_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_2_df
		"Detected failure on Zone 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_2_df 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c00 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_3_calc_done
		"Criterion calculation on Zone 3 done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_3_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_3_df
		"Detected failure on Zone 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_3_df 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_4_calc_done
		"Criterion calculation on Zone 4 done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_4_calc_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_diag_zon_4_df
		"Detected failure on Zone 4"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_diag_zon_4_df 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_dist_load_min
		"Distance roamed  superior to minimun distance betwen two regeneration success"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_dist_load_min 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c2d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_dist_load_min_rgn_forb
		"Boolean variable indicating if regeneration is fobidden because of the minimum distance between two regenerations"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_dist_load_min_rgn_forb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_dist_load_min_spd_req
		"Distance roamed superior to minimum distance betwen two regeneration success to activate speed reque"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_dist_load_min_spd_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c2e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_dist_min_ok_suc
		"Condition indicating regeneration success on minimum distance condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_dist_min_ok_suc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_driv
		"Driving conditions are fulfilled"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_driv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_efi_cmd_ind
		"Boolean indicating the activation of the solenid valve"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_efi_cmd_ind 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_efi_cmd_on
		"Boolean indicating a  possible injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_efi_cmd_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_efi_ctr_on
		"Boolean indicating maximal sampling time is reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_efi_ctr_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d39 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_efi_sldv_cmd
		"Boolean enabling to activate the command of the solenoid valve of fuel injector in exhaust line"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_efi_sldv_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_efy_max_ms_sta_swi
		"Switch enabling the fix CSF up temp set point"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_efy_max_ms_sta_swi 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_eng_cold_cdn
		"Cold conditions are fulfilled for engine operating point"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_eng_cold_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_eng_hot_cdn
		"Hot conditions are fulfilled for engine operating point"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_eng_hot_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_eng_med_cdn
		"Medium thermal conditions are fulfilled for engine operating point"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_eng_med_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ea0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_eng_sp_forc_rgn
		"Forced regeneration conditions are fulfilled for engine operating point"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_eng_sp_forc_rgn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_eng_sp_nok
		"Boolean indicating engine operating point is over maximum value of AGB request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_eng_sp_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_eng_stop_csf
		"Boolean indicating if statemachine is locked in charging state du to engine stop"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_eng_stop_csf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e5f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_exh_fsys_open_cmd
		"Opening command for exhaust fuel circuit"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_exh_fsys_open_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_fms_dg_ig_init_win
		"Boolean indicating if temperature deviation is inside limits enabling reinitialization of I and D-"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_fms_dg_ig_init_win 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bbf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_cdn
		"Hot regeneration conditions fulfilled."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c2f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_cold_dist_intv_ovs
		"Bool var indicating if dist since last hot or med or cold opportunity overruns all learnt dist intervals between hot or med or cold opp."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_cold_dist_intv_ovs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c49 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_cold_id
		"boolean indicating if a real hot or medium or cold opportunity can be confirmed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_cold_id 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_dist_intv_ovs
		"Boolean variable indicating if distance since last hot opportunity overruns all learnt distance intervals between hot opportunities."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_dist_intv_ovs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_id
		"boolean indicating if a real hot opportunity can be confirmed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_id 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_med_dist_intv_ovs
		"Bool var indicating if distance since last hot or medium opportunity overruns all learnt dist intervals between hot or medium opp."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_med_dist_intv_ovs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c4b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_lastopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_med_id
		"boolean indicating if a real hot or medium opportunity can be confirmed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_med_id 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_hot_rgn_ena
		"Boolean indicating that regeneration in hot conditions is enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_hot_rgn_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_inj_fms_cor_req
		"Request of injected fuel mass flow correction for CSF up temp regulation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_inj_fms_cor_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_inj_stt
		"Information of regeneration : TRUE if injection mode is not equal to 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_inj_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c10 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_lim_dir_pft
		"Boolean indicating that torque limitation on clogged particulate filter is requested"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_lim_dir_pft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_load_cdn_3
		"Boolean confirming recognition of regeneration demand by distance."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_load_cdn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_load_spd_clc_rst_ms
		"Boolean used to reset load speed calculation in case of mass status change or validity problem for soot mass"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_load_spd_clc_rst_ms 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_load_spd_clc_rst_pft
		"Boolean used to reset load speed calculation in case of particle filter change"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_load_spd_clc_rst_pft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_load_spd_clc_stt_dec
		"Boolean variable indicating if the status of calculation of soot load speed is decreasing"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_load_spd_clc_stt_dec 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c47 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_load_spd_clc_stt_inc
		"Boolean variable indicating if the status of calculation of soot load speed is increasing"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_load_spd_clc_stt_inc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_malf_diag_ena_stt
		"Enable status of diagnosis."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_malf_diag_ena_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_malf_diag_stt_2
		"Bit 2 of status of particulate filter for malfunction diagnosis."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_malf_diag_stt_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_malf_diag_stt_6
		"Bit 6 of status of particulate filter for malfunction diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_malf_diag_stt_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_malf_diag_stt_8
		"Bit 8 of status of particulate filter for malfunction diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_malf_diag_stt_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_max_ctr_rgn_err_cold
		"Maximum regeneration failure in cold condition reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_max_ctr_rgn_err_cold 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_max_ctr_rgn_err_hot
		"Maximum regeneration failure in hot condition reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_max_ctr_rgn_err_hot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c63 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_max_ctr_rgn_err_med
		"Maximum regeneration failure in medium condition reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_max_ctr_rgn_err_med 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_max_rgn_err_spd_rq
		"Speed request activation in case of maximum regeneration failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_max_rgn_err_spd_rq 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_max_rgn_err_wait_mod
		"Wait mode activation in case of maximum regeneration failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_max_rgn_err_wait_mod 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_med_cdn
		"Medium thermal regeneration conditions fulfilled."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_med_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c31 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_med_rgn_ena
		"Boolean indicating that regeneration in medium conditions is enable"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_med_rgn_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_comb_stt_swi
		"State configuration switch for soot mass left choice."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_comb_stt_swi 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_dist_load_min
		"Boolean indicating that maximum soot mass target condition is reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_dist_load_min 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c32 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_rgn_cold_cdn
		"Conditions on soot mass in cold conditions reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_rgn_cold_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c33 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_rgn_hot_cdn
		"Conditions on soot mass in hot conditions reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_rgn_hot_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_rgn_med_cdn
		"Conditions on soot mass in medium thermal conditions are reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_rgn_med_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c35 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_rgn_spd_req_cdn
		"Minimum conditions on soot mass are reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_rgn_spd_req_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_rst
		"Flag for regeneration success or partial regeneration detection."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_thd_clc
		"Boolean variable indicating if the 3 soot mass thresholds for protection mode have been calculated since ECU ignition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_thd_clc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_thd_cold_ok
		"Cold conditions on soot mass reached AND (factor*cold simulated soot mass reached OR factor*cold distance reached)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_thd_cold_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_thd_hot_ok
		"Hot conditions on soot mass reached AND (factor*hot simulated soot mass reached OR factor* hot distance reached)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_thd_hot_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_thd_med_ok
		"Medium thermal regeneration conditions on soot mass reached AND (factor*pass rgn simulated soot mass reached OR factor*pass rgn distance reached)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_thd_med_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c59 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_thd_rgn_forc_ok
		"Conditions on soot mass reached to enable forced regeneration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_thd_rgn_forc_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ms_thd_spd_req_ok
		"Miniconditions on soot mass reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ms_thd_spd_req_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_oil_dil_clc_ena
		"Switch to enable oil dilution computation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_oil_dil_clc_ena 
    ECU_ADDRESS 0xd0002c91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_oil_rgn_ena
		"Regeneration allowed by oil conditions"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_oil_rgn_ena 
    ECU_ADDRESS 0xd0002c92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_ovl_diag_done
		"Diagnosis of overloaded particulate filter at first time done"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_ovl_diag_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_per_req_intv_clc
		"Bool var indicating if required dist intervals assuming repeatable customer opp spacing have been computed since ECU ignition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_per_req_intv_clc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_pwl_rtn
		"Particule filter request to retain power latch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_pwl_rtn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028fb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_req
		"Indicates that a Particle Filter Regeneration is processing."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002890 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rest_rgn_req
		"Regeneration restart memorized request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rest_rgn_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_cond_ena
		"Regeneration authorization status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_cond_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_ena
		"Regeneration authorization status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_ena_lim_dir
		"Boolean indicating that regeneration is forbidden and torque limitation is requested"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_ena_lim_dir 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_ena_min_lvl
		"Boolean indicating if regeneration is disable on minimum fuel level"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_ena_min_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_ena_not_pft
		"Boolean indicating if regeneration is disable on not present particulate filter configuration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_ena_not_pft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_ena_wait_cdn
		"Regeneration authorization status to enable waiting mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_ena_wait_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_eng_rest_act
		"Request to restart regeneration from engine conditions"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_eng_rest_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_eng_rest_stop
		"Request to stop regeneration from engine conditions"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_eng_rest_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_eng_rest_stt_ini
		"Engine restart state activated init value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_eng_rest_stt_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_forc_cdn
		"Forced regeneration condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_forc_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c39 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_forc_req
		"Forced regeneration request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_forc_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_no_end
		"Boolean indicating if regeneration is finished."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_no_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_ok_ini
		"Boolean confirming a regeneration request from speed stored in EEPROM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_ok_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_req_end
		"Initialization condition: Ecu ignition or leaving regeneration request state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_req_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e87 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_req_ini
		"Boolean to initialize partial regeneration combustion status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_req_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_req_stt
		"Regeneration request state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_req_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_spd_req
		"Speed request call authorization for regeneration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_spd_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_sta_cdn_1
		"Boolean meaning that soot mass evolution detects a regeneration."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_sta_cdn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_sta_cdn_2
		"Boolean meaning that combustion model detects a regeneration."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_sta_cdn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_rgn_thd_temp_err
		"Boolean indicating that regeneration has failed due to unsufficient temperature"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_rgn_thd_temp_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_sldv_dp_open_cmd
		"Opening command of solenoid valve for exhaust fuel circuit during power latch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_sldv_dp_open_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_soot_comb_ena
		"Flag enabling the soot combustion computation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_soot_comb_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_soot_comb_stop
		"Flag to detect the end of exotherme computation to ensure the soot mass storage at the end of the regeneration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_soot_comb_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_sot_comb_esti_stt
		"Status of combusted estimated soot mass (partial regeneration)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_sot_comb_esti_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e81 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_sot_comb_stt
		"Status of combusted soot mass (partial regeneration)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_sot_comb_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_load_cdn
		"Authorization switch to compute for charge end conditions."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_load_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_cdn
		"Conditions to call speed request for regeneration fulfilled."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c3b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_err
		"Speed request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_ini
		"Boolean confirming a regeneration request from speed stored in EEPROM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_ini_tmp
		"Temporary Boolean confirming a regeneration request from speed stored in EEPROM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_ini_tmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e63 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_lght_ini
		"Indicates road requesr initial value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_lght_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_lght_off
		"Flag for speed request light signal turning off while running."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_lght_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_min_cond
		"Minimum conditions to activate speed request state after engine restart."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_min_cond 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_min_cond_tmp
		"Temporary boolean for minimum conditions to activate speed request state after engine restart."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_min_cond_tmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_spd_req_rgn_cdn
		"Conditions to activate the speed request state are reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_spd_req_rgn_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt
		"Enable status for overload particulate filter"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_chg_ini
		"Transition authorization to go back to charging state."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_chg_ini 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_load_cdn
		"Charge end conditions on time and distance fulfilled."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_load_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c3d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_min_load_t
		"Time of chargement superior to minimal value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_min_load_t 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_cat_heat
		"Manual request for catalyst heating"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_cat_heat 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_chk_tmp
		"Manual request for chech temperature"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_chk_tmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_load
		"Manual request for load state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_load 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_rgn_fail
		"To regeneration failure state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_rgn_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_rgn_ok
		"Manual request for regeneration success"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_rgn_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_rgn_req
		"Manual request for regeneration request state."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_rgn_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_rgn_rst
		"Manual request for regeneration restart state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_rgn_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_mnl_spd_req
		"Manual request for speed request state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_mnl_spd_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_ms_ena
		"Authorization of estimation of soot mass"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_ms_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_oil
		"State for oil dilution calculation"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_oil 
    ECU_ADDRESS 0xd0002c90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_rgn_ena_1
		"Authorization of regeneration injection mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_rgn_ena_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_rgn_ena_2
		"Authorization of transition into regeneration injection mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_rgn_ena_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_stt_rgn_mnl
		"Boolean indicating that the statemachine manual mode is on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_stt_rgn_mnl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_temp_l
		"Low temperature indication after regeneration start"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_temp_l_hot
		"Low temperature indication after regeneration start and hot CSF."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_temp_l_hot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_tia_cor_sta_ok
		"Storing conditions enable for intake air temperature."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_tia_cor_sta_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_tia_cor_str_cnd
		"Storing conditions enable for intake air temperature."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_tia_cor_str_cnd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cd5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_0
		"transition from charging to speed request state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_0_tmp
		"Boolean for transition from charging to speed request state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_0_tmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_1
		"transition from charging to temperature check state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c26 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_10
		"Active transition from regeneration request to regeneration state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_10 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e83 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_11
		"Active transition from regeneration request to restart regeneration state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_11 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_14
		"Active transition to charging state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_14 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_1_tmp
		"temporary boolean for transition from charging to temperature check state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_1_tmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_spdreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_3
		"Active transition from speed_request state to check_temperature state for regeneration request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_4
		"Active transition to catalyst_heating state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e51 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_5
		"Active transition to regeneration request state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_5 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_6
		"Authorizes transition from catalyst heating to regeneration failure state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_7
		"Authorizes transition from catalyst heating to regeneration request state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_cdn_8
		"Active transition to state regeneration failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_cdn_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_ena
		"Authorization of injection mode transition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_req
		"Demand of transition for mode of injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_req_4
		"Active transition request reinitialisation in check_temperature state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_req_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e53 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_req_6
		"Request for transition from catalyst_heating state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_req_6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_trs_req_8
		"Transition request reinitialization"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_trs_req_8 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_cmd_cor_act
		"Boolean indicating though command correction depending on CSF upstream temperature measure is active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_cmd_cor_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bc3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_cmd_cor_act_cdn
		"Boolean indicating though conditions are filled for command correction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_cmd_cor_act_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_cmd_cor_act_req
		"Boolean indicating that command correction depending on CSF upstream temperature measure is active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_cmd_cor_act_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bc5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_dev_cdn
		"Flag of deviation temperature diagnosis condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_dev_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ce6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_diag_cdn
		"Diagnosic condition status for temperature"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_diag_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ce7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_diag_swi_pup_stt
		"State of pull up commutation (0:100k, 1:1k)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_diag_swi_pup_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ce8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_ol_cmd_act
		"Boolean indicating though open loop command is active just after DOC warming-up"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_ol_cmd_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_utp_wup_cmd_act
		"Boolean indicating though DOC warming-up phase consisting in open loop partial command is active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_utp_wup_cmd_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002bc7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_ms_err
		"Distance reached in case of failures to calculate the soot mass."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_ms_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c5d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_rgn_cold_cdn
		"Conditions on distance in cold conditions are reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_rgn_cold_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c3f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_rgn_hot_cdn
		"Conditions on distance in hot conditions are reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_rgn_hot_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_rgn_med_cdn
		"Conditions on distance in medium thermal conditions are reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_rgn_med_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c41 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_rgn_ms_err_cdn
		"Conditions on distance are reached in case of failure to calculate the soot mass."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_rgn_ms_err_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_rgn_ok
		"Conditions on distance for regeneration fulfilled."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_rgn_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c43 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_rgn_spd_req_cdn
		"Minimum conditions on distance are reached."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_rgn_spd_req_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_thd_cold_ok
		"Cold conditions on distance reached AND (factor*cold  soot mass reached OR factor*cold simulated soot mass reached)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_thd_cold_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_thd_hot_ok
		"Hot conditions on distance reached AND (factor*hot  soot mass reached OR factor*hot simulated soot mass reached)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_thd_hot_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c5f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_thd_med_ok
		"Medium thermal conditions on distance  reached AND (factor*med  soot mass reached OR factor*med simulated soot mass reached)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_thd_med_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_vh_dist_thd_spd_req_ok
		"Mini conditions on distance reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_vh_dist_thd_spd_req_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_wait_cdn_req
		"Boolean indicating that the waiting mode is requested by the system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_wait_cdn_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c51 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pft_wait_mod_act_req
		"Request for wait mode activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pft_wait_mod_act_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_post_chk_cond_ok
		"Logic indicating if post injection conditions are met"
		UBYTE
		RB_CONV_AtCatDgn_bool
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_post_chk_cond_ok 
    ECU_ADDRESS 0xd0002bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_pres_df_in_cam_chr
		"Consolidation of intake camshaft signal incoherency detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pres_df_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002804 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_pres_df_in_cam_crk_cmp
		"Consolidation of incoherency between intake camshaft signal and crankshaft signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pres_df_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002805 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_pres_df_in_cam_cyc
		"Consolidation of interference close to a intake camshaft edge confirmed failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pres_df_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002806 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_pres_df_in_cam_no_sig
		"Consolidation of no intake camshaft signal detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pres_df_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002807 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_pres_df_in_cam_nok
		"Consolidation of camshaft signal invalid for synchronisation detected failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pres_df_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002808 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_prmt_n_ac_dsb
		"AC compressor inhibition due to prolonged engine over-speed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_prmt_n_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ptc_cut
		"Cut off condition, output of shut off and limitation conditions to the CAN Inj_Base_Rapide frame"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ptc_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002de5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ptc_dsb_req
		"PTC deactivation request before coordination"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ptc_dsb_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ded 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ptc_frz
		"Output of freeze condition, to the CAN INJ_Base_Rapide frame."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ptc_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002de6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_ptcxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ptc_is_acel_req
		"PTC engine idle speed increase request from CAN"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ptc_is_acel_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_pwm_thd_i_init
		"Initialisation condition in case of high pwm during acceleration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_pwm_thd_i_init 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ram_full
		"A root cause and milleage are stored in the second buffer in RAM so no other deactivation or activation can be stored until the EEPROM is ready"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ram_full 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002944 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ram_full_prev
		"Previous compilation of Vbx_ram_full"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ram_full_prev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002945 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_raw_bgin_clu_off_no_chr
		"Incohernecy detected when the begin clutch contactor is always OFF"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_raw_bgin_clu_off_no_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_rbst_el_csm_dsb
		"Electrical consumers deactivation request for engine robustness"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rbst_el_csm_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_3_ecm
		"Intermediate flag of shut-off cond. 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_3_ecm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_3_spc_npu
		"Flag of specific shut-off cond. 3 (npu)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_3_spc_npu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_amp_dft
		"Flag for regulation shut-off on atmospheric pressure failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_amp_dft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a5d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_amp_dft_raw
		"Flag for regulation shut-off on atmospheric pressure failure (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_amp_dft_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_egr_byp_dft_raw
		"Flag for regulation shut-off on egr coolant bypass failure (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_egr_byp_dft_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_egr_wpmp_diag
		"Flag of egr regulation cut-off in case of egr water pump default"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_egr_wpmp_diag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002662 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_egr_wpmp_diag_2
		"Flag of egr regulation cut-off in case of egr water pump default (intermediate IVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_egr_wpmp_diag_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002663 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_emtv_diag_2
		"Flag for egr regulation cut-off in case of emtv diagnosis error (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_emtv_diag_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_gear_dft_raw
		"Flag for regulation shut-off on gear failure (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_gear_dft_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_it_diag_2
		"Flag for egr regulation cut-off in case of it diagnosis error (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_it_diag_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_maf_dft_raw
		"Flag for regulation shut-off on maf sensor failure (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_maf_dft_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_maf_reg_diag
		"Flag for egr regulation cut-off in case of maf reg error"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_maf_reg_diag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_maf_reg_diag_2
		"Flag for egr regulation cut-off in case of maf reg error (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_maf_reg_diag_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_no_npu
		"Flag for EGR cut-off except in npu mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_no_npu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_no_pr
		"Flag for EGR cut-off except in pr mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_no_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a5f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_npu
		"Flag for cut-off in npu mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_npu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_ovr_ecm
		"Flag of EGR regulation cut-off in case of overrun before monitool bypass"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_ovr_ecm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_pft_ms_dft_raw
		"Flag for regulation shut-off on particulate filter load failure (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_pft_ms_dft_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_pft_ms_dp_dft
		"Flag for regulation shut-off on particulate filter load failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_pft_ms_dp_dft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_pft_req
		"Flag for egr cut-off on pft request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_pft_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002664 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_pft_req_2
		"Flag for egr cut-off on pft request (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_pft_req_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_rij_pp
		"Flag for EGR cut-off in rij and pp modes"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_rij_pp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e12 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_csecsoc_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_tco_dft
		"Flag for regulation shut-off on coolant temperature failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_tco_dft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_tco_dft_raw
		"Flag for regulation shut-off on ambient temperature failure (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_tco_dft_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ba1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_tia_dft_raw
		"Flag for regulation shut-off on ambient temperature failure (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_tia_dft_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ba2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_reg_cut_vnt_reg_err_2
		"Flag of EGR regulation cut-off in case of supercharging governor error loop (intermediate lVld)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_reg_cut_vnt_reg_err_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_rgbepcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_rgb_pump
		"Robotized gearbox pump activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rgb_pump 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rgn_off_aut
		"Autonomy strategy is on and the maximum distance has been overshooted"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rgn_off_aut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rgn_on_aut
		"Autonomy strategy is on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rgn_on_aut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_rout_run_stt
		"Routine running state (1=one routine running 0=no routine running)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rout_run_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rps_lim
		"Limitation of rail pressure active"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rps_lim 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ada 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rps_sp_slop_on
		"Transient of rail pressure switch for combustion mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rps_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002adb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rst_i_ex_prs_lim
		"Signal defining the correct value to be used for initialising i part"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rst_i_ex_prs_lim 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rst_on
		"Boolean indicating maximal sampling time and minimal fuel flow are reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rst_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d3a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rtn_clos_o2_phs
		"Stored Richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_run_vh
		"Vehicle run detected"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_run_vh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rup_lkg_rup_neg
		"Boolean indicating the dynamic upstream pressure negative conditions for diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rup_lkg_rup_neg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ccc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rup_lkg_rup_pos
		"Boolean indicating the dynamic upstream pressure positive conditions for diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rup_lkg_rup_pos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ccd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rup_lkg_sys_egaf_neg
		"Boolean indicating the dynamic volumic exhaust gas flow negative conditions for diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rup_lkg_sys_egaf_neg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rup_lkg_sys_egaf_pos
		"Boolean indicating the dynamic volumic exhaust gas flow positive conditions for diagnosis"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rup_lkg_sys_egaf_pos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ccf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rupc_ad_ena
		"Flag to allow mean value calculation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rupc_ad_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rupc_ad_end
		"Flag to allow storage of the upstream pressure correction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rupc_ad_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cd1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rupc_cdn_ok
		"Boolean enabling ambiant temperature and pressure conditions for learning process."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rupc_cdn_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_rupc_sens_ena
		"Boolean enabling sensor validity condition for learning process."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rupc_sens_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cd3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_rwhs_ok
		"Criterion of validity of the  rear wheels speeds"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_rwhs_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000281f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_sdl_pws_typ_bc
		"Indicates the SDL power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sdl_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_sens_ex_prs_elec_fail
		"Detection of an electrical failure on the Ex man pres sens"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sens_ex_prs_elec_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_sens_ups_rich_valid
		"Operating state of the upstream proportional sensor signal"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sens_ups_rich_valid 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_set_id_bit6
		"Set the bit 6 of the RC marker"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_set_id_bit6 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002946 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dgaddon_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_set_id_bit7
		"Set the bit 7 of the RC marker"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_set_id_bit7 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002947 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sfty_acs_dsb
		"Accessories deactivation request for safety"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sfty_acs_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sip_frz
		"Vbx_sip_frz"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd000295e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_sitdiag_stbxxd_data.c' */
/begin MEASUREMENT
		Vbx_sit_open
		"Flag indicating that the Smart IT is considered as open."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sit_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_sitmonx_stbxxd_data.c' */
/begin MEASUREMENT
		Vbx_sit_pws_req
		"Request to maintain the power latch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sit_pws_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dsbccxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sl_eng_dsb
		"Engine control request for speed limiter abnormal deactivation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sl_eng_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000294c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dsbccxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sl_eng_dsb_sys
		"Engine control request for speed limiter system deactivation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sl_eng_dsb_sys 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000294d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_slarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sl_mstr
		"Arbitrated powertrain setpoint equal to Speed limiter setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sl_mstr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_slow_clos_req_it
		"Flag for slow egr valve closing request from it closed shut-off path"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_slow_clos_req_it 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000265e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_smk_rich_lim_slop_on
		"Transition switch of the combustion mode for the richness smoke limitation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_smk_rich_lim_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000261a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_spg_ctl_lih
		"Request of boost pressure limp home control due to exhaust pressure sensor failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_spg_ctl_lih 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002638 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_spg_it_cut
		"Boolean flag of open loop activation in case of fail 2 spg sensor validity status"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_spg_it_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000262e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_spg_reg_apl_down
		"Turbocharger negative deviation sample flag"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_spg_reg_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_spg_reg_apl_up
		"Turbocharger positive deviation sample flag"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_spg_reg_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_spg_reg_int_rst
		"Flag of reset of the criteria integration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_spg_reg_int_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgslpx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_spg_slop_on
		"Super Charger slop on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_spg_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002645 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_spg_sp_slop_on
		"Slope switch boolean of boost setpoints function."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_spg_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000264c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sta
		"Booleen indicating if first entry in ISR after start engine"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sta_ac_ptc_dsb
		"Air conditioning and PTC deactivation request for engine start"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sta_ac_ptc_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002def 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sta_alt_dsb
		"Alternator deactivation request for engine start"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sta_alt_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sta_min_tq
		"Flag to detect the staring mode."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sta_min_tq 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sta_swi_act
		"The START button has been pressed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sta_swi_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025f9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_sta_tco_ena
		"Vbx_sta_tco_ena"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002dc5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_stal_acs_dsb
		"Accessories deactivation request for anti-stall"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_stal_acs_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_stal_alt_ac_dsb
		"Consolidated alternator and air conditioning deactivation request for anti-stall"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_stal_alt_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_stal_el_csm_dsb
		"Consolidated electrical consumers deactivation request for anti-stall"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_stal_el_csm_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_star_mod_ign
		"Ignition request on starting mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_star_mod_ign 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_star_mod_no
		"No request on starting mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_star_mod_no 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_star_mod_nok
		"Starting mode value is no valid"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_star_mod_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_star_mod_sta
		"Starting request on starting mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_star_mod_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_star_mod_stop
		"Engine stop request on starting mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_star_mod_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_start_cdn
		"Routine start condtions satisfied (1=satisfied 0=not satisfied)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_start_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_stat_drag_red_agb
		"Drag reduction mode with the temporization between Drive mode -> Drag reduction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_stat_drag_red_agb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_stat_egb_neut
		"Electronic GearBox is in a configuration equivalent to Neutral for a manual gearbox, with the temporization between Drive -> Neut"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_stat_egb_neut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_stop_cdn
		"Routine stop condtions satisfied (1=satisfied 0=not satisfied)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_stop_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ed9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_supl_key_bkup_ok
		"NVMY erasable area of secret key available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_supl_key_bkup_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_supl_key_norm_ok
		"NVMY not erasable area of secret key available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_supl_key_norm_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_swa_pws_typ_bc
		"Indicates the SWA power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swa_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swi_drv_cut
		"Detection of automatic switch on the high engine derivate condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swi_drv_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002629 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swi_drv_cut_n
		"Detection that the engine speed is smaller that the engine speed threshold if engine derivative is high"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swi_drv_cut_n 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002627 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swi_drv_n
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swi_drv_n 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002628 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_cnt_tool_req
		"informs that the learning request has failed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_cnt_tool_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_diag_avl
		"Bit indicating that the Immobiliser diagnosis is available"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_diag_avl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2a7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_diag_ccu
		"Immobiliser diagnosis bit indicating that the engine isn't running due to no BCM authorisation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_diag_ccu 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_diag_ecm
		"Immobiliser diagnosis bit indicating that the engine isn't running due to ECM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_diag_ecm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_diag_mux
		"Immobiliser diagnosis bit indicating that the engine isn't running due to a CAN problem with BCM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_diag_mux 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_diag_tool
		"Immobiliser diagnosis bit indicating that the engine isn't running due to BCM secure mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_diag_tool 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_dsb_ena
		"Indicates if the inhibition of immobilizer strategy is allowed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_dsb_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_ecm_prot_stt
		"protected state of the ECM"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_ecm_prot_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_swlk_pwl_rtn_req
		"request to keep the power before going in protected state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_pwl_rtn_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000b2ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_sys_err
		"VNT error because of airsystem or system error"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_sys_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002639 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_t_end
		"Flag which indicates that the temporal convergence of the filters is OK"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_t_end 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002820 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tac_cdn
		"Indicates if generic actuator test conditions are fulfilled"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002785 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tac_ena
		"Indicates if any I/O control is in progress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002786 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tac_tout
		"Indicates if a timeout occurs when a supplier component is driven"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_tout 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002787 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_adv_cor_frz
		"Flag of freezing the regulator output (1:freeze active, 0:no freeze)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_adv_cor_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002676 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_advsatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_adv_max_slop_on
		"Transition switch of the combustion mode for the maximal advance saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_adv_max_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aa9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_advsatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_adv_min_slop_on
		"Transition switch of the combustion mode for the minimal advance saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_adv_min_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aaa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_dev_cdn
		"flag of deviation temperature before turbine diagnosis condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_dev_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_diag_cdn
		"diagnosic condition status for temperature"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_diag_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ced 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_diag_swi_pup_stt
		"state of pull up commutation (0:100k, 1:1k)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_diag_swi_pup_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fmisatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_fim_main_max_slop_on
		"Transition switch of the combustion mode for the maximal main fuel mass saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_fim_main_max_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fmisatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_fim_main_min_slop_on
		"Transition switch of the combustion mode for the minimal main fuel mass saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_fim_main_min_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fposatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_fpo_max_slop_on
		"Transition switch of the combustion mode for the maximal post fuel mass saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_fpo_max_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_fposatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_fpo_min_slop_on
		"Transition switch of the combustion mode for the minimal post fuel mass saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_fpo_min_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_ig_reg_frz
		"Freezing flag of the I part when the PID output reaches the values of saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_ig_reg_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tqisatx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_max_tqi_min_slop_on
		"Transition switch of the combustion mode for the minimal torque max saturation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_max_tqi_min_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002678 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_pid_slop_on
		"Flag of sloping at regulation switching off (1:sloping on, 0:sloping off)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_pid_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_reg_on
		"Flag of regulation state (1:regulation on, 0:regulation off)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_reg_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002677 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_regactx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_reg_on_aftr_swi
		"Flag of regulation state after switch (1 : regulation on, 0 : regulation off)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_reg_on_aftr_swi 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002aaf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_reg_on_pr
		"Flag of regulation state (1:regulation on, 0:regulation off) in PR mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_reg_on_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002671 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_reg_on_rij
		"Flag of regulation state (1:regulation on, 0:regulation off) in RIJ mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_reg_on_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002672 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_sloponx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_slop_on
		"Combustion mode switch on (1 : transition active, 0 : no transition)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000266e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_spunfil_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tbt_sp_slop_on
		"Transition switch of the combustion mode for the tbt setpoint"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tbt_sp_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000266f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_fanxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tco_ac_dsb
		"Air conditioning deactivation request for engine thermal protection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tco_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002ec1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tco_mdl_cnt
		"Top Dead Center counter"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tco_mdl_cnt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcoospt_cteaubc_data.c' */
/begin MEASUREMENT
		Vbx_tco_sp_l_mod
		"Low cooling temperature mode request (interdiction de rÃ©gulation haute tempÃ©rature avec thermostat pilotÃ©)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tco_sp_l_mod 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_temp_dif_mv_clc_on
		"Flag to display the diagnosis criteria calculation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_temp_dif_mv_clc_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002651 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_temp_max_det_on
		"Maximum EGR temperature calculation state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_temp_max_det_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002652 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_1_cf
		"Confirmed value of default state of THPL level 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_1_cf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_1_fail_fedg_stt
		"State of the falling edge diagnostic on THPL level 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_1_fail_fedg_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_1_fail_stt
		"Fail State of the THPL level 1 after rising edge diagnostic"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_1_fail_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_1_fedg_ena
		"Flag of diagnostic test on THPL level 1 after a falling edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_1_fedg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_1_redg_ena
		"Flag of diagnostic test on THPL level 1 after a rising edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_1_redg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_2_cf
		"Confirmed value of default state of THPL level 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_2_cf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_2_fail_fedg_stt
		"State of the falling edge diagnostic on THPL level 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_2_fail_fedg_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_2_fail_stt
		"Fail State of the THPL level 2 after rising edge diagnostic"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_2_fail_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_2_fedg_ena
		"Flag of diagnostic test on THPL level 2 after a falling edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_2_fedg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_2_redg_ena
		"Flag of diagnostic test on THPL level 2 after a rising edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_2_redg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_3_cf
		"Confirmed value of default state of THPL level 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_3_cf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_3_fail_fedg_stt
		"State of the falling edge diagnostic on THPL level 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_3_fail_fedg_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_3_fail_stt
		"Fail State of the THPL level 3 after rising edge diagnostic"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_3_fail_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_3_fedg_ena
		"Flag of diagnostic test on THPL level 3 after a falling edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_3_fedg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_3_redg_ena
		"Flag of diagnostic test on THPL level 3 after a rising edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_3_redg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_4_cf
		"Confirmed value of default state of THPL level 4"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_4_cf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_4_fail_fedg_stt
		"State of the falling edge diagnostic on THPL level 4"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_4_fail_fedg_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_4_fail_stt
		"Fail State of the THPL level 4 after rising edge diagnostic"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_4_fail_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_4_fedg_ena
		"Flag of diagnostic test on THPL level 4 after a falling edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_4_fedg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_4_redg_ena
		"Flag of diagnostic test on THPL level 4 after a rising edge"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_4_redg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_alt_pwm_err_sgn
		"Error sign of alternator PWM governor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_alt_pwm_err_sgn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_cf_cdi
		"Clear Diagnostic Information"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_cf_cdi 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_cmd1
		"State of coolant heater 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_cmd1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_cmd2
		"State of coolant heater 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_cmd2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_cmd3
		"State of coolant heater 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_cmd3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_cut
		"thp cut state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_cut2
		"thp cut state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_cut2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_diag_alt_pwm_ena
		"Flag of diagnostic test on all THP after a Alt PWM test"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_diag_alt_pwm_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_diag_pwm_ena
		"Flag of diagnostic test on each THP during a Alt PWM test"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_diag_pwm_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_dsb_req
		"Coolant heaters deactivation request before coordination"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_dsb_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029fb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_eng_dsb
		"Coolant heaters deactivation request for engine needs"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_eng_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_eng_frz
		"Coolant heaters freezing request for engine needs"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_eng_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_err_sgn
		"Error sign of coolant heater governor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_err_sgn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_fedg
		"Falling edge of any THP level"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_fedg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcooctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcooctl_chctlxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_frz
		"thp freeze state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_frz2
		"thp freeze state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_frz2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d49 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_ini_eprm
		"Init EEPROM state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_ini_eprm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_int_lim
		"Limitation state of thp governor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_int_lim 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_is_acel
		"Thermoplunger idle speed setpoint acceleration request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_is_acel 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d47 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_redg
		"Rising edge after an activation of a element"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_redg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_tot_cf
		"Confirmed value of default state of some elements (one or more)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_tot_cf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_thpl_vb_err_sgn
		"Error sign of voltage governor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_thpl_vb_err_sgn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tkof_acs_dsb
		"Accessories deactivation request for takeoff"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tkof_acs_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tkof_alt_ac_dsb
		"Consolidated alternator and air conditioning deactivation request for takeoff"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tkof_alt_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tkof_ass_spt_pdl_cdn
		"Detection of a sportive take off."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tkof_ass_spt_pdl_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tkof_el_csm_dsb
		"Consolidated electrical consumers deactivation request for takeoff"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tkof_el_csm_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029fd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_tkodlxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tkof_vs_ena
		"Active the take off"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tkof_vs_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002615 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tmp_df_esp_data_chr
		"Single ESP torque request coherency failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tmp_df_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002800 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_absctxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tmp_df_esp_data_seq_ctr
		"Single ESP frame sequence counter failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tmp_df_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002801 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_toil_pws
		"Boolean used to ask ECU electrical supply for oil temperature computing"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_toil_pws 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tq_rams_lim_act_1
		"Activation of safety torque limitation level 1 (low)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_rams_lim_act_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tq_rams_lim_act_2
		"Activation of safety torque limitation level 2 (mean)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_rams_lim_act_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_fstqcfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tq_rams_lim_act_3
		"Activation of safety vehicle speed limitation converted in torque limitation level 3 (strong)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_rams_lim_act_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dd7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimpmx.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimpmx_fstqprj_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tq_rams_lim_spc_act_1
		"Specific activation of safety torque limitation level 1 (low)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_rams_lim_spc_act_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimpmx.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimpmx_fstqprj_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tq_rams_lim_spc_act_2
		"Specific activation of safety torque limitation level 2 (mean)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_rams_lim_spc_act_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimpmx.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimpmx_fstqprj_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tq_rams_lim_spc_act_3
		"Specific activation of safety vehicule speed converted in torque limitation level 3 (strong)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_rams_lim_spc_act_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'outqotqd_tqrqstt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tq_req_stt_01
		"Torque request status set to 01b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_req_stt_01 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025dd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'outqotqd_trnstrs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tq_req_stt_10
		"Torque request status set to 10b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_req_stt_10 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'outqotqd_tqrqstt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tq_req_stt_11
		"Torque request status set to 11b"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_req_stt_11 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_sloponx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tq_slop_on
		"Torque set point slop on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002622 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pctraarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pctraarb_arbitxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tq_trs_ctl_mux
		"Transient intersystem torque request in progress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tq_trs_ctl_mux 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_aftrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_aftr_efy_slop_on
		"Transition switch of the combustion mode for the torque model of the after injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_aftr_efy_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_fim_tot_slop_on
		"Transition switch of the combustion mode for the torque model of the total fuel mass"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_fim_tot_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000261e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_fms_lp_efy_slop_on
		"Transition switch of the combustion mode for the late post injection efficient fuel flow"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_fms_lp_efy_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000261f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_max_fim_slop_on
		"Transition switch of the combustion mode for the maximum torque due to maximum injected fuel mass"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_max_fim_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002620 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_max_rich_slop_on
		"maximum torque transition active (combustion mode)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_max_rich_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002618 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_max_slop_on
		"maximum torque transition active (combustion mode)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_max_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002617 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_max_tbt_slop_on
		"maximum torque transition active (combustion mode)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_max_tbt_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002619 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_ocd_ena
		"Authorisation of torque compensation activation in ocd mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_ocd_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_post_efy_slop_on
		"Transition switch of the combustion mode for the torque model of the post injection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_post_efy_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_rst_ocd
		"Initialisation of first ordre filter in torque compensation calculation in ocd mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_rst_ocd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tqi_smk_slop_on
		"Transition switch of the combustion mode for the smoke limitation torque"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tqi_smk_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002621 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_tran_req
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tran_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000263a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_trs_eng_aut
		"Transition used to past in the autonomous state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_trs_eng_aut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002616 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcoospt_cteaubc_data.c' */
/begin MEASUREMENT
		Vbx_tsta_ip_dft_lght_tco_h_sp
		"Switching to high temperature mode for the overheating alert lamp in the dashboard."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tsta_ip_dft_lght_tco_h_sp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_tceauxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_tsta_ip_trs_l_mux
		"Boolean of changing mode for Information panel (delayed when changing from High temperature to Low temperature mode)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tsta_ip_trs_l_mux 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_up_shf_blk_cur
		"Vbx_up_shf_blk_cur"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002951 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ups_rich_clc_stt
		"Status of the calculated richness"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ups_rich_clc_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_ups_rich_stt
		"Status of the upstream proportional sensor richness"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ups_rich_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_usm_pws_typ_bc
		"Indicates the USM power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_usm_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_routmng_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_valid_req
		"Tool request validity (1=valid request 0=invalid request)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_valid_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eda 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_floatcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_vb_flot_dsb
		"Battery voltage floating inhibition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vb_flot_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_floatxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vb_flot_dsb_req
		"Battery voltage floating deactivation requested by gazoline/diesel engine"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vb_flot_dsb_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invficri_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_vh_key
		"Data indicating if the key vehicle is present (1=vehicle with key)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vh_key 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002818 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_virt_driv_on
		"Accelerator pedal request overrun by a virtual driver (CC/SL/ACC)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_virt_driv_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000260f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpolcco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_ctl_slop_on
		"Slope on boolean of vnt open loop function."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_ctl_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a25 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_air_sys
		"VNT error because of airsystem"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_air_sys 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000263b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_cut
		"Shut off flag for VNT"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000262f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_inhi
		"Inhibition of supercharger regulation deviation diagnostic in case of invalid component"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_inhi 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002630 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_inhi_air_sys
		"Inhibition of supercharger regulation deviation diagnostic in case of invalid air system component"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_inhi_air_sys 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000263c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_inhi_ex_prs
		"Inhibition of supercharger regulation deviation diagnostic in case of invalid exhaust pressure leakage"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_inhi_ex_prs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000263d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_inhi_gov_dev
		"Inhibition of supercharger regulation deviation diagnostic in case of governor deviation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_inhi_gov_dev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000263e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_inhi_inj_sys
		"Inhibition of supercharger regulation deviation diagnostic in case of invalid injection system"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_inhi_inj_sys 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000263f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_ok_vld
		"Flag of validity status for diagnostic conditions of the turbo fulfilled"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_ok_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_stt_ok
		"Flag of diagnostic conditions of the turbo fulfilled"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_stt_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a1a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_diag_stt_ok_ex_prs
		"Flag of exhaust pressure diagnostic conditions of the turbo fulfilled"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_diag_stt_ok_ex_prs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a1b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_emtv_i_init
		"Initialisation condition in case of emtv closure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_emtv_i_init 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_err_sgn
		"Sign of the governor error for manifold air pressure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_err_sgn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_err_sgn_cge_h
		"Flag of manifold air pressure governor error sign change from negative to positive"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_err_sgn_cge_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcdmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_err_sgn_cge_l
		"Flag of manifold air pressure governor error sign change from positive to negative"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_err_sgn_cge_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_ex_ctl_lih_ena
		"Activation state signal  of exhaust pressure regulation in case of boost pressure sensor failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_ex_ctl_lih_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002640 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_ex_lim_act
		"Activation state signal of exhaust pressure limitation strategy"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_ex_lim_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002631 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_ex_lim_tia_cold_cut
		"Flag of exhaust pressure limitation shut off in case of cold intake air temperatures"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_ex_lim_tia_cold_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002632 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_ex_reg_i_fac_slop_on
		"Sloping Flag of vnt_ex_reg_fac_switch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_ex_reg_i_fac_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_i_frz
		"Flag of the I part freezing"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_i_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_reg_dev
		"Governor deviation detected"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_reg_dev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002641 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_reg_dev_zon_0
		"Governor deviation detected in working zone 0"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_reg_dev_zon_0 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_reg_dev_zon_2
		"Governor deviation detected in working zone 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_reg_dev_zon_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_reg_dev_zon_3_4
		"Governor deviation detected in working zone 3 or 4"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_reg_dev_zon_3_4 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_reg_dfz_fac_slop_on
		"Sloping Flag of vnt_reg_dfz_fac switch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_reg_dfz_fac_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_reg_ena
		"Flag to enable the governor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_reg_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_reg_i_fac_slop_on
		"Sloping flag of vnt_reg_i_fac switch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_reg_i_fac_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_sge_act
		"Authorisation of anti-surge activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_sge_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a35 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_sge_ena
		"Activation calibration of anti-surging mode after combustion mode arbitration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_sge_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_tran_on
		"Switch signal from Control pwm to Transient pwm (before opening)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_tran_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000264b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_bpcpcox_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_vnt_tran_pwm_slop_on
		"Sloping Flag of vnt_tran_pwm switch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vnt_tran_pwm_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_vs_abst_fil
		"Vehicle speed received on the CAN network not present after a filtering time"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vs_abst_fil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002609 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_setptxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_vs_clos_spt_lamp
		"Cruise control and speed limiter : the speed is reaching the setpoint (sent on the CAN network)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vs_clos_spt_lamp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00025f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_vs_n_rat_fil_on
		"Filtered value of Vehicle Speed/Neng ratio is used (1) to calculate the gear ratio"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vs_n_rat_fil_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_vs_navl_fil
		"Vehicle speed received on the CAN network not available after a filtering time"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vs_navl_fil 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000260a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_vsintxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_vs_nok
		"Invalid or absent vehicle speed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_vs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000260b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_wait_cdn_on
		"Flag indicating waiting mode acttivated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wait_cdn_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_wait_cdn_temp
		"Waiting mode on failure has been requested"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wait_cdn_temp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002c78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wal_1_req
		"Global warning lamp 1 activation request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wal_1_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wal_2_req
		"Global warning lamp 2 activation request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wal_2_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acwfinx_stbxxx_data.c' */
/begin MEASUREMENT
		Vbx_wf_ac_req
		"Climate cooling request from wire"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wf_ac_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_schedul_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wg_abst_pres_cfm
		"Fixed nozzle turbine with wastegate present"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wg_abst_pres_cfm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wpmp_tcr
		"Turbo water cooling pump command before monitool"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wpmp_tcr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d81 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wpmp_tcr_cmd
		"Turbo water cooling pump command"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wpmp_tcr_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d83 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wpmp_tcr_pws
		"Boolean to maintain the water pump ECU power supply"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wpmp_tcr_pws 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wpmp_tcr_stop
		"Mémorization of turbo water pump"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wpmp_tcr_stop 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wup
		"Current warm-up detection state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_wup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002cb3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wup_cata_dsb
		"Vbx_wup_cata_dsb"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd0002dc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_wup_cata_ena
		"Vbx_wup_cata_ena"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd000295a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		VehicleSpeed
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER VehicleSpeed 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000189e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ac_cmd
		"Air conditioning compressor command"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vsx_ac_cmd 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00019ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ac_prs_vld
		"Relative air conditioning pressure validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_ac_prs_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cd0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciacc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciacc_noaccxx_data.c' */
/begin MEASUREMENT
		Vsx_acc_sdl_ctl_typ
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER VSX_ACC_SDL_CTL_TYP 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000253d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_acel_pdl_pwt_sp_vld
		"Powertrain setpoint (%) requested by the driver via the accelerator pedal validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_acel_pdl_pwt_sp_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001dbf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_acel_pdl_rat_vld
		"Normalised acelerator pedal position"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_acel_pdl_rat_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c17 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_acel_pdl_sens_v1_vld
		"Accelerator pedal sensor output voltage : track 1 validity status"
		UBYTE
		Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_acel_pdl_sens_v1_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c18 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_acel_pdl_v_vld
		"Normalised acelerator pedal position"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_acel_pdl_v_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c19 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_acr_stt
		"AC compressor management phases"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_acr_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attcscs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_agb_coup
		"Automatic gearbox coupler state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_agb_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attcscs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_agb_coup_vld
		"Automatic gearbox coupler state validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_agb_coup_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c59 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_agb_csm_tq_vld
		"Converter friction torque validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_agb_csm_tq_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c0c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_agbxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_agb_is_acel_req_vld
		"Idle speed setpoint acceleration by AT is requested validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_agb_is_acel_req_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_agbspcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_agb_is_acel_sp_vld
		"Automatic Transmission idle speed setpoint acceleration required validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_agb_is_acel_sp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022fb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_agb_vld
		"Automatic GearBox validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_agb_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_air_in_sys_vld
		"Air intake system validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_air_in_sys_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_air_reg_2_vld
		"Air regulation intermediate 2 validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_air_reg_2_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000203a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_air_reg_3_vld
		"Air regulation intermediate 3 validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_air_reg_3_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000203b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_air_reg_vld
		"Air regulation validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_air_reg_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ajs_cor_stt_para
		"State variable to select AJCOR parameters"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		1.
		5.
    DISPLAY_IDENTIFIER Vsx_ajs_cor_stt_para 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000198c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ajs_dt_tq_rat_vld
		"Gear torque ratio : wheel_torque/engine_torque (tuned with gear ratio) validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_ajs_dt_tq_rat_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001dd4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ajs_modu_stt_para
		"State variable to select AJMOD parameters"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		5.
    DISPLAY_IDENTIFIER Vsx_ajs_modu_stt_para 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001dc9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ajs_spv_stt_para
		"State variable to select anti-jerk parameters"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		5.
    DISPLAY_IDENTIFIER Vsx_ajs_spv_stt_para 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001dd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_alt_pow_vld
		"Alternator mechanical power validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_alt_pow_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022fd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_alt_pwm_vld
		"Alternator load validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_alt_pwm_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cd5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
