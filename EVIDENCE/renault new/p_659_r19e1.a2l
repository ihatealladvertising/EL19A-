/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_amp_vld
		"Atmospheric pressure validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_amp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ant_coup_vld
		"Anticipated (forecast) transmission coupler state validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_ant_coup_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_antxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ant_crt_slc
		"Anticipated current gear shift"
		UBYTE
		Brgjoob_bBymenb_rozDxfc_n1n2dax
		1
		100
		1.
		3.
    DISPLAY_IDENTIFIER Vsx_ant_crt_slc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c0a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_antxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ant_crt_slc_vld
		"Anticipated current gear shift validity status"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_ant_crt_slc_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c0b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ant_gear
		"Anticipated gear engaged"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_ant_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001c7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ant_gear_vld
		"Anticipated gear engaged validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_ant_gear_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ant_rat_gear
		"Anticipated Ratio Gear: identified with large true range of the ratio Vspeed/Neng."
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_ant_rat_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0002007 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapmxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_apmp_free_shf_mod
		"Vsx_apmp_free_shf_mod"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001d8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciesp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciesp_espxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_asr_msr_typ
		"Torque control type"
		UBYTE
		sdjirsa_kAEhhma_hlsAEfc_n_q_ors
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vsx_asr_msr_typ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022f9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_clu_nok_mgb_ant_coup
		"Anticipated coupler state calculated when begin clutch contactor is defective"
		UBYTE
		gFhcrdc_ukljqcc_zFmtlua__1csc8c
		1
		100
		1.
		8.
    DISPLAY_IDENTIFIER Vsx_bgin_clu_nok_mgb_ant_coup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001caa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_clu_nok_mgb_coup
		"Coupler state calculated when begin clutch contactor is defective"
		UBYTE
		gFhcrdc_ukljqcc_zFmtlua__1csc8c
		1
		100
		1.
		8.
    DISPLAY_IDENTIFIER Vsx_bgin_clu_nok_mgb_coup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_clu_nok_mgb_coup_vld
		"Coupler state calculated when begin clutch contactor is defective validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_bgin_clu_nok_mgb_coup_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_clu_ok_mgb_ant_coup
		"Anticipated coupler state calculated when begin clutch contactor is functional"
		UBYTE
		gFhcrdc_ukljqcc_zFmtlua__1csc8c
		1
		100
		1.
		8.
    DISPLAY_IDENTIFIER Vsx_bgin_clu_ok_mgb_ant_coup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_clu_ok_mgb_coup
		"Coupler state calculated when begin clutch contactor is functional"
		UBYTE
		gFhcrdc_ukljqcc_zFmtlua__1csc8c
		1
		100
		1.
		8.
    DISPLAY_IDENTIFIER Vsx_bgin_clu_ok_mgb_coup 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_clu_ok_mgb_coup_vld
		"Coupler state calculated when begin clutch contactor is functional validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_bgin_clu_ok_mgb_coup_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001caf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clb2xcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_str_clu_cnt
		"Begin stroke clutch pedal switch"
		UBYTE
		lfldkha_AFwjwnb_tkAxmyc_n_sfsnx
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_bgin_str_clu_cnt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c63 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clb2xcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_str_clu_cru
		"Begin stroke clutch pedal switch for cruise control"
		UBYTE
		lfldkha_AFwjwnb_tkAxmyc_n_sfsnx
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_bgin_str_clu_cru 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clb2xcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_str_clu_cru_rams
		"Begin stroke clutch pedal switch for cruise control safety"
		UBYTE
		lfldkha_AFwjwnb_tkAxmyc_n_sfsnx
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_bgin_str_clu_cru_rams 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clb2xcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_bgin_str_clu_cru_vld
		"Begin stroke clutch pedal switch for cruise control validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_bgin_str_clu_cru_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_brk1xcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_brk_pdl
		"Brake pedal states"
		UBYTE
		EvAetkc_wufdhja_gbEzBsd______4p
		1
		100
		1.
		4.
    DISPLAY_IDENTIFIER Vsx_brk_pdl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_brk1xcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_brk_pdl_cru_vld
		"Brake pedal states for cruise controlvalidity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_brk_pdl_cru_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_cnbkocs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_brk_pdl_open
		"Open active brake switch"
		UBYTE
		eDlybpa_szqqFga_puaotid___N_fs_
		1
		100
		1.
		2.
    DISPLAY_IDENTIFIER Vsx_brk_pdl_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_cnbkocs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_brk_pdl_open_vld
		"Open active brake switch validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_brk_pdl_open_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_brk1xcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_brk_pdl_vld
		"Brake pedal states validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_brk_pdl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_bas_mod
		"Active combustion mode (=1 :normal, =2 :catalyst heating, =3 :rgn, =4 wait mode)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_bas_mod 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00020d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcms.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcms_combsta_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_mod_act
		"Acted value of the combustion mode"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_mod_act 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_mod_req
		"Requirement value for combustion mode"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_mod_req 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019eb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_cmreqas_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_mod_req_air
		"Requirement value of AS combustion mode"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_mod_req_air 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_mod_req_egt
		"Requirement of exhaust gas tratement value of the combustion mode"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_mod_req_egt 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00020d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_mod_req_old
		"Requirement of exhaust gas treatment old value of the combustion mode"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_mod_req_old 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_mod_req_spv
		"Supervisor requirement combustion mode before the bench mode"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_mod_req_spv 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbspvcmr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbspvcmr_cmreqtq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_comb_mod_req_tq
		"Requirement value of combustion mode specified by torque model"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER Vsx_comb_mod_req_tq 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_coup_vld
		"Coupler state (1 : closed ; 2 : sliding ; 8 : open) validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_coup_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_cru_sl_on_off
		"CC or SL strategy requested by the driver"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_cru_sl_on_off 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_cru_sl_on_off_raw
		"State of the on off main switch before filtering"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_cru_sl_on_off_raw 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00022f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcicci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcicci_swtchsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_cru_sl_swi_vld
		"CCSL switches function validity status: Vsx_cru_sl_swi_vld != Nsx_vld_ok_1 significates that the switches function is out of order"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_cru_sl_swi_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00022f5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_cru_stt
		"Cruise control state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_cru_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001969 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_cru_vld
		"Cruise control validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_cru_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_ctlcsmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_csm_sum_sta_vld
		"Injected fuel quantity per second validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_csm_sum_sta_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_diag_byp_stt
		"Actual state in criteria calculation stateflow"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_diag_byp_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_diag_ov_polu_zon_rls_stt
		"Release status on extra polu zones for diagnosis"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1023.
    DISPLAY_IDENTIFIER Vsx_diag_ov_polu_zon_rls_stt 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006494 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_diag_polu_zon_rls_stt
		"Release status on polu zones for diagnosis"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1023.
    DISPLAY_IDENTIFIER Vsx_diag_polu_zon_rls_stt 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006496 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtser_docserx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_diag_sess
		"Diagnostic session table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_diag_sess 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00022a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_monispv_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_diag_sta_moni_stt
		"Monitool routine status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_diag_sta_moni_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b11 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_diag_sta_ndec_stt
		"ndec routine status"
		UBYTE
		iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_diag_sta_ndec_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000236d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_istatun_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_diag_sta_ninc_stt
		"ninc routine status"
		UBYTE
		iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_diag_sta_ninc_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000236e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_diag_sta_rpft_stt
		"rpft routine status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		3
    DISPLAY_IDENTIFIER Vsx_diag_sta_rpft_stt 
    ECU_ADDRESS 0xd0002054 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_diag_sta_stac_stt
		"Supplier actuator LID intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_diag_sta_stac_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bcb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_diag_sta_tefi_stt
		"tefi routine status"
		UBYTE
		iqAxxwa_FdjpmEd_dgjwnca_nx_g_ni
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_diag_sta_tefi_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d36 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_dlin_conf
		"State data of driveline configuration (Transmission type)."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_dlin_conf 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_doc1_mdl_utp_vld
		"Model of gas temperature before doc1 validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_doc1_mdl_utp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1cs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_doc1_utp_vld
		"DOC up temp sensor measure validity indicator"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_doc1_utp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022c5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc2cs_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_doc2_utp_vld
		"temperature before oxidation 2 validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_doc2_utp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_doc_dtp_vld
		"Local variable for DOC downstream temperature validity status"
		UBYTE
		RB_CONV_AtCatDgn_Vld_Status_2
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_doc_dtp_vld 
    ECU_ADDRESS 0xd000203d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_drag_red_agb_vld
		"Drag reduction mode validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_drag_red_agb_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c5d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vsx_driv_cut_req
		"injection cut requested by driver"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_driv_cut_req 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_driv_pwt_sp_vld
		"Powertrain setpoint (%) requested by real (pedal) and virtual (ACC/CC/SL) drivers validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_driv_pwt_sp_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000198b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dsplvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_dspl_vs_vld
		"Displayed vehicule speed validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_dspl_vs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cdf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_diaginj_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_efi_inj_sys_vld
		"Validity status for the exhaust injection"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_efi_inj_sys_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_efi_itl_ar_temp_vld
		"Exhaust fuel injector surface temperature validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_efi_itl_ar_temp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgpumpx_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_efi_pump_vld
		"Validity status for the pump of the fifth injector system"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_efi_pump_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d37 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_dgsldvx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_efi_sldv_vld
		"Validity status for the solenoid valve of the fifth injector system"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_efi_sldv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d3b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_ant_coup
		"Anticipated (forecast) transmission coupler state for automatic transmission"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_egb_ant_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_ant_coup_vld
		"Anticipated transmission coupler state for automatic transmission validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_egb_ant_coup_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_ant_gear
		"Target gear due to electronic gearbox"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_egb_ant_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001c93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_ant_gear_vld
		"Target gear due to electronic gearbox validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_egb_ant_gear_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_coup
		"Automatic Transmission coupler state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_egb_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_coup_vld
		"Automatic Transmission coupler state validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_egb_coup_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_gear
		"Current gear due to electronic gearbox"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_egb_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001c97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tadlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_gear_vld
		"Current gear due to electronic gearbox validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_egb_gear_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_egb_neut_vld
		"Electronic GearBox in a configuration equivalent to Neutral for a manual gearbox validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_egb_neut_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asegrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asegrctl_ecbvdxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_egr_byp_blk_vld
		"EGR bypass valve validity status"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_egr_byp_blk_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00019b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_bypxcmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_egr_byp_vld
		"Validity criteria of the EGR bypass"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_egr_byp_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001cee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_egr_off
		"Flag of egr regulation off"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_egr_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002658 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_egt_tq_lim_vld
		"particulate filter torque limitation request validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_egt_tq_lim_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00020d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_emtv_0_vld
		"EMTV validity status applied for EGR valve control"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_emtv_0_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cf2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_emtv_pos_sat
		"Flag for saturation of EGR valve position"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_emtv_pos_sat 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a8f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_emtv_psn_vld
		"EMTV sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_emtv_psn_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bdc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_emtv_vld
		"EMTV validity status"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_emtv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cf3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invficri_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ena_sta_agb
		"AT Starter authorization or stop"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_ena_sta_agb 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cd1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ena_sta_agb_ecm
		"AT recopy Starter authorization or stop"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_ena_sta_agb_ecm 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001e44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invficri_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ena_sta_agb_vld
		"AT Starter authorization or stop validity status"
		UBYTE
		itzAFCa_walhowa_fCBrBqc___kv_i_
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_ena_sta_agb_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cd2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ena_sta_ecm
		"Data indicating the cranking authorization ECM"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vsx_ena_sta_ecm 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001e45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clexxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_end_str_clu_cnt
		"End stroke clutch pedal switch"
		UBYTE
		rzlnwjb_BlbxuAc_tkosmyc___xfxnx
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_end_str_clu_cnt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_eng
		"Engine states"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_eng 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000198e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_lossxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_eng_tql_vld
		"Engine torque losses validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_eng_tql_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001990 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_ex_prs_vld
		"Exhaust manifold pressure validity status"
		UBYTE
		itzAFCa_walhowa_fCBrBqc___kv_i_
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_ex_prs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bfc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_fast_off_free_shf_mod
		"Vsx_fast_off_free_shf_mod"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001d9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_fast_on_free_shf_mod
		"Vsx_fast_on_free_shf_mod"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001d9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_fil_alt_pow_vld
		"Filtered  Alternator torque load validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_fil_alt_pow_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ccf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_actinjx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_fms_act_inj
		"state of activated injections : bit 2: Pinj1; bit 3: Pinj2; bit 4: Main; bit 5: After; bit 6: Post; bit 7: LPost1; bit 8: LPost2"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		254.
    DISPLAY_IDENTIFIER Vsx_fms_act_inj 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ec3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_actinjx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_fms_shf_inj
		"State of the modification of the inj: bit 2: Pinj1; bit 3: Pinj2; bit 4; -; bit 5: After; bit 6: Post; bit 7: LPost1; bit 8: LPost2"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		254.
    DISPLAY_IDENTIFIER Vsx_fms_shf_inj 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ec4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_free_shf_dspl
		"Vsx_free_shf_dspl"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001d91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsgihxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_frz_free_shf_mod
		"Vsx_frz_free_shf_mod"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001da3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_gear
		"Gear engaged"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001c7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_gear_vld
		"Gear engaged ( [-1 0 1 2 3 4 5 6] ) validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_gear_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_is
		"State variable of idle speed regulation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_is 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001de9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_cfdgiss_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_is_inj_vld
		"Injection validity status for Idle Speed"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_is_inj_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000236b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_is_raw
		"State variable of idle speed regulation without consolidation"
		UBYTE
		zidvspc_fBftdda_rbmFAla_nssN_34
		1
		100
		2.
		64.
    DISPLAY_IDENTIFIER Vsx_is_raw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001de7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_air_reg
		"Flag of air regulation without egr valve (only with inlet throttle)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_air_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a91 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_schxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_cfm
		"Inlet throttle configuration"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_it_cfm 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001956 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_ena_pp
		"Variable which allow the Thottle Saturation Mode if EGR control is shut-off in rgn_prmt mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_ena_pp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_ena_pr
		"Variable which allow the Thottle Saturation Mode if EGR control is shut-off in rgn mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_ena_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_ena_rij
		"Variable which allow the Thottle Saturation Mode if EGR control is shut-off in rij mode"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_ena_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_psn_vld
		"Inlet throttle position validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_psn_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bfb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_sat_co
		"Consolidation value of Vsx_thr_sat (before Monitool)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_sat_co 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_sat_co_swt
		"Flag for throttle saturation mode after the monitool switch"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_sat_co_swt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_sat_ena
		"Flag for enabling the Throttle Saturation Mode  (i.e. Vsx_thr_air_reg is false)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_sat_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_sat_pp
		"Value of Vsx_thr_sat in combustion mode = 4"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_sat_pp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitspr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_sat_pr
		"Value of Vsx_thr_sat in combustion mode = 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_sat_pr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsri_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_sat_rij
		"Value of Vsx_thr_sat in combustion mode = 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_sat_rij 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_itsxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_use
		"Flag indicating that the use of the inlet throttle is allowed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_use 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a93 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_cuitsco_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_use_drg_so
		"Flag indicating that the use of the inlet throttle is allowed even during maf control shut-off."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_it_use_drg_so 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itcoxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_vld
		"Inlet Throttle validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_it_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_it_vld_0
		"Inlet throttle validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_it_vld_0 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_law_free_shf_mod
		"Vsx_law_free_shf_mod"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001da4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_law_sel
		"Vsx_law_sel"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001dad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_rwsxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_lft_rwhs_vld
		"Rear left wheel speed validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_lft_rwhs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ce2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_load_lvl
		"Vsx_load_lvl"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001dae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_maf_dyn_kgh_vld
		"Dynamic mass air flow in kg/h validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_maf_dyn_kgh_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_maf_dyn_vld
		"Dynamic mass air flow validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_maf_dyn_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_maf_kgh_vld
		"Mass air flow in kg/h validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_maf_kgh_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_amfcdmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_maf_reg_neg_err_vld
		"Mass airflow regulation negative error validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_maf_reg_neg_err_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00019bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_maf_vld
		"Mass air flow validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_maf_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_map_vld
		"Manifold pressure validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_map_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mc
		"Micro cut detection"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_mc 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001de8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_ac_acel_is_sp_vld
		"Accelerated engine idle speed setpoint request for air conditionning from model validity status"
		UBYTE
		DbqmAvc_FCazhwd_yFuDCFc_B3x__2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_ac_acel_is_sp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_ac_pow_vld
		"Air conditioning power received from model validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_ac_pow_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxmd_stbxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_alt_pow_vld
		"Modelised alternator power validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_mdl_alt_pow_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00022fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_ex_prs_vld
		"Exhaust manifold pressure from model validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_ex_prs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_maf_dyn_cs_vld
		"Dynamic mass air flow validity status, after drift sensor diagnosis"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_maf_dyn_cs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafdymd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_maf_dyn_vld
		"Dynamic mass air flow from model validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_maf_dyn_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bdf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_icmafmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_maf_ic_vld
		"Mass air flow without EGR estimator validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_maf_ic_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bde 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_fmafmdx_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_maf_vld
		"Mass air flow from model validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_maf_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001bdd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxmd_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_map_vld
		"Manifold pressure from model validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_map_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001beb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_exprsmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_pft_down_prs_vld
		"Downstream pressure model validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_pft_down_prs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_tco
		"State of Tco model"
		UBYTE
		dBCtsuc_hqDqtlb_iowwora_n_1a__x
		1
		100
		0.
		30.
    DISPLAY_IDENTIFIER Vsx_mdl_tco 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_tco_vld
		"Engine coolant temperature model validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_tco_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c09 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_tco_vld_2
		"Engine coolant temperature model validity status 2"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_tco_vld_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_toil_vld
		"Modelised oil temperature validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_toil_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelmd_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mdl_tra_acel_vld
		"Transverse acceleration calculated from rear wheel speed validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mdl_tra_acel_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_mdl_up_it_temp_vld
		"Upstream throttle air temperature model validity status"
		UBYTE
		Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_mdl_up_it_temp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bfa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mgb_ant_coup
		"Manual transmission anticipated coupler state (faster opening and closing detection / Vxx_coup)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_mgb_ant_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cb1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mgb_ant_gear
		"Anticipated gear engaged due to manual gearbox"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_mgb_ant_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001cb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mgb_coup
		"Manual transmission coupler state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_mgb_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cb3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mgb_coup_vld
		"Manual transmission coupler state validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mgb_coup_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001cb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mgb_gear
		"Gear engaged due to manual gearbox"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_mgb_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001cb5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mgb_gear_vld
		"Gear engaged due to manual gearbox validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mgb_gear_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001cb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcabsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_abs_reg_vld
		"ABS in regulation received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_mux_abs_reg_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002142 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ac_acel_is_sp_vld
		"Accelerated engine idle speed setpoint request for air conditionning from CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_ac_acel_is_sp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ac4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfacxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ac_clu_req_vld
		"air conditionning compressor request sent from AC ECU to USM (M3 architecture) validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_ac_clu_req_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001afe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ac_mdf_req_vld
		"Fans activation request from air conditioning ECU received on the CAN network validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_ac_mdf_req_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ac5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqacxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ac_pow_vld
		"air conditionning power received from CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_ac_pow_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000214d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ac_req_ext_vld
		"Climate cooling request from AC ECU validity status"
		UBYTE
		itzAFCa_walhowa_fCBrBqc___kv_i_
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_ac_req_ext_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ad0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ac_req_int_vld
		"Climate cooling request from CAN ECU (when cold loop is in ECM) validity status"
		UBYTE
		itzAFCa_walhowa_fCBrBqc___kv_i_
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_ac_req_int_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ad1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ac_req_vld
		"Climate cooling request from CAN network validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_ac_req_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ac6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smacsin_stbxxx_data.c' */
/begin MEASUREMENT
		Vsx_mux_acs_acel_is_req_vld
		"Request of idle speed acceleration for accessories received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_acs_acel_is_req_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002147 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_agb_coup
		"Automatic gearbox coupler state received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_mux_agb_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ab8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_agb_coup_vld
		"Automatic gearbox coupler state received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_agb_coup_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ab9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_agb_csm_tq_vld
		"Converter friction torque received on the CAN validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_agb_csm_tq_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001aa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smat1in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_agb_is_acel_req_vld
		"CAN message validity : Idle speed setpoint acceleration request by AT"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_agb_is_acel_req_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002148 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smat2in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_agb_is_acel_sp_vld
		"Automated Gearbox idle speed setpoint CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_agb_is_acel_sp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ad6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_agb_mdf_req_vld
		"Fans activation request from AGB received on the CAN network validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_agb_mdf_req_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ac7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcatqin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_agb_tq_ctl_typ
		"AGB Torque control type"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_mux_agb_tq_ctl_typ 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001aa5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqpalin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_alt_pow_vld
		"Alternator power from CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_alt_pow_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ade 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfadfin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_alt_pwm_vld
		"Multiplexed alternator load validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_alt_pwm_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ant_crt_slc
		"Anticipated current gear shift received on the CAN"
		UBYTE
		Brgjoob_bBymenb_rozDxfc_n1n2dax
		1
		100
		1.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_ant_crt_slc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001aba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ant_crt_slc_vld
		"Anticipated current gear shift received on the CAN validity status"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_mux_ant_crt_slc_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001abb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfpdain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_aod_vs_vld
		"Accurate odometer CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_aod_vs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_asr_msr_typ
		"Torque control type received on the CAN"
		UBYTE
		sdjirsa_kAEhhma_hlsAEfc_n_q_ors
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vsx_mux_asr_msr_typ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001aae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_asr_msr_typ_vld
		"Torque control type received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_asr_msr_typ_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001aaf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_asr_reg_vld
		"ASR in regulation received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_mux_asr_reg_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ab0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcespin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ayc_reg_vld
		"AYC in regulation received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_mux_ayc_reg_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ab1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_clbduin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_bdu_ope_vld
		"BDU open information validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_bdu_ope_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbmucs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mux_bgin_clu_cnt
		"Begin stroke clutch pedal switch (from a CAN parameter)"
		UBYTE
		rzlnwjb_BlbxuAc_tkosmyc___xfxnx
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_bgin_clu_cnt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbmucs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mux_bgin_clu_cnt_vld
		"Begin stroke clutch pedal switch (from CAN parameter) validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_bgin_clu_cnt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcclbin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_bgin_str_clu_cnt
		"Begin stroke clutch pedal switch received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_bgin_str_clu_cnt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001aaa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcclbin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_bgin_str_clu_cnt_vld
		"Begin stroke clutch pedal switch received on the CAN validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_bgin_str_clu_cnt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001aab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcbpkin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_bpk_vld
		"Automatic or manual parking brake detected received on the CAN validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_bpk_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001aa7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcbrkin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_brk_pdl
		"Brake pedal states received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		7.
    DISPLAY_IDENTIFIER Vsx_mux_brk_pdl 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001aa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcbrkin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_brk_pdl_vld
		"Brake pedal states received on the CAN validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_brk_pdl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001aa9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_drag_red_agb_vld
		"Drag reduction mode received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_drag_red_agb_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001abe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_dspl_vs_vld
		"Displayed vehicle speed received on the CAN network validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_dspl_vs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002143 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_egb_neut_vld
		"Electronic GearBox in a configuration equivalent to Neutral for a manual gearbox received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_egb_neut_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001abf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ena_sta_agb
		"AT Starter authorization or stop received on the CAN network"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_ena_sta_agb 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ac8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ena_sta_agb_vld
		"AT Starter authorization or stop received on the CAN network validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_ena_sta_agb_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ac9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcclein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_end_str_clu_cnt
		"End stroke clutch pedal switch received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_end_str_clu_cnt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001aac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcclein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_end_str_clu_cnt_vld
		"End stroke clutch pedal switch received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_end_str_clu_cnt_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001aad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbfulin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_fuel_lvl_vld
		"Petrol tank reserve received on the CAN validity status"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_mux_fuel_lvl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000211b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfrwsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_lft_rwhs_vld
		"Rear left wheel speed received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_lft_rwhs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbfulin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_min_fuel_raw_vld
		"Raw low level of fuel received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_min_fuel_raw_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000211c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcrvnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_neut_cnt
		"Neutral engaged switch for manual gearbox received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_neut_cnt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ab3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcrvnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_neut_cnt_vld
		"Neutral engaged switch for manual gearbox received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_neut_cnt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ab4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctbnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_prim_sha_spd_vld
		"Primary shaft speed received on the CAN validity status"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_mux_prim_sha_spd_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ab7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_smptcin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ptc_is_acel_vld
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_mux_ptc_is_acel_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ad8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfptcin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_ptc_pow_vld
		"PTC power (from CAN) validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_ptc_pow_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002172 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_raw_egb_ant_gear
		"Target raw gear due to electronic gearbox received on the CAN"
		SBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		-128.
		127.
    DISPLAY_IDENTIFIER Vsx_mux_raw_egb_ant_gear 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ac0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_raw_egb_ant_gear_vld
		"Target raw gear due to electronic gearbox  (7th and lih also possible) received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_raw_egb_ant_gear_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ac1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_raw_egb_gear
		"Current raw gear due to electronic gearbox received on the CAN"
		SBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		-128.
		127.
    DISPLAY_IDENTIFIER Vsx_mux_raw_egb_gear 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ac2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctrein_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_raw_egb_gear_vld
		"Current raw gear due to electronic gearbox  (7 and lih also possible) received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_raw_egb_gear_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ac3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfpdain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_raw_whl_angl_vld
		"Steering wheel angle CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_raw_whl_angl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_rgb_coup
		"Robotized gearbox coupler state received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_rgb_coup 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001abc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctcsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_rgb_coup_vld
		"Robotized gearbox coupler state received on the CAN validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_rgb_coup_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001abd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tqprgin_stbxxx_data.c' */
/begin MEASUREMENT
		Vsx_mux_rgb_pump_vld
		"Robotized gearbox pump activation received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_rgb_pump_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000214e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vfrwsin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_rgt_rwhs_vld
		"Rear right wheel speed received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_rgt_rwhs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcrvnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_rvr_cnt
		"Reverse gear engaged switch for manual gearbox received on the CAN"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_rvr_cnt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ab5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcrvnin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_rvr_cnt_vld
		"Reverse gear engaged switch for manual gearbox received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_rvr_cnt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ab6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_sta_stt_vld
		"Starter status received on the CAN network validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_sta_stt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001aca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_tenvxin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_tenv_vld
		"External temperature received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_tenv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000214c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'outqotqd.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'outqotqd_tqrqstt_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_mux_tq_req_ans
		"Show to all systems how a regulation can be done (nominal, precision less or no regulation)"
		UBYTE
		thpfgAb_auenodc_jygDerb_nNmt_r_
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_tq_req_ans 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001959 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_vftacin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_tra_acel_vld
		"Transversal acceleration sensor received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_tra_acel_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_dgdtvin_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_vh_dist_vld
		"Total vehicle distance received on the CAN validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_mux_vh_dist_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000211e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxp50in_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_mux_vs_vld
		"Vehicle speed received on the CAN network validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_mux_vs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001acb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smlimspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smlimspt_nramsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_n_rams_lim_vld
		"Safety engine speed limitation validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_n_rams_lim_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001e08 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_n_vld
		"Engine speed validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_n_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_cnrvncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_neut_cnt
		"Neutral engaged switch for manual gearbox"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_neut_cnt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_no_seq_free_shf_mod
		"Vsx_no_seq_free_shf_mod"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001d92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_ocd_cond_stt
		"Status of diagnosis enabled conditions"
		UWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vsx_ocd_cond_stt 
    ECU_ADDRESS 0xd00063c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_ocd_stt
		"DOC OBD status"
		UBYTE
		RB_CONV_AtCatDgn_OBD_Status
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vsx_ocd_stt 
    ECU_ADDRESS 0xd000203c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_ocd_test_cond_stt
		"Status of test conditions"
		UWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vsx_ocd_test_cond_stt 
    ECU_ADDRESS 0xd00063c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_ofs_ad_cond_stt
		"Status of offset learning conditions"
		UWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vsx_ofs_ad_cond_stt 
    ECU_ADDRESS 0xd00063c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_oil_dil_ovs_vld
		"Oil dilution overshoot validity status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		1
    DISPLAY_IDENTIFIER Vsx_oil_dil_ovs_vld 
    ECU_ADDRESS 0xd000211a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_oitdiag_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_oit_vld
		"Inlet throttle validiy status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_oit_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001d34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_opt
		"Memorized option control"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_opt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bbc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtdat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtdat_msgdiag_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_owe_tool_zon_req
		"Geographical zon selection request from the diagnosis tool"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		5.
    DISPLAY_IDENTIFIER Vsx_owe_tool_zon_req 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000228f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_patxxmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pat_vld
		"After turbine pressure validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pat_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_asd_stt
		"CSF statemachine status for aftersale diagnosis regeneration"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		5
    DISPLAY_IDENTIFIER Vsx_pft_asd_stt 
    ECU_ADDRESS 0xd0002055 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_csf_diag_vld
		"Broken CSF validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_pft_csf_diag_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000205a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_diag_ena_lkg_stt
		"Enable status of diagnosis for overload particulate filter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_pft_diag_ena_lkg_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000206e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_diag_ena_stt
		"Enable status of diagnosis"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		511.
    DISPLAY_IDENTIFIER Vsx_pft_diag_ena_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000205c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftdpsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_dp_chr_vld
		"CSF differential pressure static plausibility validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_dp_chr_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftdpsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_dp_dirt_vld
		"CSF differential pressure dynamic plausibility validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_dp_dirt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_dprscsx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_dp_vld
		"CSF differential pressure validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_dp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtempcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_dtp_vld
		"CSF downstream temperature validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_dtp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_efi_mod
		"State variable indicating the mode of calculation of the fuel mass flow injected in the exhaust line"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_efi_mod 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000204b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftefyx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_efy_prct_vld
		"CSF efficiency validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_efy_prct_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_egaf_cor_vld
		"Corrected volumic exhaust gas flow validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_egaf_cor_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_egaf_vld
		"Exhaust gas air flow validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_egaf_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_eng_sp
		"Engine operating point"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_eng_sp 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002410 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_eng_sp_sta
		"Engine operating point when entering regeneration state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_eng_sp_sta 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00023d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_hot_cold_dist_intv_vld
		"Validity status of the array of learnt distance intervals between successive hot or medium or cold opportunities"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_hot_cold_dist_intv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002092 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_hot_cold_req_dist_vld
		"Validity status of the required distances to find a hot or medium or cold opportunity"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_hot_cold_req_dist_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002099 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_hot_dist_intv_vld
		"Validity status of the array of learnt distance intervals between successive hot opportunities"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_hot_dist_intv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002093 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_hot_med_dist_intv_vld
		"Validity status of the array of learnt distance intervals between successive hot or medium opportunities"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_hot_med_dist_intv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002094 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_hot_med_req_dist_vld
		"Validity status of the required distances to find a hot or medium opportunity"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_hot_med_req_dist_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000209a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_hot_req_dist_vld
		"Validity status of the required distances to find a hot opportunity"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_hot_req_dist_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000209b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_load_mod_nr
		"Condition mode number in synthesis of charging state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_load_mod_nr 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000208d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_load_spd_clc_stt_prev
		"previous value of Vsx_pft_load_spd_clc_stt"
		UBYTE
		nngBqjb_bunueAa_okABDAa_nft_Nc_
		1
		100
		1.
		4.
    DISPLAY_IDENTIFIER Vsx_pft_load_spd_clc_stt_prev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002096 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_load_stop_req
		"Synthesis of criteria for regeneration demand"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vsx_pft_load_stop_req 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000658c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_load_vld
		"CSF charging computation validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_load_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002071 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_low_load_spd_vld
		"Particulate filter low load speed validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_low_load_spd_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00020d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_malf_diag_ena_stt
		"Enabling status of diagnosis."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_pft_malf_diag_ena_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002062 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_malf_diag_stt
		"Status of particulate filter for malfunction diagnosis."
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_pft_malf_diag_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002063 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_msswixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_cor_vld
		"Particulate filter soot mass (corrected) validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_cor_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000208a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_dp_vld
		"CSF equivalent load validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_dp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_esti_vld
		"CSF estimated soot mass during the regeneration validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_esti_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002084 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_lft_ini_vld
		"Initial value of soot mass still stored when living regeneration request state validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_lft_ini_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002088 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_lft_mdl_vld
		"Non reseted estimated soot mass left in CSF validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_lft_mdl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002082 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_lft_vld
		"Soot mass still stored when regeneration request state is left validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_lft_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002089 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mslftxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_lft_vld_mem
		"Estimated soot mass left in CSF memory validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_lft_vld_mem 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002087 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_prs_vld
		"Particulate filter soot mass (corrected) validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_prs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002070 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_sim_sta_vld
		"Memory of estimated soot mass at exit of charging state validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_sim_sta_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000208e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_miofxxx_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_sim_vld
		"Simulated soot mass charged in CSF validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_sim_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002086 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ms_sta_vld
		"Memory of soot mass at exit of charging state validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_ms_sta_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000208f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_loadspd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_mv_sot_load_spd_vld
		"Validity of Vxx_pft_mv_pos_sot_load_spd and Vxx_pft_mv_raw_sot_load_spd"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_mv_sot_load_spd_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002097 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_o2facxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_o2_fac_sot_esti_vld
		"Estimation of O2 concentration validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_o2_fac_sot_esti_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_oil_csm_vld
		"Engine oil consumption validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_oil_csm_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_ovl_vld
		"Overloaded CSF validity status."
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_pft_ovl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00019bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_cdntgtx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_rgn_cdn_tgt_clc
		"Calc val of driving condition target for next CSF rgn: Null (delivery use), Cold (urban intensive use) or Medium (normally mixed use)"
		UBYTE
		ccifiAd_sqpcyxd_CDCpfFb_n0t1tdf
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_rgn_cdn_tgt_clc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00023ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_rgn_max_err_vld
		"Maximum regeneration failures validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_rgn_max_err_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002090 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_rgn_temp_vld
		"Temperature sensors for regeneneration computation validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_rgn_temp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002083 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_rgn_wio_dp_vld
		"Regeneration detection by soot mass estimation through differential pressure validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_rgn_wio_dp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00020d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_msswixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_sot_ms_cor_stt
		"Type of mass include in ms_cor ms_prs=1, ms_sim=2, mixt=3"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_sot_ms_cor_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000208b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_msswixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_sot_ms_cor_swi
		"Type of mass include in ms_cor ms_prs=1, ms_sim=2, mixt=3 gived by calibration"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		1.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_sot_ms_cor_swi 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000208c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_stt_rgn
		"CSF statemachine actual state"
		UBYTE
		nqbBDkb_olADjia_huaouid_nd_xpr_
		1
		100
		0.
		80.
    DISPLAY_IDENTIFIER Vsx_pft_stt_rgn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00023d1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdhist_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_stt_rgn_asd
		"CSF statemachine actual state shunt to regeneration success state if partial regeneration occured"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		255.0
    DISPLAY_IDENTIFIER Vsx_pft_stt_rgn_asd 
    ECU_ADDRESS 0xd0001eba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_sys_clc_dtp_vld
		"CSF downstream temperature calculated in combustion model validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_sys_clc_dtp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002085 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_sys_egaf_vld
		"Exhaust gas air mass flow for estimation of downstream pressure and temperature validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_sys_egaf_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_tiamvxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_tia_mv_vld
		"Intake air temperature average value validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_tia_mv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_toil_clc_vld
		"Recalculated oil temperature validity status"
		UBYTE
		RB_CONV_OneToOne
		1
		100
		0
		2
    DISPLAY_IDENTIFIER Vsx_pft_toil_clc_vld 
    ECU_ADDRESS 0xd0002119 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_uprscsx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_up_prs_vld
		"CSF upstream pressure validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_up_prs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_utp_reg_cmd_cor_vld
		"CSF upstream temperature regulation correction validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_utp_reg_cmd_cor_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000204d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_utp_reg_mod
		"Command mode for CSF upstream temperature regulation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_utp_reg_mod 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000204c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_utp_reg_vld
		"Particle filter upstream temperature regulation validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_utp_reg_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002043 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utempcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_utp_vld
		"CSF upstream temperature validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_pft_utp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_vld
		"CSF validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_pft_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000206d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_waitreq_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_pft_wait_req_stt
		"Status of wait mode request"
		UBYTE
		BBkhydb_BopFqDa_zoqBvwc___s2ewx
		1
		100
		1.
		5.
    DISPLAY_IDENTIFIER Vsx_pft_wait_req_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00020d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_post_chk_cond_stt
		"Status of post injection conditions"
		UWORD
		RB_CONV_AtCatDgn_OneToOne_wu
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vsx_post_chk_cond_stt 
    ECU_ADDRESS 0xd00063cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_pow_r_vld
		"Vsx_pow_r_vld"
		UBYTE
		VA_I_9
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001db1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_engstxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_prev_eng
		"Previous engine states"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_prev_eng 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000198f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_tbspdcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_prim_sha_spd_vld
		"Primary shaft speed validity status"
		UBYTE
		zdkvpcb_haoDnad_Ctrtujd_nn2N__i
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_prim_sha_spd_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c16 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_ptq_vld
		"Pumping torque validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_ptq_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001991 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_rat_gear
		"Ratio Gear:gearbox gear identified with thin true range of the ratio Vspeed/Neng."
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_rat_gear 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0002008 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_tmdlsxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_rat_gear_stab
		"Stabilized ratio Gear:gearbox gear identified with thin true range of the ratio Vspeed/Neng and the stability of the ratio."
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		6.
    DISPLAY_IDENTIFIER Vsx_rat_gear_stab 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001cb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_raw_egb_ant_gear
		"Target raw gear due to electronic gearbox"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		15.
    DISPLAY_IDENTIFIER Vsx_raw_egb_ant_gear 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c5f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_raw_egb_ant_gear_vld
		"Target raw gear due to electronic gearbox validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_raw_egb_ant_gear_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_raw_egb_gear
		"Current raw gear due to electronic gearbox"
		UBYTE
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		1
		100
		-1.
		15.
    DISPLAY_IDENTIFIER Vsx_raw_egb_gear 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attrecs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_raw_egb_gear_vld
		"Current raw gear due to electronic gearbox validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_raw_egb_gear_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_1
		"Flag of shut-off cond. 1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_2
		"Flag of shut-off cond. 2"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000265f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_sfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_3
		"Flag of shut-off cond. 3"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_3 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002669 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_aftr_sta
		"Flag of EGR regulation cut-off after start"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_aftr_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a7f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_amp
		"Flag of egr cut off in case of amp default"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_amp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_drgn_sta
		"Flag of EGR regulation cut-off during start state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_drgn_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a81 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_emtv_diag
		"Flag of egr regulation cut-off in case of emtv diagnosis error"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_emtv_diag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002665 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_fast_acel
		"Flag of EGR regulation cut-off during fast acceleration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_fast_acel 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_is_t_ovs
		"Flag of EGR regulation cut-off in case of idle state time overshoot"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_is_t_ovs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_it_clos
		"Flag of egr regulation cut-off in case of closed emtv"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_it_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002666 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_it_diag
		"Flag of egr regulation cut-off in case of it diagnosis error"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_it_diag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002667 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_n_avg_ovs
		"Flag of EGR regulation cut-off in case of engine speed overshoot"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_n_avg_ovs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a83 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_n_avg_uds
		"Flag of EGR regulation cut-off in case of too low engine speed"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_n_avg_uds 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_ovr
		"Flag of EGR regulation cut-off in case of overrun"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_ovr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002659 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_sge
		"Flag of EGR strategy shut-off required by SGE strategy"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_sge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000265a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_tco_thd
		"Flag of EGR regulation cut-off in case of tco threshold ovs"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_tco_thd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_tia_thd
		"Flag for EGR regulation cut-off in case of tia threshold"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_tia_thd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_rfsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_reg_cut_vnt_reg_err
		"Flag of EGR regulation cut-off in case of supercharging governor error loop"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_reg_cut_vnt_reg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002668 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attcscs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_rgb_coup
		"Robotized gearbox coupler state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_rgb_coup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_attcscs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_rgb_coup_vld
		"Robotized gearbox coupler state validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_rgb_coup_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_rwsxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_rgt_rwhs_vld
		"Rear right wheel speed validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_rgt_rwhs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ce3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslslxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_road_typ
		"Vsx_road_typ"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001daf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_run_vh_vld
		"Vehicle run detected validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_run_vh_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_cnrvncs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_rvr_cnt
		"Reverse gear engaged switch for manual gearbox"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_rvr_cnt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_altdfsr_stbxxx_data.c' */
/begin MEASUREMENT
		Vsx_sens_alt_fil_pwm_vld
		"Filtered wire frame alternator load validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_alt_fil_pwm_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cd7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbsrcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sens_bgin_clu_cnt
		"Wire begin clutch contactor state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_sens_bgin_clu_cnt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001c69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbsrcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sens_bgin_clu_cnt_vld
		"Wire begin clutch contactor state validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_bgin_clu_cnt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_crksixx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_crk_vld
		"Crankshaft sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_crk_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cb9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_td1diag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_doc1_utp_vld
		"temperature before oxidation 1 sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_doc1_utp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_pbtxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_ex_prs_vld
		"Exhaust manifold pressure from sensor validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_ex_prs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_camsixx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sens_in_cam_vld
		"Intake camshaft sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_in_cam_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_maf_cs_vld
		"Mass air flow validity status, after drift sensor diagnosis"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_maf_cs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001be2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_maf_vld
		"Mass air flow sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_maf_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_map_vld
		"Manifold pressure from sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_map_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_uprsabv_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_abv_up_prs_vld
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_sens_pft_abv_up_prs_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00022c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_dp_in_vld
		"Local CSF differential pressure validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_pft_dp_in_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000205e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_pftdpsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_dp_vld
		"differential pressure sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_pft_dp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bfd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitdf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitdf_dtpdiag_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_dtp_vld
		"particle filter downstream temperature sensor validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_pft_dtp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_malf_dp_in_vld
		"Local malfunction CSF differential pressure validity status."
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_pft_malf_dp_in_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002064 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdclog_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_ovl_prs_in_vld
		"Local CSF pressure validity status."
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_pft_ovl_prs_in_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00019be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_rel_up_prs_vld
		"CSF upstream relative pressure from sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_pft_rel_up_prs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatituf.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatituf_utpdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_pft_utp_vld
		"Validity indicator for CSF upstream temperature raw information"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_pft_utp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_spg_vld
		"Boost pressure from sensor validity status"
		UBYTE
		DbqmAvc_FCazhwd_yFuDCFc_B3x__2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_spg_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bf4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtdiag_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_tbt_vld
		"temperature before turbine sensor validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_tbt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sens_tco_vld
		"engine coolant temperature sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_tco_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_tia_vld
		"Intake air temperature sensor validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_tia_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bf6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilubc_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sens_toil_vld
		"Oil temperature analog sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_toil_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxsr_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_up_it_temp_vld
		"Upstream throttle temperature measurement validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_up_it_temp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'oucboueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'oucboueg_upshtdg_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_ups_heat_vld
		"Upstream proportional sensor heater powerstage validity status"
		UBYTE
		RB_CONV_OuCboUeg_Vld_Status
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vsx_sens_ups_heat_vld 
    ECU_ADDRESS 0xd0001958 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upssrxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_sens_ups_rich_vld
		"Richness from upstream proportional sensor validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sens_ups_rich_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c05 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_sitdiag_stbxxd_data.c' */
/begin MEASUREMENT
		Vsx_sit_vld
		"Smart Inlet throttle validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_sit_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001d35 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_stflwxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sl_stt
		"Speed limiter state"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4.
    DISPLAY_IDENTIFIER Vsx_sl_stt 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000196a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_dacaxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sl_vld
		"Speed limiter validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001d69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_slo_clos_req
		"Flag for slow valve closing request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_slo_clos_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000265b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ezsocec_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_slo_clos_req_is
		"Flag for slow egr valve closing request from idle speed too long shut-off path"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_slo_clos_req_is 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_ecsocxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_slo_clos_req_ovr
		"Flag for slow egr valve closing request from overrun shut-off path"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_slo_clos_req_ovr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000265c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smokexx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_smk_fim_vld
		"Smoke limitation fuel mass validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_smk_fim_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001993 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_spg_prs_lih_ena
		"Flag to enable supercharger pressure sensor limp home in case of sensor failure"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_spg_prs_lih_ena 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00019bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_spg_reg_vld
		"Boost pressure regulation validity criteria"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_spg_reg_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00019b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_spg_vld
		"Boost pressure validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_spg_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bf3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invficri.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invficri_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sta_stt_vld
		"Starter status validity status"
		UBYTE
		itzAFCa_walhowa_fCBrBqc___kv_i_
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_sta_stt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001cd3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_sta_tco_vld
		"Engine coolant temperature during engine starting validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_sta_tco_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_stal_acs_dsb_stt
		"Stalling state in anti-stall strategy"
		UBYTE
		Btazhnd_dbwbdEa_sBBrftd_n_l__bt
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_stal_acs_dsb_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002df3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_star_mod
		"State of start demand"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_star_mod 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001a06 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_cbstain_xxxm3x_data.c' */
/begin MEASUREMENT
		Vsx_star_mod_vld
		"StartingMode validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_star_mod_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a07 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_stt_dhil
		"Vsx_stt_dhil"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001da8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsdlyxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_stt_dly
		"Vsx_stt_dly"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001d94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_stt_fast_off
		"Vsx_stt_fast_off"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd000235e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfonxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_stt_fast_on
		"Vsx_stt_fast_on"
		UBYTE
		VA_I_16
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001da0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_swlk_stt
		"Immobiliser automaton phase number"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_swlk_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_22_stt
		"Supplier flow actuator (VCV) intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_22_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bbd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_23_stt
		"Supplier rail pressure regulator (PCV) intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_23_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bbe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_24_stt
		"Supplier oxygen upper sensor heater intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_24_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bbf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_25_stt
		"Supplier oxygen lower sensor heater intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_25_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_29_stt
		"Supplier ignition coil 1 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_29_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_30_stt
		"Supplier ignition coil 2 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_30_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_31_stt
		"Supplier ignition coil 3 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_31_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_32_stt
		"Supplier ignition coil 4 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_32_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_35_stt
		"Supplier fuel injector 1 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_35_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_36_stt
		"Supplier fuel injector 2 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_36_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_37_stt
		"Supplier fuel injector 3 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_37_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_38_stt
		"Supplier fuel injector 4 intermediary status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_38_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tac_stt
		"Current component status returned to build positive or negative answer"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tac_stt 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bc9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_tbf_fct_apl_down_vld
		"temperature before particulate filter function low validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_tbf_fct_apl_down_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002019 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_tempdgx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_tbf_fct_apl_up_vld
		"temperature before particulate filter function high validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_tbf_fct_apl_up_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000201a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_tbt_reg_vld
		"Confirmed default on temperature before turbine regulation function"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_tbt_reg_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00020e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbitbt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbitbt_tbtcsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_tbt_vld
		"Temperature before turbine validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_tbt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tco_vld
		"engine coolant temperature validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_tco_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tenvxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tenv_vld
		"External temperature validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_tenv_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_chvcmdx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_thpl_vld
		"Coolant heaters validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_thpl_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000230a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_tiaxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_tia_vld
		"Intake air temperature validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_tia_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bf8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_toil_vld
		"Oil temperature validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_toil_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tq_dif_vld
		"Vsx_tq_dif_vld"
		UBYTE
		VA_I_9
		2
		100
		0
		255
    ECU_ADDRESS 0xd0001db2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_ivltqxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_tq_fct_vld
		"Torque realization validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_tq_fct_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000199b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tq_rams_lim_vld
		"Safety torque limitation validity status"
		UBYTE
		Bhjtdld_Bxgefzb_DuEvmhd__2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_tq_rams_lim_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000199a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_rubtqxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tql_eng_frn_vld
		"Engine rubbing torque losses validity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_tql_eng_frn_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001992 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_tacelcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_tra_acel_vld
		"Transverse acceleration validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_tra_acel_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ce4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'clcoospt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'clcoospt_tstaxbc_data.c' */
/begin MEASUREMENT
		Vsx_tsta_vld
		"Electronically controlled thermostat validity indicator"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_tsta_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002118 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_ttcfmxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_tt_vld
		"Temperature next to turbine validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_tt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00022ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxcs_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_up_it_temp_vld
		"Upstream throttle temperature validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_up_it_temp_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bf9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_ups_rich_clc_vld
		"Calculated richness vaildity status"
		UBYTE
		uADawDa_nypsEha_DoCvmhd_n2_l_Nd
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_ups_rich_clc_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c03 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_ups_rich_vld
		"Upstream proportional sensor richness validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_ups_rich_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001c04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vb_rly_vld
		"Main relay validity indicator"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_vb_rly_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cd8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiemi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiemi_batxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vb_vld
		"Filtered voltage battery validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_vb_vld 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001cd9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dgtdvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vh_dist_l_res_vld
		"Vehicle mileage with low resolution validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_vh_dist_l_res_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002300 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_dgtdvcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vh_dist_vld
		"Vehicle mileage validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_vh_dist_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002301 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_entrfxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vh_eng
		"CAN output data indicating the engine states"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_vh_eng 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001e0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_cold_sta
		"Cold start flag for vnt"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_vnt_cold_sta 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002642 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_diag_lih_cdn
		"Condition for fixed pwm use or openloop modulation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_vnt_diag_lih_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002643 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_diag_stt
		"VNT state indicator"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		17.
    DISPLAY_IDENTIFIER Vsx_vnt_diag_stt 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_ex_prs_lim_req
		"Request of exhaust pressure limitation"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_vnt_ex_prs_lim_req 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00019ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_stt
		"Open loop flag for VNT governor"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_vnt_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002644 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_tobpcxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_tran_req
		"Vnt transient request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vsx_vnt_tran_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000264a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasotco.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasotco_vntxcmd_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_vld
		"Variable Nozzle Turbocharger validity status"
		UBYTE
		qoqFqhc_FAxzcac_irphkFc__0v1v_l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_vnt_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001957 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_mdxxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vsx_vnt_zon
		"Vnt working zone indicator"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Vsx_vnt_zon 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd00019b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vs_2_vld
		"Vehicle speed validity status"
		UBYTE
		crcpByb_qtnxvic_rzBrBqc_n0o_2ax
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER Vsx_vs_2_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ce0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_ratioxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vs_n_rat_fil_vld
		"Filtered Ratio validity status"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_vs_n_rat_fil_vld 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001c7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfivsi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfivsi_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_vs_vld
		"Vehicule speed validity status"
		UBYTE
		cqvsmgd_egstFCa_yhphkFc_n_v0v2l
		1
		100
		0.
		2.
    DISPLAY_IDENTIFIER Vsx_vs_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ce1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_paotxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vsx_wpmp_tcr
		"State variable for SF state machine"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vsx_wpmp_tcr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002323 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[0]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[0] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006314 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[10]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[10] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006328 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[11]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[11] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000632a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[12]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[12] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000632c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[13]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[13] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000632e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[14]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[14] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006330 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[1]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[1] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006316 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[2]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[2] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006318 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[3]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[3] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000631a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[4]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[4] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000631c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[5]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[5] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000631e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[6]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[6] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006320 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[7]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[7] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006322 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[8]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[8] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006324 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_dec_slop_itl_tb[9]
		"Decrease slope internal list which contains all the decrease slope setpoints."
		UWORD
		uscBxeb_xbkoejd_nCwmFFd_rp__n0a
		1
		100
		-65535.
		0.
    DISPLAY_IDENTIFIER Vtx_dec_slop_itl_tb[9] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006326 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[0].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000745c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0007467 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007460 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007454 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000745e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007456 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007459 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007462 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007458 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000745d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000745a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007452 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007464 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000745b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007468 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007466 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[0].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[0].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007457 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[1].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007474 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000747f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007478 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000746c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007476 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000746e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007471 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000747a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007470 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007475 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007472 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000746a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000747c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007473 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007480 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000747e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[1].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[1].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000746f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[2].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000748c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0007497 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007490 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007484 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000748e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007486 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007489 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007492 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007488 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000748d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000748a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007482 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007494 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000748b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007498 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007496 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[2].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[2].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007487 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[3].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00074a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00074af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000749c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000749e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00074aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000749a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00074ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[3].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[3].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000749f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[4].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00074bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00074c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00074b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00074c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00074c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[4].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[4].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[5].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00074d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00074df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00074ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074d1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00074da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00074dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[5].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[5].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[6].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00074ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00074f7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00074e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00074f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00074f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00074eb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[6].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[6].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[7].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007504 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000750f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007508 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00074fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007506 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00074fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007501 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000750a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007500 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007505 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007502 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00074fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000750c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007503 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007510 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000750e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[7].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[7].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00074ff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[8].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000751c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0007527 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007520 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007514 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000751e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007516 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007519 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007522 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007518 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000751d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000751a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007512 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007524 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000751b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007528 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007526 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[8].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[8].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007517 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vtx_frm[9].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007534 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000753f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007538 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000752c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007536 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000752e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007531 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000753a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007530 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007535 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007532 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000752a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000753c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007533 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007540 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000753e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_frm[9].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vtx_frm[9].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000752f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_gear_rat_tgt[0]
		"Calibration vector of gear ratio targets: Neutral, 1st_gear,..., 6th_gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_gear_rat_tgt[0] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001904 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_gear_rat_tgt[1]
		"Calibration vector of gear ratio targets: Neutral, 1st_gear,..., 6th_gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_gear_rat_tgt[1] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001906 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_gear_rat_tgt[2]
		"Calibration vector of gear ratio targets: Neutral, 1st_gear,..., 6th_gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_gear_rat_tgt[2] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001908 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_gear_rat_tgt[3]
		"Calibration vector of gear ratio targets: Neutral, 1st_gear,..., 6th_gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_gear_rat_tgt[3] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000190a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_gear_rat_tgt[4]
		"Calibration vector of gear ratio targets: Neutral, 1st_gear,..., 6th_gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_gear_rat_tgt[4] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000190c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_gear_rat_tgt[5]
		"Calibration vector of gear ratio targets: Neutral, 1st_gear,..., 6th_gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_gear_rat_tgt[5] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000190e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_rgearxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_gear_rat_tgt[6]
		"Calibration vector of gear ratio targets: Neutral, 1st_gear,..., 6th_gear."
		UWORD
		dujshzb_DwjACja_csdmxkc_ijpA0o0
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vtx_gear_rat_tgt[6] 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001910 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[0]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[0] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006332 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[10]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[10] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006346 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[11]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[11] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006348 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[12]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[12] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000634a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[13]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[13] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000634c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[14]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[14] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000634e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[1]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[1] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006334 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[2]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[2] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006336 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[3]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[3] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006338 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[4]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[4] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000633a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[5]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[5] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000633c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[6]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[6] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000633e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[7]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[7] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006340 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[8]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[8] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006342 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_inc_slop_itl_tb[9]
		"Increase slope internal list which contains all the increase slope setpoints."
		UWORD
		mawdnod_mAdbavd_aAwiCea_rp__a0a
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_inc_slop_itl_tb[9] 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd0006344 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_ini_i[0]
		"Initial torque value of Idle Speed Regulator integral correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vtx_ini_i[0] 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000120a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_ini_i[1]
		"Initial torque value of Idle Speed Regulator integral correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vtx_ini_i[1] 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd000120c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_p_fac[0]
		"Current proportionnal correction factor"
		UWORD
		FhjEdpd_murFlfd_zlheCCb_Np__0a0
		1
		100
		0.
		7.9990234375
    DISPLAY_IDENTIFIER Vtx_is_p_fac[0] 
    FORMAT "%12.9" 
    ECU_ADDRESS 0xd000121c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_p_fac[1]
		"Current proportionnal correction factor"
		UWORD
		FhjEdpd_murFlfd_zlheCCb_Np__0a0
		1
		100
		0.
		7.9990234375
    DISPLAY_IDENTIFIER Vtx_is_p_fac[1] 
    FORMAT "%12.9" 
    ECU_ADDRESS 0xd000121e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[0]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[0] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006350 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[10]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[10] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006364 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[11]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[11] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006366 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[12]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[12] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006368 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[13]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[13] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000636a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[14]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[14] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000636c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[1]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[1] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006352 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[2]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[2] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006354 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[3]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[3] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006356 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[4]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[4] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006358 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[5]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[5] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000635a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[6]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[6] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000635c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[7]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[7] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000635e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[8]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[8] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006360 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_arissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_is_sp_itl_tb[9]
		"Idle speed internal list which contains all the idle speed setpoints."
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vtx_is_sp_itl_tb[9] 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0006362 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_eng_rev_act_sum[0]
		"Table of actual engine revolution sum for the oil wear estimation strategy"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vtx_owe_eng_rev_act_sum[0] 
    ECU_ADDRESS 0xd00053b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_eng_rev_act_sum[1]
		"Table of actual engine revolution sum for the oil wear estimation strategy"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vtx_owe_eng_rev_act_sum[1] 
    ECU_ADDRESS 0xd00053b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_eng_rev_act_sum[2]
		"Table of actual engine revolution sum for the oil wear estimation strategy"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vtx_owe_eng_rev_act_sum[2] 
    ECU_ADDRESS 0xd00053bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_eng_rev_act_sum[3]
		"Table of actual engine revolution sum for the oil wear estimation strategy"
		ULONG
		RB_CONV_1Trs
		1
		100
		0.0
		300000000.0
    DISPLAY_IDENTIFIER Vtx_owe_eng_rev_act_sum[3] 
    ECU_ADDRESS 0xd00053c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_km[0]
		"Table of number of kilometers travelled on initialisation"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vtx_owe_km[0] 
    ECU_ADDRESS 0xd00053c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_km[1]
		"Table of number of kilometers travelled on initialisation"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vtx_owe_km[1] 
    ECU_ADDRESS 0xd00053c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_km[2]
		"Table of number of kilometers travelled on initialisation"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vtx_owe_km[2] 
    ECU_ADDRESS 0xd00053cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_km[3]
		"Table of number of kilometers travelled on initialisation"
		ULONG
		RB_CONV_Distance_1km
		1
		100
		0.0
		16777215.0
    DISPLAY_IDENTIFIER Vtx_owe_km[3] 
    ECU_ADDRESS 0xd00053d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_pot_km[0]
		"Table of potential kilometer"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vtx_owe_pot_km[0] 
    ECU_ADDRESS 0xd0007ab6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_pot_km[1]
		"Table of potential kilometer"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vtx_owe_pot_km[1] 
    ECU_ADDRESS 0xd0007ab8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_pot_km[2]
		"Table of potential kilometer"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vtx_owe_pot_km[2] 
    ECU_ADDRESS 0xd0007aba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_owhisxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vtx_owe_pot_km[3]
		"Table of potential kilometer"
		UWORD
		RB_CONV_OneToOne
		1
		100
		0.0
		65535.0
    DISPLAY_IDENTIFIER Vtx_owe_pot_km[3] 
    ECU_ADDRESS 0xd0007abc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[0]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[0] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004f94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[1]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[1] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004f98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[2]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[2] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004f9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[3]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[3] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004fa0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[4]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[4] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004fa4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[5]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[5] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004fa8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[6]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[6] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004fac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[7]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[7] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004fb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[8]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[8] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004fb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_egaf_sum[9]
		"Vector of sum of exhaust gas air flow"
		ULONG
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		1
		100
		0.
		429496729.
    DISPLAY_IDENTIFIER Vtx_pft_egaf_sum[9] 
    FORMAT "%11.1" 
    ECU_ADDRESS 0xd0004fb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[0]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[0] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000659a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[10]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[10] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[11]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[11] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[12]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[12] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[13]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[13] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[14]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[14] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[15]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[15] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[1]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[1] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000659c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[2]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[2] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000659e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[3]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[3] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[4]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[4] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[5]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[5] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[6]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[6] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[7]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[7] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[8]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[8] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_dist_intv[9]
		"Array (16 values) of learnt distance intervals between successive hot or medium or cold opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_dist_intv[9] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[0]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[0] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd000209c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[10]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[10] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[11]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[11] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[12]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[12] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[13]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[13] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[14]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[14] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[15]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[15] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[1]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[1] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd000209d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[2]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[2] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd000209e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[3]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[3] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd000209f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[4]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[4] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[5]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[5] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[6]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[6] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[7]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[7] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[8]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[8] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_cold_intv_sum_rat[9]
		"Array whose each of 16 val = ratio of dist driven with [dist to following hot, med or cold opp < 1 learnt dist intv between such opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_cold_intv_sum_rat[9] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[0]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[0] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[10]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[10] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[11]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[11] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[12]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[12] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[13]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[13] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[14]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[14] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[15]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[15] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[1]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[1] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[2]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[2] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[3]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[3] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[4]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[4] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[5]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[5] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[6]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[6] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[7]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[7] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[8]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[8] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_dist_intv[9]
		"Array (16 values) of learnt distance intervals between successive hot opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_dist_intv[9] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[0]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[0] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[10]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[10] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[11]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[11] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[12]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[12] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[13]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[13] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[14]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[14] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[15]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[15] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[1]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[1] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[2]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[2] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[3]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[3] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[4]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[4] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[5]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[5] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[6]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[6] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[7]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[7] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[8]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[8] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_nxtoppx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_intv_sum_rat[9]
		"Array whose each of the 16 values = ratio of dist driven with [dist to following hot opp < 1 of learnt dist intervals between hot opp]"
		UBYTE
		cacfqoc_gteDmfa_ycrbfoa_n_Ra8oa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER Vtx_pft_hot_intv_sum_rat[9] 
    FORMAT "%9.7" 
    ECU_ADDRESS 0xd00020b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_intvopp_xxxxxd_data.c' */
/begin MEASUREMENT
		Vtx_pft_hot_med_dist_intv[0]
		"Array (16 values) of learnt distance intervals between successive hot or medium opportunities"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vtx_pft_hot_med_dist_intv[0] 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00065da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
