    "Oxygen calibration correction value"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000041A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2Dvt
    "Limited and filtered O2 calibration value"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000041C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2Flt
    "O2 voltage after filtering and segment averaging"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000420

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2FltOfsCor
    "Filtered and corrected O2 voltage signal"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000041E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2FltRippel_mp
    "Filtered value of deviation of 2nd O2 voltage sample from mean of 1st and 3rd samples during heater coupling check"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000979C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2FltSegOld_mp
    "Measuring point to store old segment O2 voltage accumulation for the latest sensor"
    SLONG
    Volt
    1
    100
    -429496729.600
    429496729.400

    
    FORMAT "%13.3"
    
    ECU_ADDRESS 0xD40019D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2Grad_mp
    "Change of the O2 voltage between first & third sampling (LSU heater active) during heater coupling check"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000979E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2HtCoupStp1
    "First sample of O2 voltage during heater coupling check"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000422

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2HtCoupStp2
    "Second sample of O2 voltage during heater coupling check"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000424

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2HtCoupStp3
    "Third sample of O2 voltage during heater coupling check"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000426

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2OfsCorAvrg_mp
    "Mean measured LSU voltage"
    SWORD
    Volt_FnReso1
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000983C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2PresComp_mp
    "Pressure compennsated O2 voltage"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000983E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2Raw
    "Raw voltage value lambda signal after subtraction of reference 1.5 Volt"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000042C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2RawAdcDirect
    "Direct O2 voltage value from the ADC (before segment filtering)"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000428

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2RawOfsCor
    "O2 voltage signal corrected by O2 calibration"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000042A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2RawOfsCorLast_mp
    "Declared only for O2 voltage to ratio conversion curve axis reference"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001C7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uO2Rippel_mp
    "deviation of 2nd O2 voltage sample from mean of 1st and 3rd samples during heater coupling check"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD00097A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uRiFlt
    "Filtered value of Ri voltage"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD000042E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uRiRawOfsCor
    "Ri voltage after offset correction, for OBD requirements"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0000430

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uRiRaw_mp
    "Ri voltage value directly from ADC"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009790

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    LSU_uSumO2OfsCorMeas_mp
    "Sum of uO2RawOfsCor in one measure phase"
    SLONG
    Volt_FnReso1
    1
    100
    -214748364.800
    214748364.700

    
    FORMAT "%13.3"
    ARRAY_SIZE 1
    ECU_ADDRESS 0xD0009840

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_cntRepActrTst_mp
    "Counter for repetition of gradient detection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_cntSpdActrTst_mp
    "Speed counter for MeUn Actr test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_cntTrgOffSetPTst_mp
    "Number of sequences for ramp function in setpoint test"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CAE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_ctRot_mp
    "Number of function calls of the rotation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_dvolSet
    "Setpoint value (volume flow) of rail pressure governing"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000432

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_facCrntCtlLim_mp
    "Metering unit current control, I component"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001CBA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_facRefActrTst
    "Detection threshold for the MeUn Actr test"
    UWORD
    Fact1
    1
    100
    0.00
    511.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00005D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iActFlt_mp
    "Metering unit current control filtered actual current value"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CBC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iActVal
    "Current actual value of the analog input"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000434

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iDvt_mp
    "Metering unit current control governor deviation"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CBE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iEndLimSetPTst_mp
    "Limited meun end current in setpoint test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iEndSetPTst
    "actual limited end value for meun current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000436

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iOfsSetPTst
    "offset value for increasing of meun current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000438

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iOldSetPTst_mp
    "actual meun current at start of setpoint test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CB2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iPCVAvrgLoActrTst_mp
    "Average PCV current during MeUn Actr test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iRefActrTst_mp
    "Detected current of MeUn Actr test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0009846

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iResActrTst_mp
    "Mean current of three reference MeUn currents"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD000984C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iSet
    "Setpoint current for the metering unit"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000043A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iSetActrTst
    "Desired set current forMeUn Actr test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000043C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iSetFlt
    "Metering unit current control filtered current setpoint value"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000043E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iSetMaxActrTst
    "Upper desired set current for MeUn Actr test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000440

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iSetMinActrTst
    "Lower desired set current forMeUn Actr test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000442

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iStrtLimSetPTst_mp
    "limited meun start current in setpoint test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CB4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iStrtSetPTst
    "actual limited start value of meun current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000444

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_iSubstSetPTst
    "actual substitute value for meun current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000446

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_nActrTst
    "Engine speed for test phases for MeUn Actr test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0000448

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_nDiffRef_mp
    "Filtered engine speed for a curve"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001C9E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_nSubsActrTst
    "engine speed during engine meun actuator test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000450

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_pActrTst
    "Desired setpoint pressure for MeUn Actr test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0000452

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_pSetPntActrTst
    "Setpoint pressure for MeUn Actr test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD000045A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_qAvrgActrTst_mp
    "Average injection quantity during MeUn Actr test"
    SWORD
    InjMassCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001C9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_rPsPreRot_mp
    "Duty cycle of MeUn current governor before rotation"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CA0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_rPs_mp
    "PWM signal output from the metering unit"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CA2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_rSetDT1_mp
    "Setpoint duty cycle with DT1 component"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_rSetLin_mp
    "Linearised setpoint of the metering unit"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CA6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_rSet_mp
    "Duty cycle setpoint for the metering unit"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stActrCtl_mp
    "State of actuator value control for metering unit"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stActrTst
    "Result of the MeUn Actr test"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stEffectActrTst
    "Status indicating the effect of the MeUn Actr test on the set current through the metering test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000084C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stEffectSetPTst
    "effect bits of setpoint test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000084D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stParSetPTst
    "parameter for setting running modes"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000084E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stRefActrTst
    "Status indicating the violated condition for aborting the MeUn Actr test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stRefSetPTst
    "refuse conditions for setpoint test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00005DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stResActrTst_mp
    "Status result of the MeUn Actuator Test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0009854

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stRot
    "state of anchor rotation function of metering unit"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000084F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stRotXPostDrv_mp
    "Postdrive extension by function for rotation of anchor in the metering unit"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stStMActrTst
    "Status machine of MeUn Actr test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000850

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stStMSetPTst
    "state machine for setpoint test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000851

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_stZeroVolTst
    "Result of Zero Delivery test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000852

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_swtTstParActrTst
    "Switch to select parameter from tester (0x01) or dataset(0x00)."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000853

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiDlySetPTst
    "delay time between two ramps"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD000045C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiEvalActrTst_mp
    "Elapsed time of MeUn Actr test"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiPer_mp
    "Duration of the PWM power stage period."
    SWORD
    Period
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001CAA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiRmpDurActrTst
    "Ramp gradient desired current for MeUn Actr test"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD000045E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiStpMeasSetPTst_mp
    "actual measured time for one step to increase meun current"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001CB6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiStpSetPTst
    "time for one step to increase meun current"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000460

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiTotSetPTst_mp
    "total time for setpoint test"
    SWORD
    Time_s
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CB8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_tiWait_mp
    "Time elapsed in a certain state before transition to next state is possib"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001C9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_trgSigSetPTst_mp
    "trigger signal for ramp function"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MeUn_uRaw_mp
    "Raw voltage value of the analog input"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001CAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_ctDebNTP
    "Error counter for testing with null load test pulse procedure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009949

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_ctDebTst
    "Error counter for testing the test voltage"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000994A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_ctDebVltgRatio
    "Error counter of ratiometric correction factor plausibility check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000994B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_ctDiagNTP
    "Counter for setting the test flag in the diagnosis while testing with null load test pulse procedure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000854

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_ctDiagTst
    "Counter for setting the test flag in the diagnosis while testing the test voltage in the ADC monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000855

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_ctDiagVltgRatio
    "Counter for setting the test flag in the diagnosis while testing the ratiometric correction factor in the ADC monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000856

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_facVltgRatio
    "Ratiometric correction factor in the function monitoring"
    UWORD
    Mo_fac_q0p00098
    1
    100
    0.00
    63.99902

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000994E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_st
    "Status Info of ADC monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009950

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_stIrvErrNTP
    "Irreversible error bit from testing with null load test pulse procedure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009B48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_stIrvErrTst
    "Irreversible error bit from testing the test voltage in ADC monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009B49

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_stIrvErrVltgRatio
    "Irreversible error bit from testing the ratiometric correction factor in ADC monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009B4A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_stMsg
    "ADC status form Level 2 to Level 1"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000857

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_uNTP
    ""
    SBYTE
    Mo_u_mV_q39p06
    1
    100
    -5000.
    4961.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD000994C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCADC_uTst
    ""
    SBYTE
    Mo_u_mV_q39p06
    1
    100
    -5000.
    4961.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD000994D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bCPUNew
    "New Question for instruction test recieved"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009A41

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bErrCntErr
    "Permanent error in query- response communication with monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x8
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009A40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bErrCntNPl
    "Error counter from monitoring module not plausible"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009A40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bPCPNew
    "New Question for PCP monitoring recieved"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x4
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009A41

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bPFCNew
    "New Question for program flow check recieved"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x2
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009A41

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bSpiErr
    "Permanent error in SPI-communication with monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x80
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009A40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_bSpiNPl
    "Error counter SPI Communication not plausible"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x10
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009A40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctCorRespCnt
    "Counter for counting the number of corrections of the response counter"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A29

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctDiagErrCnt
    "Error counter for reporting not plausible FC or MM to DSM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000858

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctDiagErrSPI
    "Error counter for reporting SPI-communication error to DSM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000859

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrFC
    "Error counter in function controller for errors from monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A36

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMM
    "Error counter response from monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A2B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMMMsg
    "Info to level 1: error counter response from monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000085A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrMMOld
    "Old error counter response from monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A2C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctErrSPI
    "error counter for SPI-transmissions in monitoring module communication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A2D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_ctSOPTstActv
    "Counter for number of active shut off path test calls"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Query
    "Enlarged query from monitoring module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009A3C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_Response
    "Response to query from monitoring module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009A30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_st
    "Status bitbase for communication with monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stMmRespCnt
    "counter for receiving the 4 response bytes"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A35

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stQueryNew
    "Bitbase for info 'new query from monitoring module'"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A41

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCom_stWDAActvMsg
    "Info to level 1: Watchdog switch off activ"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000085B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCPU_ctSeq
    "Sequence counter for instruction test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A42

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCPU_IpoIn
    "Input Value for interpolation routine in instruction test"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A44

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCPU_PartResp
    "Partial response from instruction test to monitoring module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009A4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCPU_Query
    "Takeover of a new query out of query-response communication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCCPU_TempRes
    "Temporary result in instruction test"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009A48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_adCurrent
    "current address pointer for cyclical ROM-check"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009954

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_adRamOffset
    "current offset for cyclical RAM-check"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009958

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebErrChkRAM
    "error debounce counter for double storage and cyclical RAM-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000995C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebErrChkROM
    "error debounce counter for cyclical ROM-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000995D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebHealChkRAM
    "error healing counter for double storage and cyclical RAM-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000995E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_ctDebHealChkROM
    "error healing counter for cyclical ROM-test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000995F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_numCurrent
    "current checksum for cyclical ROM-check"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009960

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_st
    "Request of a complete memory test during initialisation; status of complete ROM test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D76A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCMem_stFunctionSwitch
    "variable to switch between monitored CODE or DATA section"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009964

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPCP_adCurrent
    "Current address display for the PCP code test"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009968

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPCP_ctErr
    "Error counter for the CRC checksum calculation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000996C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPCP_ctHeal
    "Erasing counter for CRC checksum error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000996D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPCP_numCurrentCSum
    "Current checksum for the PCP code test"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009970

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_Checksum
    "Temporary result of checksum-calculation for program flow check in monitoring"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009A70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_Checkword
    "Modul specific checkword for program flow check"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009A74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_Counter
    "Module call counter for program flow check in monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCPFC_PartResp
    "Partial response from program flow check to monitoring module"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009A7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_ctMain1RamChk
    "Diagnosis counter for time of RAM-check in areas of MAIN1"
    ULONG
    Mo_ti_us_q1p0
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000B318

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_ctMain2RamChk
    "Diagnosis counter for time of RAM-check in areas of MAIN2 (excluding Protected RAM)"
    ULONG
    Mo_ti_us_q1p0
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000B31C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_ctMainProtRam
    "Diagnosis counter for time of RAM-check in areas of Protected RAM"
    ULONG
    Mo_ti_us_q1p0
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000B320

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_ctRepEx
    "Diagnosis counter for time of RAM-check in areas of recheck"
    ULONG
    Mo_ti_us_q1p0
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000B324

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_numAreasChecked
    "Diagnosis variable for amount of current checked areas"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B314

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_numReset
    "Diagnosis variable of made resets during boot up"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B313

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_stEEPInit
    "Diagnosis variable for values of MoCMem_st from EEPROM during Init"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B32C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_stProtRAMCleared
    "Status variable for state Protected-RAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B310

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRam_stRepExRam
    "Status variable of made recheck"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B311

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRom_ctRepEx_mp
    "Diagnosis counter for time of ROM-check in areas of recheck"
    ULONG
    Mo_ti_us_q1p0
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD40019D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRom_KeyCode
    "Variable to deactivate complete ROM-check of code"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRom_KeyData
    "Variable to deactivate complete ROM-check of data"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRom_numRomPageErr
    "erroneous ROM-page for single errors in complete ROM-check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B330

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRom_ptrTabIndexAct
    "Pointer for current page to be check of complete ROM-check"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B332

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCRom_stXPostDrv_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091B9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctABEFrz
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctABEFrzCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A85

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebHwNoRdy
    "Number of retries to wait for the hardware until it is ready, before beginning with the diagnose of the performed injection"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebPSDia
    "Number of repetitions of a powerstage test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebPSIni
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A89

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebSOPTst
    "Number of repetitions of shut-off path test (implementation of a time monitoring)"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebSOPTstCpl
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebWait4ABE
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctDebWait4ABECpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009A8F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrMM
    "Copy of the error counter from the monitoring module in function controller"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrMMRespByte
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrMM_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0009858

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrOSTimeout
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrRespTime
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrSPI
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctErrSPI_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD000985D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctIdx_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_ctWaitInjTstRdy
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_st
    "status variable for shut off path test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009A9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stABE_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0009862

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stAct
    "status variable for synchronizing shut off path test and query-/response communication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AAD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stActMsg
    "copy of the status variable for synchronizing shut off path test and query-/response communication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000085C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stActvMsg
    "Information for level 1, 2: Shut-off path test is on or WDA-line is active (injections disabled)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000085D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stErr
    "contains the state of the communication via SPI-subsystem to the monitoring module"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AAF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stExtSM_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0009867

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stInnerSM_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD000986C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stIVHSOPTst_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0009871

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stLdRespTab
    "status variable ""response tables loaded"""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AA1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stMm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AA3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stMmRespCnt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stMm_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0009876

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stOvl
    "Status variable for CJ945 overvoltage detection latch"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdy
    "Status variable for synchronisation from shut-off path test and query/response communication (test is done completely)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D76C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stRdyMsg
    "information for level 1,2 about status of synchronizing shut off path test and query-/resonse-communication"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000085E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stReqErrReac
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D76E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stReqErrReacCpl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D76F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_stWDA_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD000987B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_tiResp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009AA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoCSOP_tiRespMM_mp
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0009880

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoExe_ctCyc
    "10 ms counter to generate scheduling for monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009974

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_stAPP_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091BB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_stETC
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009977

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_uAPP1RawOld
    ""
    UBYTE
    Mo_u_mV_q19p53
    1
    100
    0.00
    4980.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD0009975

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_uAPP2RawOld
    ""
    UBYTE
    Mo_u_mV_q9p77
    1
    100
    0.00
    2490.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD0009976

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_uRaw1
    ""
    UWORD
    Mo_u_mV_q1p0
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009978

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_uRaw1_mp
    "Current value for accelerator pedal signal 1"
    UBYTE
    Mo_u_mV_q19p53
    1
    100
    0.00
    4980.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD00091BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_uRaw2_mp
    "Current value for accelerator pedal signal 2"
    UBYTE
    Mo_u_mV_q9p77
    1
    100
    0.00
    2490.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD00091BD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFAPP_uRawETC
    ""
    UBYTE
    Mo_u_mV_q19p53
    1
    100
    0.00
    4980.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD000997A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFBrk_st
    "status of the brake for monitoring functions"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000997B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_ctDeb
    "Error counter for engine speed comparison during function monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009988

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_ctDiag
    "Counter for setting the test flag in the diagnosis"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000085F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_nEng
    "Engine speed during function monitoring"
    UBYTE
    Mo_n_rpm_q40p0
    1
    100
    0.00
    10200.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD0009989

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_nEngL2
    ""
    UBYTE
    Mo_n_rpm_q40p0
    1
    100
    0.00
    10200.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD000997C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_phiGT1Last
    "Angle value state from previous call of the engine speed monitoring"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009980

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_stIrvErr
    "Irreversible error bit during engine speed comparison during the engine speed monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009B4B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_stSync
    "Synchronisation status of engine speed monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000998A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_stSync1
    "Identification 1 for synchronisation in function monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_stSync2
    "Identification 2 for synchronisation in function monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AC1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_stTst
    "Identification for release condition of the fault test for the diagnosis"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000860

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFESpd_tiLast
    "System time from previous call of the engine speed monitoring"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009984

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_ctTst
    "Duration of actual engine test in function monitoring"
    ULONG
    Mo_ti_s_q0p01
    1
    100
    0.00
    42949672.9500

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD000998C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stAPPIdlPos
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stAPPIdlPos_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stBrkNotPressed
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stBrkNotPressed_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091BF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stCond_mp
    "Condition for ETC Active (ShortTrip or Base Actuator) in level 2"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stRSAAPPIdlPos_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stRSABrkNotPressed_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stRSAETCond_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stRSAVehSpdCond_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stTO_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stTst
    "Engine test status for function monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009990

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stTstMsg
    "Engine test status from level 2 to level 1"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000861

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stTstRSA_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stTst_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stuRawIdlAPP_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_stuRSARawIdlAPP_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091C9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFETC_v
    ""
    UWORD
    Mo_v_kmh_q0p01
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00099DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFICO_stDisturb
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D770

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFICO_stPSShutOff
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_numCylActr_mp
    "Cylinder number injection place specific"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 10
    ECU_ADDRESS 0xD0009894

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_numInjType_mp
    "Injection type injection place specific"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 10
    ECU_ADDRESS 0xD000989E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_phiInjAct_mp
    "Angle of injection read last"
    SWORD
    Mo_phi_degCrS_q0p02197
    1
    100
    -720.0439
    720.0220

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_phiInjBegActr_mp
    "Energizing angle injection place specific"
    SWORD
    Mo_phi_degCrS_q0p02197
    1
    100
    -720.0439
    720.0220

    
    FORMAT "%8.4"
    ARRAY_SIZE 10
    ECU_ADDRESS 0xD00098A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_pLinCurr_mp
    "linearisised value of rail pressure in monitoring"
    SWORD
    Mo_p_hPa_q8000p0
    1
    100
    -262144000.
    262136000.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001CC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_stChkSum
    "Checksums of variables in MoFInjDat_GetInj"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0009AD4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_stMemChk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AD1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_stPressSRC
    "State of rail pressure sensing in MoFInjDat"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009AD8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_tiInjAct_mp
    "Energising time of injection read last"
    SWORD
    Mo_ti_us_q0p4
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CC4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_tiInjDurActr_mp
    "Energising duration injection place specific"
    SWORD
    Mo_ti_us_q0p4
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 10
    ECU_ADDRESS 0xD00098BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_tiTDCAvrg
    "Mean value of average torque-effective energising time per cylinder"
    SWORD
    Mo_ti_us_q0p4
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009ADA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_tiTDCSumET_mp
    "Sum of torque-effective energising duration cylinder specific"
    SWORD
    Mo_ti_us_q0p4
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00098D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFInjDat_uRaw_mp
    "raw voltage value of rail pressure sensor in monitoring"
    UWORD
    Mo_u_mV_q4p88
    1
    100
    0.00
    319995.1

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001CC6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFOvR_stActvMsg
    "Status about current overrun monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000862

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFOvR_stPlausInj
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009994

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFOvR_stRls
    "Status of all release bits for overrun monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFOvR_tiLimET_mp
    "Permissible energising time of overrun monitoring"
    SWORD
    Mo_ti_us_q0p4
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CC8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFOvR_tiOvRMonActive_mp
    ""
    SWORD
    Mo_ti_s_q0p04
    1
    100
    -1310.720
    1310.680

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001CCA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFRailP_ctDebErr
    "Debounce variable for the SRC error in rail pressure"
    UBYTE
    Mo_ti10ms_ms_q10p0
    1
    100
    0.00
    2550.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD0009995

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFRailP_ctDebGradMax
    "Debounce counter for the rail pressure gradient error detection"
    UBYTE
    Mo_ti10ms_ms_q10p0
    1
    100
    0.00
    2550.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD0009996

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFRailP_ctDiag
    "Counter for setting the test flag in the diagnosis of Rail Pressure"
    UBYTE
    Mo_ti10ms_ms_q10p0
    1
    100
    0.00
    2550.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD0000863

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFRailP_p
    "Rail pressure of function monitoring"
    UBYTE
    Mo_p_hPa_q8000p0
    1
    100
    0.00
    2040000.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD0009997

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFRailP_stGradErr
    "State of railpressure gradient monitoring in function monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009998

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFRailP_stIrvErr
    "Irreversible error bit for the rail pressure monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009B4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MoFRST_stRstMsg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009948

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bCplChk
    "Failure in Complement Check"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00099A1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bICOL1
    "Injection Cut Off demand from Level 1"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x2
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00099A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bICOL2
    "Injection Cut Off demand from Level 2"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x1
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00099A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bLimpHom
    "Demand of limp-home function by homogeneous mode"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x10
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00099A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bLowVltg
    "Low Voltage detected"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x4
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00099A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bRamErr
    "RAM Error occured in cyclic check"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x2
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00099A1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_bRomErr
    "ROM Error occured in cyclic check"
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    BIT_MASK 0x4
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD00099A1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_ctDebMax_u16
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 2
    ECU_ADDRESS 0xD0009A0E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_ctDebMax_u8
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 21
    ECU_ADDRESS 0xD00099F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_ctRst
    "Reset counter for Pre-ICO Reset"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D768

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_EnvCondMoCErrCol1
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD00005DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_EnvCondMoCErrCol2
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD00005E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_EnvCondMoFESpd
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD00005F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_EnvCondMoFRailP
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD00005FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_EnvCondPSShutOff
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000604

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_EnvConds
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0000606

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_ErrCol1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000864

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_ErrCol2
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000610

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stCplChk
    "Complementcheck failed"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000999C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stEEPRW
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000999A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stICODiagMsg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000865

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stICOMsg
    "Injection cut off demand from ECU monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stIrvErrReacMsg
    "Status if ICO or irrev. CAN-Error is existent. (Info to Level 1 for Healing error in case of T15-off/on by power-on reset)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000866

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoC
    "Status Bits for demands of error reaction in controller monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099A1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stMoF
    "Status Bits for demands of error reaction in function monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Mo_stRstDiagMsg
    "Message indicating Occurrence of a reset"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000867

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MRly_ctErlyOpng_mp
    "Status of main relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000849

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MRly_st
    "Request to switch on/off the main relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000084A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MRly_stAct
    "Status of main relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000084B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MRly_stStkRlytst_mp
    "Status of sticky main relay test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MRly_stStkRly_mp
    "main relais stuck"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091CB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    MRly_uBattFlt_mp
    "Status of main relay"
    SWORD
    Volt_Batt
    1
    100
    -655360.0
    655340.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001CCC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    NSCDsRLam_rLam
    "Lambda value from the sensor at NSC downstream"
    SWORD
    lambda
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD0000462

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    NSCDsRLam_rLamRec
    "Reciprocal lambda value from the sensor at NSC downstream"
    SWORD
    lambdaRecVal
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD0000464

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt1000msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004580

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt100msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004574

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt10msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004564

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt1msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004554

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt2000msTask
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004584

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt200msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004578

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt20msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004568

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt2msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004558

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt4000msTask
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004588

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt400msTask
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000457C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt40msTask
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000456C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt4msTask
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000455C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt50msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004570

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt5msTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004560

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cnt60000msTask
    ""
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000458C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntBgTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004550

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntDsmClearTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004590

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntEngReStrtTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004598

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntEpmNoSyncTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntIniEndTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000454C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntIniTask
    "Counter for this Task"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0004548

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntMoTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncDummyTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncFirstTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000459C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncIni
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004594

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncPostTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncPreTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncS0Task
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncS1Task
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_cntSyncSchedTask
    "Counter for this Task"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00045A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_accessResource_u8
    "Errors in connection with resources, however, ERCOSEK resources are not used in MEDC17."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_callevel_u8
    "Can occur if an ERCOSEK function (e. g. schedule) is called up from an ISR without permission."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_deadline_u8
    "Cannot occur as in the MEDC17 a deadline monitoring function of the system control is used instead of the ERCOSEK function."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_default_u8
    "Other unknown errors."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_generalError_u8
    "According to ETAS these error codes are not produced by ERCOSEK and can therefore not occur."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_idValue_u8
    "Alarm ID or value for Cycle/Delay for an alarm is faulty."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_limit_u8
    "Can, for example, occur in ActivateTask, if the task which is still running is meant to be called up again."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_noFuncState_u8
    "Can, for example, occur in CancelAlarm, if the alarm is not active or an active alarm is activated again."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_stackcnt_u8
    "The user or Ercosek stack has a stack over-flow/underflow."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CDA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_stackstat_u8
    "Detail-Info, if a stack over-flow/underflow occurs."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CDB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_sum_u8
    "Sum counter of all possible counters. Can be used in order to monitor as to whether an error occurs at all."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CDC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    OS_ErrCtr_timetable_u8
    "Can, for example, occur if a timetable can-not be found or if it has already been ac-tivated when being activated."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CD6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCR_stMon
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008CD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_cntErrActrTst
    "number of not detected changes of duty cycle"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000868

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_cntRepActrTst_mp
    "counter for the passed test iterations"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_cntTrgOffActrTst_mp
    "actual counter value to generate ramp trigger signal (state ""low"" of PCV_trgSigActrTst_mp)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091CD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_cntTrgOffSetPTst_mp
    "Number of sequences for ramp function in setpoint test"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D06

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_ctAdaptCalc_mp
    "Counter for the successful calculation of the adaptation"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CEE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_ctAdaptCycl_mp
    "Driving cycle counter for successful adaption"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CF0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_ctAdaptStbl_mp
    "Counter for the number of PCV adaptation function calls in the PCV_ADAPT_STABLE state"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CF2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_ctAdaptSum_mp
    "Counter for the number of PCV adaptation function calls in the PCV_ADAPT_SUM_UP state"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CF4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_ctNoStrtAct_mp
    "Counter for the actual number of failed start-up attempts because of faulty PCV"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_ctNoStrtLstCyc_mp
    "Counter for the number of failed start-up attempts till last cycle because of faulty PCV"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_dvolFlow_mp
    "Input value for the map PCV_facAdaptFlow_MAP"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001CF6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_dvolLeak_mp
    "Leakage in the pressure control valve"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D26

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_dvolMeUnFlow_mp
    "limited fuel flow through metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001CF8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_dvolPreCtlNom_mp
    "leaded away quantity from flow through metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001CFA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_facAdapt
    "Adaptation factor for the PCV curve"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD0000468

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_facAdaptFlow
    "Factor for estimating the flow through the PCV"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD000046A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_facCrntCtlLim_mp
    "Pressure setpoint of rail pressure control for the PCV"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001D12

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_facWinActrTst_mp
    "factor to calculate pressure window dependant on PCVCD_iActVal"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001CEC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iActFlt_mp
    "Pressure setpoint of rail pressure control for the PCV"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D14

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iActVal
    "Current actual value of the analog input"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000046C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iAct_mp
    "Setpoint current for the pressure control valve"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D16

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iCnvPresAdapt_mp
    "set current with adapt PCV correction value"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D18

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iCnvPres_mp
    "value of curve for converting pressure to current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D1A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iDvt
    "Setpoint current for the pressure control valve"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000046E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iEndLimSetPTst_mp
    "Limited pcv end current in setpoint test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D08

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iEndSetPTst
    "actual limited end value for pcv current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000470

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iOfsSetPTst
    "offset value for increasing of pcv current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000472

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iOldSetPTst_mp
    "actual meun current at start of setpoint test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D0A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iSet
    "Setpoint current for the pressure control valve"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000474

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iSetClose_mp
    "Current for closing the PCV"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D1C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iSetFlt
    "filtered setpoint current for the pressure control valve"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000476

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iSetMax_mp
    "Maximum current for closing the PCV"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D1E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iSetMin_mp
    "Setpoint current at pressure control valve shut-off"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D20

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iStrtLimSetPTst_mp
    "limited pcv start current in setpoint test"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D0C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iStrtSetPTst
    "actual limited start value of pcv current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000478

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_iSubstSetPTst
    "actual substitute value for pcv current"
    SWORD
    Curr
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000047A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_nSetActrTst
    "low idle speed"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000047C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_nSubsActrTst
    "engine speed during pcv actuator test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000047E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_numAdaptThres_mp
    "Threshold for adaption counter"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CFC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_numCycOffActrTst
    "number of cycles for the ramp trigger signal beeing low"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000869

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_numRepActrTst
    "number of test iterations"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000086A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pAdaptThres_mp
    "Rail pressure threshold for calculating the adaptation factor"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001CFE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pAvrgActrTst_mp
    "average of actual rail pressure RailCD_pPeak"
    SLONG
    Pres_Rail
    1
    100
    -214748364800.
    214748364700.

    
    FORMAT "%13.0"
    
    ECU_ADDRESS 0xD40019DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pFltSum_mp
    "Rail pressure added up to form the mean value"
    SLONG
    Pres_Rail
    1
    100
    -214748364800.
    214748364700.

    
    FORMAT "%13.0"
    
    ECU_ADDRESS 0xD4001A00

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pSet
    "Pressure setpoint of rail pressure control for the PCV"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD0000480

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pSetSum_mp
    "Control pressure for the PCV added up to create a mean value"
    SLONG
    Pres_Rail
    1
    100
    -214748364800.
    214748364700.

    
    FORMAT "%13.0"
    
    ECU_ADDRESS 0xD4001A04

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pStrtEvalActrTst_mp
    "reference pressure to evaluate the actual average value of RailCD_pPeak"
    SLONG
    Pres_Rail
    1
    100
    -214748364800.
    214748364700.

    
    FORMAT "%13.0"
    
    ECU_ADDRESS 0xD40019E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pWinActrTst
    "window for rail pressure changes dependant on pcv-current"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD0000482

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_pWinLoActrTst
    "initial window for rail pressure changes dependant on pcv-current"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD0000484

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_qAvrgActrTst_mp
    "average value of injection quantity InjCtl_qSetUnBal"
    SLONG
    InjMassCyc
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rDstHiActrTst
    "delta duty cycle additional to average value"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000486

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rDstLoActrTst
    "PCV_dcycDstHiActrTst_C"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000488

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rOutActrTst
    "outgoing duty cyle to cover hysteresis"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000048A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rPs
    "Output dutycycle for pressure control valve"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000048C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rSet
    "setpoint dutycycle for PCV"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000048E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rSetDT1_mp
    "Setpoint duty cycle with DT1 component"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D00

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rSetLin_mp
    "Linearised setpoint of the pressure control valve"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D02

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rStpActrTst
    "size of the steps to change duty cycle"
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000490

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_rStrtActrTst_mp
    "average value of duty cycle of PCV"
    SLONG
    DtyCyc
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stActrCtl
    "State of the actuator value control for the pressure control valve"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000086B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stAdapt
    "Status of the status machine for the adaptation function"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000086C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stAdaptMeUn
    "Release message for the metering unit"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000086D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stDefActrTst
    "boolean value for PCV state: defect=true, ok=false"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000086E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stEffectActrTst
    "effect bits"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000086F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stEffectSetPTst
    "effect bits of setpoint test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000870

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stEngStrtMov_mp
    "Engine movement in the calculation of the electrical setpoint current for the PCV"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stNoStrt
    "Status message of rail pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000871

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stParSetPTst
    "parameter for setting running modes"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000872

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stRefActrTst
    "refuse bits"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000612

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stRefSetPTst
    "refuse conditions for setpoint test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000614

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stRsltActrTst
    "message construct consisting of PCV_cntErrActrTst and PCV_stDefActrTst"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000616

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stSetClose_mp
    "State requirement for closing the PCV"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stStMActrTst
    "actual state of state-machine"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000873

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_stStMSetPTst
    "state machine for setpoint test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000874

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_swtCtlState
    "Pressure setpoint of rail pressure control for the PCV"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000875

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_swtSrcPSActrTst_mp
    "selection of parameters ( 0 = application data, 1 = tester data )"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091CE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiCalcActrTst_mp
    "calculated application time (PCV_numCycOffActrTst * 10ms)"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiDelActrTst_mp
    "stopwatch for delay time to record values and calculate PCV_pAvrgActrTst_mp"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiDelMeasActrTst
    "delay time for evaluation"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD0004324

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiDlySetPTst
    "delay time between two ramps"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000492

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiNoStrt_mp
    "time which shows the current time since no valid engine start"
    UWORD
    Time_ms
    1
    100
    0.00
    655350.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D22

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiSetCloseMax_mp
    "Dwell time in the PCV_stActrCtl == PCV_CLOSE_MODE (0x20) state"
    UWORD
    Time_ms
    1
    100
    0.00
    655350.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D24

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiStpMeasSetPTst_mp
    "actual measured time for one step to increase pcv current"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D0E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiStpSetPTst
    "time for one step to increase pcv current"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000494

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiTotalActrTst_mp
    "stopwatch for total test time"
    SLONG
    Time_s
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD40019F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiTotSetPTst_mp
    "total time for setpoint test"
    SWORD
    Time_s
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D10

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_tiWaitActrTst_mp
    "stopwatch for waiting time"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_trgSigActrTst_mp
    "trigger signal to ramp dutycycle of pcv and control evaluation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091CF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_trgSigSetPTst_mp
    "trigger signal for ramp function"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_uAvrgActrTst_mp
    "average value of battery voltage BattCD_u"
    SLONG
    Volt_Batt
    1
    100
    -42949672960.0
    42949672940.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD40019FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PCV_uRaw_mp
    "Duty cycle setpoint for the pressure control value"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001D04

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PFltLd_stRgnThrActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000876

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PSP_st
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000877

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PthSet_stOvrRun
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000087A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PthSet_stOvrRunCoord
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000087B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PthSet_trqInrSet
    ""
    SWORD
    Trq
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000049A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PT_rGrip
    ""
    SWORD
    TransR
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000496

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PT_rTrq
    ""
    SWORD
    TransR
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000498

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PT_stGrip
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000878

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    PT_stTraType
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000879

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_CEngDsT_mp
    "coolant temperature as input parameter of temperature calculation of QWC"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001D28

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_facFTS
    "Pressure wave correction factor based on the fuel temperature"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD000049C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_facMI1PoI2_mp
    "Weighting factor for activating/deactivating the pressure wave quantity change of MI1 by PoI2"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D2C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_facPiI2PiI1_mp
    "Weighting factor for activating/deactivating the pressure wave quantity change of PiI2 by PiI1"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D2E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_facPiIMI1_mp
    "Weighting factor for activating/deactivating the pressure wave quantity change of PiI1 by MI1"
    SWORD
    Fact1
    1
    100
    -256.0000
    255.9922

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_FuelT_mp
    "fuel temperature as input parameter of temperature calculation of QWC"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001D2A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_pCurrInDiffHyd_mp
    "Current rail pressure as input value for the map QWC_tiDiffHyd_MAP"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qDesInDiffHyd_mp
    "Desired injection quantity as input value for the map QWC_tiDiffHyd_MAP"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D4E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qMI1
    "MI1 pressure wave correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000049E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qMI1PoI2_mp
    "Base value of MI1 pressure wave correction based on PoI2"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D32

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qNorm
    "Injection normalisation quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00004A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qPiI1
    "PiI1 pressure wave correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00004A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qPiI1MI1_mp
    "PiI1 pressure wave correction quantity base value based on MI1"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D34

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qPiI2MI1_mp
    "PiI2 pressure wave correction quantity base value based on MI1"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D36

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qPiI2PiI1_mp
    "PiI2 pressure wave correction quantity base value based on PiI1"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_qPoI2
    "PoI2 pressure wave correction quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00004A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_rMI1Norm_mp
    "Normalised MI1 injection behaviour for pressure wave correction based on the rail pressure"
    SWORD
    QntR
    1
    100
    -32.00000
    31.99902

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001D3A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_st
    "Status of pressure wave correction"
    UBYTE
    QWC_st_VERB
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000087C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tCor
    "Input temperature for the pressure wave correction"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiMI1DiffHydCor_mp
    "Difference between the end of the hydraulic needle closing and the end of the electrical energizing of the injector for MI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiMI1PoI2Cor_mp
    "Corrected time interval between MI1 and PoI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D3C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiMI1PoI2_mp
    "Time interval from end of MI1 to beginning of PoI2"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D3E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI1DiffHydCor_mp
    "Difference between the end of the hydraulic needle closing and the end of the electrical energizing of the injector for PiI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D52

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI1MI1Cor_mp
    "Corrected time interval between PiI1 and MI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI1MI1_mp
    "Interval from end of PiI1 to beginning of MI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D42

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI2DiffHydCor_mp
    "Difference between the end of the hydraulic needle closing and the end of the electrical energizing of the injector for PiI2"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D54

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI2MI1Cor_mp
    "Corrected time interval between PiI2 and MI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D44

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI2MI1_mp
    "Interval from end of PiI2 to beginning of MI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D46

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI2PiI1Cor_mp
    "Corrected time interval between PiI2 and PiI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    QWC_tiPiI2PiI1_mp
    "Interval from end of PiI2 to beginning of PiI1"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D4A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_ctGradExcd_mp
    "Number of pressure spikes detected"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D60

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_numPerMeasTst
    "intervall between to measurement points"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000618

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_pCurr_mp
    "Current fuel pressure"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D5C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_pFlt
    "Maximum rail pressure during last 10ms"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_pFltWinNeg_mp
    "Rail pressure decrease from which the system switches to the large signal parameter"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D5E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_pLin
    "Linearised value of the fuel pressure sensor"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_pLinCurr_mp
    "Maximum SRC default value"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D56

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stEngStrtMov_mp
    "Engine movement determined during offset monitoring of the rail pressure sensor"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stEpmTested_mp
    "Error status of camshaft and crankshaft speed sensors"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stGrad
    "Status of the gradient test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000087D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stMon_mp
    "Monitoring status of rail pressure sensor voltage offset"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stOfsTstMon
    "Current state of the rail pressure sensor offset monitoring"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000087E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stOfsTstXPostDrv_mp
    "Postdrive extension by VDOfsTst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stSRCCurr_mp
    "Maximum SRC default value"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091D5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stStMMeasTst
    "current state of rail perssure measurement test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000087F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_stSubsVal
    "state for railressure replaced value in case of an error"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000880

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_swtMeasTyp
    "switch to select desired type of measurement"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000881

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_tClntLstCyc_mp
    "Water temperature from last driving cycle for offset monitoring of the rail pressure sensor"
    SWORD
    Temp_Cels
    1
    100
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001D62

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_tidPresRst_mp
    "Recovery time of the pressure jump counter."
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD4001A0C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_tiFltPT1_mp
    "Current filter time for PT1 filter"
    SLONG
    TimeDelay_s
    1
    100
    0.000002000000001
    4294.9672960

    
    FORMAT "%12.7"
    
    ECU_ADDRESS 0xD4001A08

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_tiOfsTstDel_mp
    "Delay time = f(RailP_pFlt) for rail pressure sensor offset test"
    SWORD
    TimeRed
    1
    100
    -5242.880
    5242.720

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001D64

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uOfsAftRun
    "Value of the rail pressure sensor voltage during active monitoring in after-run"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uOfsAftRunMax
    "Upper offset threshold of the rail pressure sensor offset monitoring during after-run"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uOfsAftRunMin
    "Lower offset threshold of the rail pressure sensor offset monitoring during after-run"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uOfsStrt
    "Value of the rail pressure sensor voltage during active monitoring in the starting phase"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004B2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uOfsStrtMax
    "Upper offset threshold of the rail pressure sensor offset monitoring during startup"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uOfsStrtMin
    "Lower offset threshold of the rail pressure sensor offset monitoring during startup"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uRaw
    "Raw value of rail pressure"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00004B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uRawMax
    "maximum raw value of rail pressure from the ADC"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000559C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uRawNoCorCur_mp
    "uncorrected RDS output voltage"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001D58

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RailP_uRawNoCor_mp
    "not corrected rail pressure voltage raw value"
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001D5A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_cntHpTst_mp
    "Currently active phase of HpTst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091DD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_cntInjHpTst_mp
    "Injection counter for HpTst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_cntTrgOffSetPointTst_mp
    "Number of sequences for ramp function in setpoint test"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001DF4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dpSetPointDec
    "Maximum rail pressure setpoint increase on negative ramp"
    SWORD
    PresRail_sec
    1
    100
    -13107200.
    13106800.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dpSetPointInc
    "Maximum rail pressure setpoint increase per second"
    SWORD
    PresRail_sec
    1
    100
    -13107200.
    13106800.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dpSetPointIncLim
    ""
    SWORD
    PresRail_sec
    1
    100
    -13107200.
    13106800.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004BE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolCPCDvtFlt_mp
    "Filtered volume flow deviation"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D66

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolCPCDvt_mp
    "Volume flow deviation selected"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolEstAged
    "Estimated volume flow of an aged system"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD00004C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolInjVlvCtl_mp
    "Correction value of the precontrol after consideration of the control quantities for the injectors"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DC6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolLeak_mp
    "Leakage of the high pressure system"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DC8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnCtlDT1_mp
    "DT1 component of pressure governor by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D6A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnCtlI
    "I component of pressure governor by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD00004C2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnCtlP_mp
    "P component of pressure governor by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnCtlType_mp
    "value to detect overrun"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnCtlUpLim
    "Upper actuator value limit for pressure governing by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD00004C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnCtl_mp
    ""
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D6E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnDvt
    "Volume flow governor deviation"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD00004C6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnLimFst_mp
    "maximum admissible set value MeUn for rail pressure monitoring as a function of set value of metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DB4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolMeUnShutOff_mp
    "selected volume flow rate of fuel while switching off the system"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtl
    "Precontrol value for pressure governing by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD00004C8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtlAdaptPCV
    "Discharged fuel quantity"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD00004CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtlBas_mp
    "Basic precontrol value from map for pressure governing by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DCA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtlInit_mp
    "Precontrol initialization value for pressure control by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DCC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtlInj_mp
    "Precontrol value for pressure governing by metering unit (injection specific part)"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DCE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtlOfs_mp
    "Offset from the map for precontrol of pressure control by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DD0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtlPoI1_mp
    "Precontrol value based on post injection quantity 1 for pressure control by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DD2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolPreCtlPoI2_mp
    "Precontrol value based on post injection quantity 2 for pressure control by metering unit"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DD4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_dvolSetPoint_mp
    "Rail pressure setpoint based on the volume flow"
    SWORD
    Qp_mm3_sec
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_facFlPLimFTSCor_mp
    ""
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001E00

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_facMeUnCtlICor_mp
    "Correction factor for I amplification for pressure control by metering unit"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001D96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_facMeUnCtlPCor_mp
    "Correction factor for P amplification for pressure control by metering unit"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001D98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_facMeUnTiRmpVal_mp
    "Current ramp value of the ramp during switchover from control by metering unit to control by pressure control valve"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001D74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_facPCVTiRmpVal_mp
    "Current ramp value of the ramp during switchover from control by pressure control valve to control by metering unit"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001DD8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_facTiRmpVal_mp
    "Current ramp value when the offset curve is ramped to a reduced offset curve and vice versa."
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001DDA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_iMeUnClsHpTst
    "current to close the MeUn during high pressure test"
    UWORD
    Curr
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000061A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlDKd_mp
    "D amplification for pressure control by metering unit"
    SLONG
    Kd_pRail2Q
    1
    100
    -3276.80000000
    3276.79999847

    
    FORMAT "%13.8"
    
    ECU_ADDRESS 0xD4001A10

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlIKiHpTst_mp
    "I-Amplification for pressure governor via metering unit durinh HpTst"
    SLONG
    Ki_pRail2Q
    1
    100
    -100000.000000
    99999.9999534

    
    FORMAT "%13.6"
    
    ECU_ADDRESS 0xD4001A14

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlIKiNeg_mp
    "I amplification for negative large signals for pressure control by metering unit"
    SLONG
    Ki_pRail2Q
    1
    100
    -100000.000000
    99999.9999534

    
    FORMAT "%13.6"
    
    ECU_ADDRESS 0xD4001A18

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlIKiPos_mp
    "I amplification for positive large signals for pressure control by metering unit"
    SLONG
    Ki_pRail2Q
    1
    100
    -100000.000000
    99999.9999534

    
    FORMAT "%13.6"
    
    ECU_ADDRESS 0xD4001A1C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlIKi_mp
    "I amplification for small signals for pressure control by metering unit"
    SLONG
    Ki_pRail2Q
    1
    100
    -100000.000000
    99999.9999534

    
    FORMAT "%13.6"
    
    ECU_ADDRESS 0xD4001A20

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlPKpHpTst_mp
    "P-Amplification for pressure governor via metering unit"
    SLONG
    Kp_pRail2Q
    1
    100
    -6553.60000000
    6553.59999695

    
    FORMAT "%13.8"
    
    ECU_ADDRESS 0xD4001A24

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlPKpNeg_mp
    "P amplification for negative large signals for pressure control by metering unit"
    SLONG
    Kp_pRail2Q
    1
    100
    -6553.60000000
    6553.59999695

    
    FORMAT "%13.8"
    
    ECU_ADDRESS 0xD4001A28

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlPKpPos_mp
    "P amplification for positive large signals for pressure control by metering unit"
    SLONG
    Kp_pRail2Q
    1
    100
    -6553.60000000
    6553.59999695

    
    FORMAT "%13.8"
    
    ECU_ADDRESS 0xD4001A2C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_MeUnCtlPKp_mp
    "P amplification for small signals for pressure control by metering unit"
    SLONG
    Kp_pRail2Q
    1
    100
    -6553.60000000
    6553.59999695

    
    FORMAT "%13.8"
    
    ECU_ADDRESS 0xD4001A30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_nHpTst
    "Array of engine speed levels for the HpTst"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD00004CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_nSetPntHpTst_mp
    "engine speed setpoint desired from HpTst"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001DA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_nSubsHpTst
    "Engine speed druing rail high pressure engine test"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00004D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pCPCFltMin_mp
    "Output of the curve Rail_pCPCFltMin_CUR"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pCPCSetMax_mp
    "threshold for PCV set value to detect rail pressure error in CPC mode"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DB2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_PCVCtlDKd_mp
    "D amplification for pressure control by PCV"
    SLONG
    Kd
    1
    100
    -32768.0000000
    32767.9999847

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0xD4001A3C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_PCVCtlIKiNeg_mp
    "I amplification for negative large signals for pressure control by PCV"
    SLONG
    Ki
    1
    100
    -1000000.00000
    999999.999534

    
    FORMAT "%13.5"
    
    ECU_ADDRESS 0xD4001A40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_PCVCtlIKiPos_mp
    "I amplification for positive large signals for pressure control by PCV"
    SLONG
    Ki
    1
    100
    -1000000.00000
    999999.999534

    
    FORMAT "%13.5"
    
    ECU_ADDRESS 0xD4001A44

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_PCVCtlIKi_mp
    "I amplification for small signals for pressure control by PCV"
    SLONG
    Ki
    1
    100
    -1000000.00000
    999999.999534

    
    FORMAT "%13.5"
    
    ECU_ADDRESS 0xD4001A48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_PCVCtlPKpNeg_mp
    "P amplification for negative large signals for pressure control by PCV"
    SLONG
    Kp
    1
    100
    -65536.0000000
    65535.9999695

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0xD4001A4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_PCVCtlPKpPos_mp
    "P amplification for positive large signals for pressure control by PCV"
    SLONG
    Kp
    1
    100
    -65536.0000000
    65535.9999695

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0xD4001A50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_PCVCtlPKp_mp
    "P amplification for small signals for pressure control by PCV"
    SLONG
    Kp
    1
    100
    -65536.0000000
    65535.9999695

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0xD4001A54

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pDltTmrUpHpTst
    "Pressure threshold for build up time meassurement"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pDvt
    "Governor deviation of the rail pressure governor"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pDvtFltLim_mp
    "Filtered governor deviation of rail pressure"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pEndLimSetPointTst_mp
    "limited rail end pressure in setpoint test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DF6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pEndSetPointTst
    "actual limited end value for rail pressure"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMaxSetSubst
    "upper limit of substituded rail pressure setpoint value"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMeUnDvt
    "Governor deviation for the MeUn governor"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMeUnDvtFst_mp
    "Maximum governor deviation allowed for rail pressure monitoring as a function of engine speed for fast monitoring"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DB6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMeUnDvtMax_mp
    "Output of the curve Rail_pMeUnDvtMax_CUR"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DB8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMeUnDvtMin2_mp
    "Minimum governor deviation allowed for rail pressure monitoring as a function of engine speed for second monitoring stage"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DBA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMeUnDvtMin_mp
    "Output of the curve Rail_pMeUnDvtMin_CUR"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DBC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMeUnDvtPre_mp
    "Governor deviation for the metering unit determined by CPC governing"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMeUnFltMin_mp
    "Output of the curve Rail_pMeUnFltMin_CUR"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DBE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pMinRailSetPnt_mp
    "rail pressure for timer up hp test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DA6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pOfsSetPointTst
    "offset value for increasing of rail pressure"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pOldSetPointTst_mp
    "actual rail pressure at start of setpoint test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DF8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVClose_mp
    "Control value for holding the PCV closed"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DDC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVCPCOfs_mp
    "Recalculated CPC offset value for the control value for holding the PCV closed"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D7A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVCtlDT1_mp
    "DT1 component of pressure governor by metering unit"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVCtlI_mp
    "I component of pressure governor by metering unit"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D7E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVCtlLoLim_mp
    "Lower set value limitation of rail pressure governor by PCV"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVCtlPILim_mp
    "DT1 component of pressure governor by metering unit (limited)"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVCtlP_mp
    "P component of pressure governor by PCV"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVCtlUpLim_mp
    "Upper set value limitation of rail pressure governor by PCV"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVDvt
    "Governor deviation for the PCV governor"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVDvtMax_mp
    "Output of the curve Rail_pPCVDvtMax_CUR"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVDvtPre_mp
    "Governor deviation for the pressure control valve determined by CPC governing"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVFltMin_mp
    "Output of the curve Rail_pPCVFltMin_CUR"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVInitI_mp
    "Initialization of the I component of the pressure governor when switching from metering unit to pressure control valve"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVOfs_mp
    "Ramp switch output for the control value for holding pressure control valve closed"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DDE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVRedOfs_mp
    "Measuring point for precontrol reduction for quicker pressure reduction by the pressure control valve"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DE0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPCVSetMax_mp
    "Maximum admissible setpoint pressure for rail pressure monitoring"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DC4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPreCtl_mp
    "Precontrol value for pressure control by the pressure control valve"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DE2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pPT1Flt_mp
    "PT1 filtered rail pressure for pressure control by metering unit"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetHiHpTst
    "desired fuel pressure during build up phase of high pressure test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetMaxHpTst
    "Maximum fuel pressure setpoint requested by HpTst"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetMinHpTst
    "Minimum fuel pressure setpoint requested by HpTst"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetMin_mp
    "Curve value for the minimum rail pressure as set value"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPntHpTst_mp
    "Rail pressure setpoint requested from HpTst"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPoint
    "Rail pressure setpoint"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointDec_mp
    "Maximum rail pressure setpoint decrease per schedule sequence"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DE8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointInc_mp
    "Maximum rail pressure setpoint increase per schedule sequence"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DEA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointLim_mp
    "Rail pressure setpoint after range limitation in normal operation"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DEC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointMax
    "Maximum rail pressure setpoint"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointMin
    "Minimum rail pressure setpoint"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointRSA
    ""
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointSubst
    "External request for the rail pressure setpoint"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointZFCLim_mp
    "rail pressure setpoint value with ZFC dependend limitation"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DEE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetPointZFC_mp
    "Rail pressure setpoint after ZFC intervention"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DF0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSetZLHpTst
    "Zero load fuel pressure setpoint requested by HpTst"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pStepHpTst
    "Fuel pressure setpoint steps for HpTst"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pStrtLimSetPointTst_mp
    "limited rail start pressure in setpoint test"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DFA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pStrtSetPointTst
    "actual limited start value of rail pressure"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pSubstSetPointTst
    "actual substitute value for rail pressure"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pTmrDwn1HpTst
    "Pressure threshold for first drop down time measurement"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pTmrDwn2HpTst
    "Pressure threshold for second drop down time measurement"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00004FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pTmrUpHpTst_mp
    "measuremen tpoint for pressure threshold for build up time measurement"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001DAA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pWindUp_mp
    "Recalculated I component when actuator limitation is reached"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001D8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_pZFCInit_mp
    "Beginning ZFC rail pressure setpoint for PT1 filter"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001E08

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qAvrgHpTst_mp
    "Reference quantity for HpTst"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001DAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qCPCtlTypeRgn_mp
    "quantity to switch to PCV Mode in regeneration"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qCPCtlType_mp
    "Fuel quantity limit for switching to CPC governing"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001D9E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qFlPLimCor_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E02

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qFlPLim_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E04

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qFlTempLim_mp
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001E06

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qLim
    ""
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000500

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qMeUnCtlType_mp
    "Hysteresis threshold for switching to pressure control by metering unit based on fuel quantity"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001DA0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qPreCtlBas_mp
    "Injection quantity selected for precontrol"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001DD6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_qSetPointInc_mp
    "quantity for rail pressure increment limitation"
    SWORD
    InjMass
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001DF2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stCPC
    "Status of the state machine for switching the rail pressure control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000882

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stCPCMon1_mp
    "State bits for the monitoring of the PCV set value"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091DF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stCPCMon3_mp
    "Status bits for monitoring for minimum rail pressure during switchover to CPC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stCPCMon4_mp
    "Error path for monitoring for maximum rail pressure during switchover to CPC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stCtlLoop
    "State of the rail pressure governor control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000883

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stCtlType
    "Status of governor concept and governor principle applied"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000884

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stDwn1HpTst
    "First status of build up phase"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stDwn2HpTst
    "Second status of build up phase provided"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stDwn3HpTst
    "Third status of build up phase provided"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stDwnHpTst
    "Status of current drop down phase of HpTst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0000885

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stEffectHpTst
    "Interface of HpTst to other functions"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000088A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stEffectSetPointTst
    "effect bits of setpoint test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000088B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stMeUnFrzI_mp
    "Status of the recalculated I component for the set value limitation for metering unit control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091DA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stMeUnMon0_mp
    "State bits for monitoring for a positive governor deviation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stMeUnMon1_mp
    "State bits for monitoring for a positive governor deviation and setpoint value of the volume flow through the metering unit"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stMeUnMon2_mp
    "State bits for monitoring for a negative governor deviation at zero delivery"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stMeUnMon3_mp
    "State bits for monitoring for minimum rail pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stMeUnMon4_mp
    "State bits for monitoring for maximum rail pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stParSetPointTst
    "parameter for setting running modes"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000088D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVFrzI_mp
    "stae of frozen I-part of PCV governor"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091DB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVMon0_mp
    "State bits for monitoring for a positive governor deviation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVMon1_mp
    "Status bits for monitoring for a positive governor deviation combined with PCV set value"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVMon2_mp
    "Status bits for monitoring for a negative governor deviation combined with PCV set value"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091E9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVMon3_mp
    "State bits for monitoring for minimum rail pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVMon4_mp
    "State bits for monitoring for maximum rail pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091EB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVRedOfs_mp
    "state value to switchover reduced offset value for the pre control value PCV"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001DE4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPCVWindUp
    "Status of the recalculated I component for the set value limitation for the PCV"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000088C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stPresMinZFC_mp
    "State of the state machine that determines the minimum rail pressure threshold"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stQLim_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091EF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stRefHpTst
    "Status of running conditions for HpTst"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000061C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stRefSetPointTst
    "refuse conditions for setpoint test"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000061E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stSetSubstCond_mp
    "bitcoded state of switching conditions to substituted rail pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stStMHpTst
    "Status of HpTst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000088E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stStMSetPointTst
    "state machine for setpoint test"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000088F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stSwtCon_mp
    "Status of switchover conditions for the governor principle"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stSwtCPCCon_mp
    "Status of switchover condition for the CPC state machine"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001DA2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stUp1HpTst
    "Status of current build up phase of HpTst"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD00043FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stUpHpTst
    "Array of states of build up phases of HpTst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 5
    ECU_ADDRESS 0xD0000890

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_stZFCDem_mp
    "Status for closed PCV when ZFC learning phase is active"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_swt5StepHpTst
    "Switch to enable fifth step without injections"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000895

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_swtCtlParHpTst
    "Switch to enable separate governor parameters during HpTst"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000896

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_swtCtlSel
    "Status for governor concept used (CPC or 2-actuator)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000897

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_swtPreCtl
    "Rail pressure governor with/without precontrol"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000898

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_swtPress
    "Switchover between open loop and closed loop control using the absolute/differential value of the rail pressure"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000899

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_swtTstParHpTst
    "Switch to select parametes from tester (1) or dataset (0)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000089A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_swtWindUp
    "Rail pressure governor with frozen or recalculated I component"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000089B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiDelSetPointTst
    "delay time between two ramps"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000502

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiDrop5StpHpTst
    "Time durations of rail pressure between the pressure thresholds during the drop down phase"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    ARRAY_SIZE 16
    ECU_ADDRESS 0xD0000504

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiDwnHpTst
    "Array of drop down time of each phase"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    ARRAY_SIZE 7
    ECU_ADDRESS 0xD0004328

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiHpTst_mp
    "Timer for state durations of HpTst"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD4001A5C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUn0Deb_mp
    "MeUn 0 = measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A60

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUn1Deb_mp
    "MeUn 1 = measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A64

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUn2Deb_mp
    "MeUn 2 = measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUn3Deb_mp
    "MeUn 3 = measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUn4Deb_mp
    "MeUn 4 = measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUnCtlDT1_mp
    "Time constant of the DT1 element for pressure control by metering unit"
    SLONG
    TimeDelay_s
    1
    100
    0.000002000000001
    4294.9672960

    
    FORMAT "%12.7"
    
    ECU_ADDRESS 0xD4001A34

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUnCtlPT1_mp
    "Time constant of the PT1 filter for pressure control by metering unit"
    SLONG
    TimeDelay_s
    1
    100
    0.000002000000001
    4294.9672960

    
    FORMAT "%12.7"
    
    ECU_ADDRESS 0xD4001A38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiMeUnRmpDur_mp
    "Runtime of the ramp to ramp the delivery volume of the metering unit from the current setpoint to the maximum delivery"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001D8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiPCV0Deb_mp
    "PCV 0 = Measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiPCV1Deb_mp
    "PCV 1 = Measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiPCV2Deb_mp
    "PCV 2 = Measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiPCV3Deb_mp
    "PCV 3 = Measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiPCV4Deb_mp
    "PCV 4 = Measuring point for running debounce counters"
    ULONG
    InjTime_us
    1
    100
    0.00
    1717986918.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiPCVCtlDT1_mp
    "Time constant of the DT1 element for pressure control by PCV"
    SLONG
    TimeDelay_s
    1
    100
    0.000002000000001
    4294.9672960

    
    FORMAT "%12.7"
    
    ECU_ADDRESS 0xD4001A58

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiPCVRmpDur_mp
    "Runtime of the ramp to ramp from the current setpoint to the new PCV closing value"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DE6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiRmpHpTst_mp
    "Timer for ramps in HpTst"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DAE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiStpMeasSetPointTst_mp
    "actual measured time for one step to increase rail pressure"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DFC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiStpSetPointTst
    "time for one step to increase rail pressure"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD0000524

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiSwtCPC_mp
    "Current dwell time in a transition state of the CPC state machine"
    UWORD
    Time_ms
    1
    100
    0.00
    655350.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001D90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiTotSetPointTst_mp
    "total time for setpoint test"
    SWORD
    Time_ms
    1
    100
    -327680.0
    327670.0

    
    FORMAT "%8.1"
    
    ECU_ADDRESS 0xD4001DFE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_tiUpHpTst
    "Array of build up time of each phase"
    SLONG
    Time_ms
    1
    100
    -21474836480.0
    21474836470.0

    
    FORMAT "%13.1"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0004344

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rail_trgSigSetPointTst_mp
    "trigger signal for ramp function"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091ED

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env.adLoc
    "Reset information / Address location where the last reset occurs"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0003140

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env.xUserValue
    "Reset information / User defined value of the last reset reason"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0003144

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env.xId
    "Reset information / Reset-ID of the last reset reason"
    UWORD
    Reset_ID
    1
    100
    0.00
    130.000000000

    
    FORMAT "%13.9"
    
    ECU_ADDRESS 0xD0003148

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env.xGrp
    "Reset information / Reset-group-ID of the last reset reason"
    UBYTE
    Reset_GrpID
    1
    100
    0.00
    31.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD000314A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Env.ctRst
    "Reset information / Reset counter which counts all resets"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000314B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_FlMRErrBuf
    "Buffer in which errors from the flash marginread test are stored"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0007D8B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_MoCADC_st
    "Value of MoCADC_st stored in protected RAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D842

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_MoCADC_uTst
    "Modified Value of MoCADC_uTst stored in protected RAM"
    SBYTE
    Mo_u_mV_q39p06
    1
    100
    -5000.
    4961.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD000D843

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_MoCCom_st
    "Value of MoCCom_st stored in protected RAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D844

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_MoCMem_st
    "Value of MoCMem_st stored in protected RAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D845

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_MoCSOP_st
    "Value of MoCSOP_st stored in protected RAM"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000D846

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_MoFESpd_nEngShftd
    "Modified Value of MoFESpd_nEngShftd stored in protected RAM"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000D848

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Mo_ctRst
    "Value of Mo_ctRst stored in protected RAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D840

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Mo_stMoC
    "Value of Mo_stMoC stored in protected RAM"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D841

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_TrapErrIntrBuf
    "Buffer in which ErrorInterrupts and Traps are stored"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 4
    ECU_ADDRESS 0xD0007D87

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Vxx_acel_pdl_sens_v1
    "Value of Vxx_acel_pdl_sens_v1 stored in protected RAM"
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000D84A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_Vxx_tqi_fim_tot
    "Value of Vxx_tqi_fim_tot stored in protected RAM"
    UWORD
    Reset_mg_stk
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000D84C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_xHistBuf
    "Historybuffer of the last 8 Reset-ID's"
    UWORD
    Reset_ID
    1
    100
    0.00
    130.000000000

    
    FORMAT "%13.9"
    ARRAY_SIZE 8
    ECU_ADDRESS 0xD000D830

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Reset_xId
    "Message containing reset ID number"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000620

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    RsaETC_stEngTstActv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099DD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_ctInterrupt_u16
    "Interrupt occurence in this sample"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E0A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_ctReentrantSample_u32
    "Reentrant samples"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001A88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_ctSampleProc_u8
    "count of measurements"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007D94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_ctSample_u16
    "samples in the specified sampling-time"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001E0C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_flState_u8
    "Rtmo State and Error flags"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiAvrg_Tick
    "Average runtime"
    ULONG
    Rtmo_Time_us
    1
    100
    0.00
    53687091.1875

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001A8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiLoad_u16
    "LoadTime"
    UWORD
    Rtmo_Percent_u16
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD4001E0E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiMaxCalldist_Tick
    "Maximal calldistance"
    ULONG
    Rtmo_Time_us
    1
    100
    0.00
    53687091.1875

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001A90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiMaxLoadRun_u16
    "maximum system during actual drive cycle"
    UWORD
    Rtmo_Percent_u16
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD0005638

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiMaxLoad_u16
    "Maximum system load"
    UWORD
    Rtmo_Percent_u16
    1
    100
    0.00
    99.99847

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000D84E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiMax_Tick
    "Maximal runtime"
    ULONG
    Rtmo_Time_us
    1
    100
    0.00
    53687091.1875

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001A94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiMinCalldist_Tick
    "Minimal calldistance"
    ULONG
    Rtmo_Time_us
    1
    100
    0.00
    53687091.1875

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001A98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiMin_Tick
    "Minimal runtime"
    ULONG
    Rtmo_Time_us
    1
    100
    0.00
    53687091.1875

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001A9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Rtmo_tiSampleDuration_Tick
    "Sample duration"
    ULONG
    Rtmo_Time_us
    1
    100
    0.00
    53687091.1875

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD4001AA0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SpdGov_nSetPLo
    ""
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0000526

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SSPMon_dfdec1_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CE4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SSPMon_dfdec2_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CE6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SSPMon_dfdec3_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CE0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SSPMon_dfinc1_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CE8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SSPMon_dfinc2_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CEA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SSPMon_dfinc3_mp
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001CE2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Strt_st
    "The control value of the actuation of starter relay"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000089C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Strt_stPs
    "The output of the starter to the powerstage"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000089D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    StSys_stStrt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008CE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctDeadline1msErr
    "Number of deadline violations in 1ms-Task"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007D9D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctInit_mp
    "Number of ECU initializations since the ECU has been switched on"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B360

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctIrrSwOff
    "Counter for detection of irregular switch-off of the ECU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000089E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctSwtOnCan_mp
    "Counter switching-on ECU by CAN"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctSwtOnEin_mp
    "Counter switching-on ECU by Terminal 15"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctSwtOnStc_mp
    "Counter switching-on ECU by stopcounter"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctSwtOnWak_mp
    "Counter switching-on ECU by WAK pin"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091FB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_ctUnderVltg_mp
    "Number of 5V undervoltage cases since the ECU has been switched on"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000B361

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stMn
    "Current system/ECU state"
    UBYTE
    ExeCon_State_01
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD000089F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stMnOld
    "Previous system/ECU state"
    UBYTE
    ExeCon_State_01
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00008A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stPostDrv
    "PostDrive control state"
    UBYTE
    SyC_PostDrv_State
    1
    100
    0.00
    7.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00008A1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stPostDrvFin_mp
    "PostDrive was regularly finished since last switch-on"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091F7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stPreDrv
    "PreDrive control state"
    UBYTE
    SyC_PreDrv_State
    1
    100
    0.00
    9.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00008A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stStopCntXPostDrv_mp
    "Requirement by stopcounter to prolong PostDrive"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091FD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stSub
    "Current system/ECU sub-state"
    UBYTE
    ExeCon_State_02
    1
    100
    0.00
    6.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00008A3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stSubOld
    "Previous system/ECU sub-state"
    UBYTE
    ExeCon_State_02
    1
    100
    0.00
    6.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD00008A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stSwtOn_mp
    "Status current reason for switching-on ECU"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stT15
    "State of Terminal 15 for system control"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008CF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_stVldTiEcuOff
    "ECU off time valid"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiBoot_mp
    "Time from ECU switch-on until system state SYC_INI is reached"
    ULONG
    Time_usec_q1_COMPU
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001AA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiDrv
    "Time since state SYC_DRIVE was reached"
    ULONG
    Time_msec_q10_COMPU
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD0004400

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiEcuOff
    "ECU off time"
    SLONG
    Time_sec_q1_COMPU
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0004354

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiFrst10ms
    "Time from ECU switch-on until the first 10ms task"
    UWORD
    Time_msec_q1_COMPU
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000622

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiIniEnd_mp
    "Duration of system state SYC_INIEND"
    UWORD
    Time_usec_q1_COMPU
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001EA2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiIniSyn_mp
    "Duration of system state SYC_INISYN"
    UWORD
    Time_usec_q1_COMPU
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001EA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiIni_mp
    "Duration of system state SYC_INI"
    ULONG
    Time_usec_q1_COMPU
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD4001AA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiPostDrv
    "Time since state SYC_POSTDRIVE was reached"
    ULONG
    Time_msec_q10_COMPU
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD0004404

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiPreDrv
    "Time since state SYC_PREDRIVE was reached"
    ULONG
    Time_msec_q10_COMPU
    1
    100
    0.00
    42949672950.0

    
    FORMAT "%13.1"
    
    ECU_ADDRESS 0xD0004408

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiShutdown_mp
    "Duration of system state SYC_SHUTDOWN"
    UWORD
    Time_msec_q1_COMPU
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001EA6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    SyC_tiUnderVltg_mp
    "Duration of the last 5V undervoltage"
    UBYTE
    OneToOne_ms
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    T15_st
    "Terminal 15 status after debouncing"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    T15_stRaw
    "Raw value of Terminal 15 status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008A5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    T15_st_mp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009129

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    T50_st
    "Status of Terminal 50"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000052C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_ctAngDvt_mp
    "increment number for angle correction value TAA_phiAngDvt_mp"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009202

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_ctBufSect_mp
    "sensor wheel section table for tooth angle adaption (only for testing purposes)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00091FF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_ctLrnCycl
    "number of successful learn cycles for the different engine speed ranges"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD0000740

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_facDyn_mp
    "dynamic change of increment periods per sensor wheel revolution"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001EA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_facIpo_mp
    "interpolation factor for correction values in tooth angle adaption"
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001EAE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_nMinCalc_mp
    "minimum engine speed for tooth angle adaption due to algorithm numerics"
    SWORD
    EngN
    1
    100
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001EB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_numActv
    "number of increments to be evaluated in current task activation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_numIncBefGap_mp
    "increment number of increment before first gap of sensor wheel"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009203

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_numIncIR_mp
    "number of increments per angle-synchronous interrupt"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009204

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_phiAngDvt_mp
    "angle correction value for increment TAA_ctAngDvt_mp"
    SBYTE
    AngleCrS
    1
    100
    -2.813
    2.791

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0009205

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_phiIncDvt_mp
    "non-interpolated increment angle deviations (only for testing puposes)"
    SWORD
    AgCrSHiReso
    1
    100
    -5.625000
    5.624828

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001EAA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stAdap
    "partial algorithm of tooth angle adaption to be executed"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000624

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stAdapMode_mp
    "adaption mode for tooth angle adaption (no / in / out of main range)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009200

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stAdapVal
    "settlement status of tooth angle adaption"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CB6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stEnaCond_mp
    "activation condition for tooth angle adaption fulfilled (except overrun)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009206

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stErr_mp
    "configuration errors in tooth angle adaption"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009207

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stFin
    "last executed partial algorithm from tooth angle adaption"
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000626

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stIdxSync_mp
    "tooth angle adaption is synchronized with angle system"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009208

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stIpoMode_mp
    "interpolation mode used for calculation of angle correction values"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009209

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stLrnMode
    "current learning mode of tooth angle adaption"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008A7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stRev2Fin_mp
    "trigger signal: two sensor wheel revolutions finished"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000920A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stRlsOvrRunCo_mp
    "activation condition for tooth angle adaption fulfilled"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000920B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stSpdRngRdHi_mp
    "upper speed range for interpolation of angle correction values"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000920C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stSpdRngRdLo_mp
    "lower speed range for interpolation of angle correction values"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000920D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_stSpdRngWr_mp
    "current speed range for tooth angle adaption"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009201

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_tiIncAvrg_mp
    "average increment period duration of two sensor wheel revolutions"
    SLONG
    TIncPerDurHiReso_us
    1
    100
    -838860.800000
    838860.799609

    
    FORMAT "%13.6"
    
    ECU_ADDRESS 0xD4001AAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TAA_tiInc_mp
    "private increment periods buffer in tooth angle adaption (only for testing purposes)"
    SWORD
    TIncPerDur_us
    1
    100
    -3276.800
    3276.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001EAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_facCorFlt_mp
    "Measurement point for battery correction factor for single flow implementation."
    SWORD
    Fact
    1
    100
    -4.000000
    3.999878

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD4001EB2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_rAct
    "Position of throttle valve"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000052E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_rCnv_mp
    "Measurement point for output of the curve for single flow implementation."
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EB4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_rPs
    "Output to power stage for single flow implementation."
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000530

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_rTVA
    "control duty cycle for Thr valve for single flow implementation."
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000532

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_stAdap
    "Switch status adaption for single flow implementation."
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0000628

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_stOpnLdDia
    "Status of open load diagnosis for bank two in double flow implementation."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008A9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ThrVlv_uRaw_mp
    ""
    SWORD
    Volt
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AFA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    tiOvRMonActive
    ""
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0009992

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Tra_numGear
    ""
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000743

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Tra_numGearDes
    ""
    SBYTE
    OneToOne
    1
    100
    -128.0
    127.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0000744

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbChPmp_frqPmp
    ""
    UWORD
    TRBCHPMP_FRQ
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000062A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbChPmp_st
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbChPmp_stFrqErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008AB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbChPmp_stPs
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbChPmp_stSCGErr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008AD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbChPmp_tiPerRawVal_mp
    ""
    UWORD
    TRBCHPMP_PER
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EB6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbCh_r
    "Input set point value for the actuator"
    SWORD
    Prc
    1
    100
    -400.0000
    399.9878

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000534

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbCh_rPs
    ""
    SWORD
    DtyCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0000536

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbnDsRLam_rLam
    "Lambda value from the sensor at turbine downstream"
    SWORD
    lambda
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD0000538

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbnDsRLam_rLamRec
    "Reciprocal lambda value from the sensor at turbine downstream"
    SWORD
    lambdaRecVal
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000053A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrbnDsRLam_rO2PresComp
    "Pressure compensated O2 ratio from the sensor at turbine downstream"
    SWORD
    O2
    1
    100
    -0.3276800
    0.3276700

    
    FORMAT "%9.7"
    
    ECU_ADDRESS 0xD000053C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TrqInrCtl_r
    ""
    SWORD
    Prc_Fact100
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD000053E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    TS_stMnSwtAC
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_actr_rly_cmd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C8D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_ajs_cut_mon
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CBA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_alco_typ_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CA3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_crsh_lvl1_det
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CBE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_crsh_lvl2_det
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CBF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_crsh_lvl2_det_fmt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_cru_on_off_in
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_actr_rly_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C3D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_actr_rly_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C3E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_actr_rly_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C3F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_cmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_cyc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_el
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_no_norm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BBA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_no_sig_wit_cam
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BBB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BBC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_shp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BBD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_crk_syn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BBE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ecm_err_itl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C54

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ecm_err_no_norm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C55

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ecm_inj_cpt_blk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C56

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ecm_inj_no_norm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C57

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ecm_mon_secu_1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C5A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ecm_mon_secu_2
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C59

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_efi_inj_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C06

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_efi_inj_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C07

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_efi_inj_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C08

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_efi_sldv_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C0C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_efi_sldv_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C0D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_efi_sldv_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C0E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_egr_byp_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BF6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_egr_byp_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BF7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_emtv_hbdg_el
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BFA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_emtv_hbdg_ovh
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BFB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ex_cam_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BBF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ex_cam_crk_cmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ex_cam_l_puls
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ex_cam_syn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ff_actr_blk_open
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C89

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_fprs_actr_blk_clos
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C8B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_fprs_fct_dirt_lkg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C51

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_glow_cmd_fail
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj1_chk_sum
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj1_crt_intv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C77

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj1_shp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj2_chk_sum
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C7B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj2_crt_intv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj2_shp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C7D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj3_chk_sum
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C7F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj3_crt_intv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj3_shp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C81

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj4_chk_sum
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C83

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj4_crt_intv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj4_shp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C85

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_inj_cpt_blk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C79

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_crk_cmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_cyc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_frq_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_l_puls
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_nok
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_no_sig
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BC9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_in_cam_syn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BCA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_it_hbdg_el
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BFE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_it_hbdg_ovh
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BFF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_pws_1_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C47

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_pws_1_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C48

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_pws_2_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C49

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_pws_2_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C4A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_pws_3_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C43

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_pws_3_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C44

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_rail_prs_h_lvl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_amp_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B6A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_amp_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B6B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ex_prs_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B7C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ex_prs_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B7D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_maf_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B66

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_maf_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B67

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_map_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B74

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_map_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B75

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_rup_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_rup_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B91

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_tco_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_tco_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BAD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_tia_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B78

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_tia_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B79

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_heat_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C19

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_heat_ovh
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C1A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_heat_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C1B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_heat_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C1C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_lamb_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B95

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_pump_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_virt_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B97

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_wire_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_ups_wire_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B99

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_wfl_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C69

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sens_wfl_oc_1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sfty_tq_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099EB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sfty_tq_clc_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sfty_tq_fail
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099ED

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_sfty_tq_supl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd1_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C23

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd1_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C24

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd1_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C25

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd2_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C26

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd2_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C27

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd2_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C28

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd3_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C29

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd3_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C2A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_thpl_cmd3_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C2B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_tqi_cor_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C4F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ups_ecu_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ups_ecu_itl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B9B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ups_ecu_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ups_ro2_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B9D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ups_ro2_slow_trs
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B9E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ups_tip_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C1D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_ups_uo2_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B9F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_vb_rly_oc_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_vb_rly_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_vnt_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C02

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_vnt_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C03

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_wpmp_tcr_blk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C35

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_wpmp_tcr_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C36

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_wpmp_tcr_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C37

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_df_wpmp_tcr_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C38

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_actr_rly_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C40

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_actr_rly_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C41

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_actr_rly_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C42

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BCB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_cmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BCC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_cyc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BCD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_el
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BCE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_no_norm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BCF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_no_sig_wit_cam
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_shp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_crk_syn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_efi_inj_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C09

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_efi_inj_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C0A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_efi_inj_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C0B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_efi_sldv_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C0F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_efi_sldv_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C10

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_efi_sldv_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C11

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_egr_byp_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BF8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_egr_byp_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BF9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_emtv_hbdg_el
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BFC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_emtv_hbdg_ovh
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BFD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ex_cam_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ex_cam_crk_cmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ex_cam_l_puls
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ex_cam_syn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_crk_cmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BD9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_cyc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BDA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_frq_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BDB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_l_puls
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BDC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_nok
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BDD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_no_sig
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BDE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_in_cam_syn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BDF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_it_hbdg_el
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C00

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_it_hbdg_ovh
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C01

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_pws_1_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C4B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_pws_1_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C4C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_pws_2_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C4D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_pws_2_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C4E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_pws_3_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C45

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_pws_3_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C46

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_amp_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_amp_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B6D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ex_prs_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B7E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ex_prs_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B7F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_maf_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_maf_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B69

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_map_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B76

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_map_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B77

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_rup_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_rup_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B93

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_tco_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BAE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_tco_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BAF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_tia_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B7A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_tia_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B7B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_heat_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C1E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_heat_ovh
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C1F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_heat_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C20

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_heat_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C21

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_lamb_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_pump_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_virt_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_wire_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_ups_wire_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_sens_wfl_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C67

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd1_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C2C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd1_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C2D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd1_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C2E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd2_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C2F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd2_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C30

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd2_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C31

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd3_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C32

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd3_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C33

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_thpl_cmd3_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C34

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ups_ecu_chr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ups_ecu_itl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ups_ecu_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ups_ro2_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ups_ro2_slow_trs
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BA9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ups_tip_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C22

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_ups_uo2_oor
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BAA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_vb_rly_oc_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_vb_rly_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_vnt_h
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C04

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_vnt_l
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C05

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_wpmp_tcr_blk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C39

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_wpmp_tcr_oc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C3A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_wpmp_tcr_scg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C3B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_ena_wpmp_tcr_scw
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C3C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_brut_abrt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C13

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_brut_abrt_1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_brut_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C14

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_brut_end
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_drpt_abrt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_drpt_abrt_1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_drpt_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_drpt_end
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_ffit_abrt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C16

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_ffit_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C17

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_ffit_end
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008D8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_diag_sta_vvtc_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CA4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_dies_wat_det
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C6A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_ecm_mon_rst_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CA5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_map_run
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B6E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_map_stp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B6F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_pbt_run
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B80

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_pbt_stp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B81

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_rup_run
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B8B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_rup_stp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_stop_srce_dft
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_stop_srce_norm_driv
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_stop_srce_norm_sys
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eng_stop_srce_secu
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_eprm_rdy
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_gear_cge_tqe_sp_lim
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0007CA6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_htg_cmd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C6F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_htg_pwl_on
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_ini_dgtc
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_inj_cmd_max_nok
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C75

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_it_stop_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CA7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_it_stop_ena_act
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CBD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_max_ecu_pws
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_mil_flsh_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CA8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_min_ecu_pws
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C8F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_min_fuel
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C63

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_mux_min_fuel_raw_prev
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C64

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_n_rams_lim_spc_act_1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0007CA9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_n_rams_lim_spc_act_2
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    1.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0007CAA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_ovt_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CAB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_prg_appl_key_stt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C53

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_pwl_dly_pws
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C90

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_pwl_dly_secu
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C91

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_pwl_on
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C92

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_pwst_prs_stt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CAC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_raw_eng_syn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_raw_in_cam_lvl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_raw_run_eng_det
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_raw_sens_bgin_clu_cnt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_raw_sens_ups_rich_valid
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BAB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_rest_pwl_rtn
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C95

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_rly_cmd_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C93

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_rs_dyn_mod_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CAD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_brk_pdl_open
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_ex_prs_frz
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_igk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_map_buf
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_map_buf_not
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B71

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_map_v_flt_rdy
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_map_v_stp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B73

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_buf
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_buf_not
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B83

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_dfth_max
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B84

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_dfth_min
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B85

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_df_frz
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_frz_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B87

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_init_frz
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_pbt_v_flt_rdy
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B89

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_rup_buf
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B8D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_rup_buf_not
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B8E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_rup_v_flt_rdy
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007B8F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sens_wfl_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C6B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_acel_pdl_off
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099BF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_acel_pdl_tq_req_plau
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099C0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_aftr_rst
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099EF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_aftr_rst_ajs_cut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099CA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_aftr_rst_mem
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D777

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_agb_tq_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099A7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_agb_tq_req_plau
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_ajs_cut_mon
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099CB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_brk
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099B3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_brk_pdl_ok
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_brk_pdl_ok_tmp
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099B5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_forc_on
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099B6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_on
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099B7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_resu_acel_decl
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_stt_act
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099B9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_tq_req_plau
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099BC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_tq_req_plau_tmp_1
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099BA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_cru_tq_req_plau_tmp_2
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099BB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_eng_aut
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_inj_no_tq_plau
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_is_i_on
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099CC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_lpos_inj
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_lpos_inj_no_tq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_moni_bch_ok
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_mon_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_msr_tq_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099A9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_msr_tq_req_plau
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_no_inj
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099DE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_no_pinj_main_aftr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_post_inj
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_post_inj_no_tq
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099D5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_rst_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_sens_brk_pdl_open
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099A3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_stop_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_stop_req_aftr_rst
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_stop_req_mem
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D776

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_supl_ext_ctrl_ok
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099DF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_supl_inj_mon_nok_mem
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000D774

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_supl_inj_nok_aftr_rst
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CBB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_tq_mon_nok
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sfty_tq_req_plau
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099CD

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_sl_on_off_in
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BB3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_supl_emul_ecm
    "Immobilizer controller emulation status"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_supl_ext_ctrl_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00099E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_wfl_authorize_conf
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_wf_ac_req_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CAE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_wf_alt_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CAF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_wf_comp_cfa_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CB0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_wf_ptc_cfm
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CB1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_wup_cmd
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C71

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vbx_wup_req
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C72

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    VehV_v
    ""
    SWORD
    Speed_km_h_001_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000054A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_actr_rly_vld
    ""
    UBYTE
    vld_states_2
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_brk_pdl_clos
    ""
    UBYTE
    brk_states
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007CB2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_diag_sta_brut_stt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C15

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_diag_sta_drpt_stt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_diag_sta_ffit_stt
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C18

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_down_egr_cool_temp_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CB3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_ecm_inj_2_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C58

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_ecm_mon_vld
    ""
    UBYTE
    vld_states
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C5B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_ff_actr_vld
    ""
    UBYTE
    vld_states_4
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C8A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_ff_fct_vld
    ""
    UBYTE
    vld_states_5
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C50

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_fprs_actr_vld
    ""
    UBYTE
    vld_states_2
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C8C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_fprs_fct_vld
    ""
    UBYTE
    vld_states_5
    1
    100
    0.00
    5.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C52

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_inj1_vld
    ""
    UBYTE
    vld_states_4
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C7A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_inj2_vld
    ""
    UBYTE
    vld_states_4
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C7E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_inj3_vld
    ""
    UBYTE
    vld_states_4
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C82

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_inj4_vld
    ""
    UBYTE
    vld_states_4
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C86

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_inj_ecu_vld
    ""
    UBYTE
    vld_states
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007CB4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_inj_sys_vld
    ""
    UBYTE
    vld_states_2
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C88

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_inj_vld
    ""
    UBYTE
    vld_states_4
    1
    100
    0.00
    4.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C87

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_min_fuel_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C65

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pcv_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008AF

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_1_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CA1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_2_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CA2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_3_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C96

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_acel_pdl_v1_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C97

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_acel_pdl_v2_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_ac_prs_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C99

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_emtv_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C9A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_ex_prs_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C9B

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_it_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C9C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_map_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C9D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_pftrelprs_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C9E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_rail_prs_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007C9F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_pws_sens_ups_vld
    ""
    UBYTE
    vld_states_3
    1
    100
    0.00
    3.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007CA0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_sens_fuel_temp_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C66

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_sens_rail_prs_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C6D

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_sfty_tq_mon_vld
    ""
    UBYTE
    vld_states
    1
    100
    0.00
    1.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0007CBC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_vcv_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008B0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vsx_wpmp_egr_vld
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    2.000

    
    FORMAT "%5.3"
    
    ECU_ADDRESS 0xD0007CB5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vtx_supl_chlg_val
    "Immobilizer controller noise"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0007BEA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vtx_supl_ini_noi
    "Immobilizer controller noise"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD0007BF0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_acel_pdl_sens_v1
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005556

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_acel_pdl_sens_v2
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005558

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_crsh_det
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CCA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_crsh_mem
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CCB

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_cru_sl_whl_cmd_in
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000555A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_diag_in_vvtc_n_sub_val
    ""
    UWORD
    Rpm025_RSA
    1
    100
    0.00
    16383.75

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000559E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_down_egr_cool_temp
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00055A0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_egb_n_lim
    ""
    UWORD
    Rpm025_RSA
    1
    100
    0.00
    16383.75

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00055A2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_egr_tqi_fisa_cor
    ""
    SWORD
    TRQ_32_RSA
    1
    100
    -1024.000
    1023.969

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005576

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_emtv_last_ana_psn
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054E0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_emtv_pwm
    ""
    SWORD
    Prc001_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005566

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_emtv_pwm_1
    ""
    SWORD
    Prc001_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005568

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_emtv_sens_pws
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054E2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_eng_run_ena_airb
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_eng_run_ena_ccu
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_eng_run_ena_rgb
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_eng_run_ena_ssg
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CC5

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_fuel_temp
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005582

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_gear_cge_fmt
    ""
    UWORD
    R01_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00055A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_htg_diag
    ""
    UBYTE
    Prc_0392_RSA
    1
    100
    0.00
    100.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C12

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_htg_pwm_prct
    ""
    UBYTE
    Prc_0392_RSA
    1
    100
    0.00
    100.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007C73

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_inj_dist
    ""
    ULONG
    LengthKm1
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F94

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_inj_dist_ini
    ""
    ULONG
    LengthKm1
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F98

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_inj_dist_l_res
    ""
    UWORD
    km_16_RSA
    1
    100
    0.00
    1048560.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD0005590

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_is_tqe_sp_old
    ""
    SWORD
    Mo_trq_nm_q0p320
    1
    100
    -1024.000
    1023.969

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00099CE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_it_last_ana_psn
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005502

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_it_pwm
    ""
    SWORD
    Prc001_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000556A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_it_pwm_1
    ""
    SWORD
    Prc001_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000556C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_it_sens_pws
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005504

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_mat
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00055A6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_min_fuel_dly
    ""
    UWORD
    sec_001_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005586

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_min_fuel_dly_prev
    ""
    UWORD
    sec_001_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005588

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_n_mv_pbtxxsr_mp
    ""
    UWORD
    Rpm025_RSA
    1
    100
    0.00
    16383.75

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001AFC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_ovt_smk_appl
    ""
    UWORD
    InjMass_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD00055A8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_ovt_tq_appl
    ""
    UWORD
    Trq132_no_Offs_RSA
    1
    100
    0.00
    2047.969

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00055AA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_pft_vh_dist_max_rgn_err
    ""
    UWORD
    km_16_RSA
    1
    100
    0.00
    1048560.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD00055AC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_prg_appl_key
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000062C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_pump_tql
    ""
    UWORD
    TRQ_32_RSA
    1
    100
    0.00
    2047.969

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005584

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_pwl_dly
    ""
    UWORD
    Time_sec_1
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005592

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_pwl_dly_pws
    ""
    UWORD
    Time_sec_1
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005594

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_pws_1
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005598

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_pws_2
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000559A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_pws_3
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005596

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_rail_prs
    ""
    UWORD
    PresBar_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000558C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_ac_prs
    ""
    UWORD
    V01_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005562

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_eng_angl
    ""
    UWORD
    AngleCrSRSA
    1
    100
    0.00
    1310.700

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000555C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_in_cam_toth_per
    ""
    UWORD
    Per_Dur
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000555E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_n
    ""
    UWORD
    Rpm025_RSA
    1
    100
    0.00
    16383.75

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005560

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_pws_1
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005570

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_pws_2
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005572

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_pws_3
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000556E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_amp
    ""
    UWORD
    Pres_hPa
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054E6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_doc1_utp
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005536

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_ex_prs
    ""
    UWORD
    hPa_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005522

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_maf
    ""
    UWORD
    AirMass_mgStroke01_RSA
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00054E4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_map
    ""
    UWORD
    hPa_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054EA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_pft_rel_up_prs
    ""
    SWORD
    Pres_hPa
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005524

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_pft_utp
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000553A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_spg
    ""
    UWORD
    hPa_1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054F8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_tbt
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005544

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_tco
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005552

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_tia
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00054FC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_ups_lamb
    ""
    SWORD
    lambdarecval_RSA
    1
    100
    -32.76800
    32.76700

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000554C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_ups_rich
    ""
    UWORD
    lambdarecval_RSA
    1
    100
    0.00
    65.53500

    
    FORMAT "%8.5"
    
    ECU_ADDRESS 0xD000554E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_sens_up_it_temp
    ""
    UWORD
    TempC_RSA
    1
    100
    -40.00000
    6513.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00054FE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_tdc_ctr
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007BE3

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_tdc_per
    ""
    ULONG
    TDC_Period
    1
    100
    0.00
    13743.8953440

    
    FORMAT "%13.7"
    
    ECU_ADDRESS 0xD0002F70

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_raw_vb
    ""
    UWORD
    V01_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005564

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_rich_prop_up
    ""
    UWORD
    bicbiueg_dgdgtdat_rich_prop_up
    1
    100
    0.00
    1.998811

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD000554A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_rps_rail_prs_dif
    ""
    SWORD
    PresBar_RSA
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000558E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_run_eng_ena
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0007CCC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_amp_v
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054E8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_doc1_utp_v
    ""
    UWORD
    V02_RSA
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005534

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_doc1_utp_v_mv
    ""
    UWORD
    V02_RSA
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005538

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_fuel_temp_v
    ""
    UWORD
    V01_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005540

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054FA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_avr
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054EC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_ctr0
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054EE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_ctr1
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054F0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_flt
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054F2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_mv
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054F4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_stp
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00054F6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_sum0
    ""
    ULONG
    V1_RSA
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F58

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_map_v_sum1
    ""
    ULONG
    V1_RSA
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F5C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005506

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_apl
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005508

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_avr
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000550A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_ctr0
    ""
    UWORD
    WU_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000550C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_ctr1
    ""
    UWORD
    WU_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000550E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_flt
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005510

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_max
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005512

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_max0
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005514

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_max1
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005516

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_min
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005518

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_min0
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000551A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_min1
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000551C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_mv
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000551E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_stp
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005520

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_sum0
    ""
    ULONG
    V1_RSA
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F60

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pbt_v_sum1
    ""
    ULONG
    V1_RSA
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F64

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pft_rel_up_prs_v
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005532

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pft_utp_v
    ""
    UWORD
    V02_RSA
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000553E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_pft_utp_v_mv
    ""
    UWORD
    V02_RSA
    1
    100
    0.00
    6553.500

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD000553C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_prop_down_v
    ""
    UWORD
    V000122_RSA
    1
    100
    0.00
    5.000000

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD00055AE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_prop_up_v
    ""
    UWORD
    V000122_RSA
    1
    100
    0.00
    7.994998

    
    FORMAT "%8.6"
    
    ECU_ADDRESS 0xD0005550

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rail_prs
    ""
    UWORD
    PresBar_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005542

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_avr
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005526

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_ctr0
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005528

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_ctr1
    ""
    UWORD
    OneToOne
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000552A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_flt
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000552C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_mv
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD000552E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_stp
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005530

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_sum0
    ""
    ULONG
    V1_RSA
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F68

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_rup_v_sum1
    ""
    ULONG
    V1_RSA
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD0002F6C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_tbt_v
    ""
    SWORD
    Volt_RSA
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005548

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_tbt_v_mv
    ""
    SWORD
    Volt_RSA
    1
    100
    -6553.600
    6553.400

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD0005546

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_tco_v
    ""
    UWORD
    V01_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005554

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sens_tia_v
    ""
    UWORD
    V1_RSA
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD0005500

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_acel_pdl_sens_v1
    ""
    UWORD
    Mo_u_mV_q1p0
    1
    100
    0.00
    65535.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD00099A4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_cru_brk_t_1
    ""
    UBYTE
    Mo_ti_s_q0p04
    1
    100
    0.00
    10.20

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0xD0007CB7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_cru_brk_t_2
    ""
    UBYTE
    Mo_ti_s_q0p04
    1
    100
    0.00
    10.20

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0xD0007CB8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_cru_brk_t_long
    ""
    UBYTE
    Mo_ti_s_q0p04
    1
    100
    0.00
    10.20

    
    FORMAT "%5.2"
    
    ECU_ADDRESS 0xD0007CB9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_mux_agb_tqe_sp
    ""
    UWORD
    Mo_trq_nm_q0p32
    1
    100
    -400.0000
    1647.969

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00099C2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_mux_msr_tqe_sp
    ""
    UWORD
    Mo_trq_nm_q0p32
    1
    100
    -400.0000
    1647.969

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD00099C4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_n
    ""
    UBYTE
    Mo_n_rpm_q32p0
    1
    100
    0.00
    8160.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD00099C6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_sfty_n_old
    ""
    UBYTE
    Mo_n_rpm_q32p0
    1
    100
    0.00
    8160.

    
    FORMAT "%5.0"
    
    ECU_ADDRESS 0xD00099D0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    vxx_time_counter
    ""
    UWORD
    sec_001_RSA
    1
    100
    0.00
    655.3500

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD000558A

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_tqi_cor_fma
    ""
    UWORD
    FMA_qCor_001_RSA
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD0005574

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    Vxx_tqi_raw_pbtxxsr_mp
    ""
    UWORD
    Trq132_no_Offs_RSA
    1
    100
    0.00
    2047.969

    
    FORMAT "%8.3"
    
    ECU_ADDRESS 0xD4001AFE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    WaHtEl_st
    ""
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00008B4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    WaHtEl_stPs
    "The electrical water heater actuator status."
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    ARRAY_SIZE 3
    ECU_ADDRESS 0xD00008B1

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_ctPCLAccumulated_mp
    "Number of measurement values accumulated for ZFC_qPCL_mp calculation"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009213

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_dpRailLim_mp
    "Current maximum rail pressure deviation for ZFC"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001EB8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_dpRail_mp
    "Rail pressure deviation at the rail pressure calibration point"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001EBA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_idxFBCElm_mp
    "Index for FBC parameter maps for operation point"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000920F

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_numCylInj_mp
    "Current cylinder number for the zero fuel calibration injection"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009215

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_phiInj_mp
    "Start of energizing of the injection for zero quantity calibration"
    SWORD
    AngleCrS
    1
    100
    -720.0000
    719.9780

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001ECA

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_pRailSetPoint_mp
    "ZFC rail pressure setpoint requested"
    SWORD
    Pres_Rail
    1
    100
    -3276800.
    3276700.

    
    FORMAT "%8.0"
    
    ECU_ADDRESS 0xD4001EBC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_qPCLAccumulated
    "Accumulated quantity of pilot calibration with lambda (PCL)"
    SLONG
    InjMassCyc
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD0004358

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_qPCLThres_mp
    "Quantity threshold of pilot calibration with lambda (PCL)"
    SWORD
    InjMassCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EC2

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_qPCL_mp
    "Average quantity of pilot calibration with lambda (PCL)"
    SWORD
    InjMassCyc
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EC4

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_SigThres_mp
    "Current signal threshold for ZFC"
    SWORD
    OneToOne
    1
    100
    -32768.00
    32767.00

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001EC0

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_Sig_mp
    "Measured value of the calibration"
    SLONG
    OneToOne
    1
    100
    -2147483648.00
    2147483647.00

    
    FORMAT "%13.2"
    ARRAY_SIZE 6
    ECU_ADDRESS 0xD00098DC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_stClbCond
    "States of ZFC conditions"
    ULONG
    OneToOne
    1
    100
    0.00
    4294967295.00

    
    FORMAT "%13.2"
    
    ECU_ADDRESS 0xD000440C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_stCldCham
    "State of the combustion chamber for ZFC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008B7

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_stCmbCham_mp
    "State of the detection of a cold combustion chamber for ZFC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD000920E

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_stDem_mp
    "Zero fuel calibration requests"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD0009210

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_stEvalPCL_mp
    "State of evaluation of the lambda sensor for PCL"
    UBYTE
    ZFC_EvalEngSpd_Rslt
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0009214

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_stEvalSig_mp
    "Status of the evaluation of the ZFC signal"
    UBYTE
    ZFC_EvalEngSpd_Rslt
    1
    100
    0.00
    2.00000000000

    
    FORMAT "%13.11"
    
    ECU_ADDRESS 0xD0009212

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_stInj_mp
    "Status of the ZFC injection programming"
    UBYTE
    ZFC_Inj_State
    1
    100
    0.00
    64.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD0009216

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_st_mp
    "Status of ZFC"
    UBYTE
    ZFC_State
    1
    100
    1.00000000000
    16.0000000000

    
    FORMAT "%13.10"
    
    ECU_ADDRESS 0xD0009211

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_swtClbActv
    "SW switch for activating ZFC"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008B8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_swtPCLActv
    "Switchvalue for PCL (0=PCL not active; 1=PCL active)"
    UBYTE
    OneToOne
    1
    100
    0.00
    255.0

    
    FORMAT "%5.1"
    
    ECU_ADDRESS 0xD00008B9

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_tiET_mp
    "Energizing time for the zero fuel calibration injection"
    SWORD
    InjTime_us
    1
    100
    -13107.20
    13106.80

    
    FORMAT "%8.2"
    
    ECU_ADDRESS 0xD4001ECC

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_volPCLAccumulated
    "Accumulated volume of pilot calibration with lambda (PCL)"
    SLONG
    InjQntInj
    1
    100
    -21474836.4800
    21474836.4700

    
    FORMAT "%13.4"
    
    ECU_ADDRESS 0xD000435C

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_volPCLThres_mp
    "Volume threshold for pilot calibration with lambda (PCL)"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EC6

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_volPCL_mp
    "Average volume of pilot calibration with lambda (PCL)"
    SWORD
    InjQntInj
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EC8

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin MEASUREMENT

    ZFC_vStopClb_mp
    "Minimum vehicle speed of the current energizing time calibration"
    SWORD
    Vel
    1
    100
    -327.6800
    327.6700

    
    FORMAT "%8.4"
    
    ECU_ADDRESS 0xD4001EBE

        /* AsapMFm - KWP2000 */

/end MEASUREMENT

/begin FUNCTION

    ACCmpr_DD
    ""

    /begin DEF_CHARACTERISTIC
      AirC_DigOutCmpr.tiBtwTstSCB_C AirC_DigOutCmpr.tiBtwTstOT_C AirC_DigOutCmpr.numTstMax_C AirC_DigOutRedTrq.tiBtwTstSCB_C AirC_DigOutRedTrq.tiBtwTstOT_C AirC_DigOutRedTrq.numTstMax_C
      AirC_stCmprPsDiaDisbl_C AirC_stCmprPsDisbl_C AirC_stCmprTyp_CW AirC_stRedTrqPsDiaDisbl_C AirC_stRedTrqPsDisbl_C AirC_trqCmprMax_C
      AirC_trqCmprMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AC_trqMaxAC DevLib_stPwrStgEnaCond
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      AirC_stPsCmpr AirC_stPsCmprRedTrq AirC_trqCmprMax
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      AirC_stPsCmprRedTrq_mp AirC_stPsCmpr_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    AccPrAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    AccPr_Std
    ""


/end FUNCTION

/begin FUNCTION

    AdcHal
    ""

    /begin DEF_CHARACTERISTIC
      Adc_idxAirCClntIA_C Adc_idxCEngDsTIA_C Adc_idxCrCPanIA_C Adc_idxdummyIABPS_C Adc_idxdummyIAEGRCWTS_C Adc_idxdummyIAFLPS_C
      Adc_idxdummyTCACDsIA_C Adc_idxdummy_C Adc_idxEGRVlvIA_C Adc_idxFuelTIA_C Adc_idxOilTIA_C Adc_idxPCACDsIA_C
      Adc_idxPPFltUsIA_C Adc_idxPTrbnUsIA_C Adc_idxTAFSIA_C Adc_idxTEGRClrDsIA_C Adc_idxThrVlvIA_C Adc_idxTOxiCatDsIA_C
      Adc_idxTOxiCatUsIA_C Adc_idxTPFltDsIA_C Adc_idxTPFltUsIA_C Adc_idxTrbChIA_C Adc_idxTTrbnUsIA_C Adc_idxVDD5A_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    AdcI
    ""


/end FUNCTION

/begin FUNCTION

    AddHtr_DD
    ""

    /begin DEF_CHARACTERISTIC
      WaHtEl_DigOut.tiBtwTstSCB_C WaHtEl_DigOut.tiBtwTstOT_C WaHtEl_DigOut.numTstMax_C WaHtEl_stPsDiaDisbl_CA WaHtEl_stPsDisbl_CA
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_facCor DevLib_stPwrStgEnaCond
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      WaHtEl_st WaHtEl_stPs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    AFS_DD
    ""

    /begin DEF_CHARACTERISTIC
      AFS_dmTransf_CUR AFS_facPerCor_C AFS_nAvrgThrHiSRCLoB2_C AFS_nAvrgThrHiSRCLo_C AFS_nAvrgThrLoSRCLo_C AFS_qAirmThrSRCHiActv_CUR
      AFS_swtOffTstSel_C AFS_swtOscSel_C AFS_tiCorSRCHi_C AFS_tiCorSRCLo_C AFS_tiDlyActvSRCHiAirm_C AFS_tiLPFiltPT1_C
      AFS_tiOffsDrftTstDly_C AFS_tiOffsDrftTstLim_C AFS_tiPerHFM6_C AFS_tiRawSRCHi_C AFS_tiRawSRCLo_C AFS_tiThrHiPlOffsDrft_C
      AFS_tiThrLoPlOffsDrft_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Air_tiRawTAFS CoEng_st EpmCrS_numSeg EpmCrS_tiSeg Epm_nEng InjCtl_qRaw
      T15_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      AFS_dmSens AFS_stOffsTst AFS_swtActvAftRun AFS_tiRaw
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      AFS_qAirmThrSRCHiActv_mp AFS_stPlsOffsDrftTstActv_mp AFS_stSRCHiTstRls_mp AFS_stSRCLoTstRls_mp AFS_tiCor_mp AFS_tiRawAvrg_mp
      AFS_tiTransfCrvIn_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Amd29BDD160
    ""


/end FUNCTION

/begin FUNCTION

    Amd29BDD320
    ""


/end FUNCTION

/begin FUNCTION

    ASMod_AxisPoints
    ""


/end FUNCTION

/begin FUNCTION

    ASMod_Co
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_nThresDwn_C ASMod_numEnvPres_C ASMod_numTrbnDs_C ASMod_numTrbn_C ASMod_swtCalcQntInjCmb_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AFS_dm Epm_nEng InjSys_qInrCmb
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ASMod_dmAFSCor ASMod_dmEGFld ASMod_nEng ASMod_pEGFld ASMod_qInjCmb ASMod_stInit
      ASMod_tEGFld ASMod_tWallFld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ASMod_Eng
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_dmAir_MAP ASMod_dmEGMinVal_C ASMod_dmExhMnfUsDfl_C ASMod_facAirMass_CUR ASMod_facCorrCldEng_CUR ASMod_facIAT_CUR
      ASMod_facStrtDlv_CUR ASMod_numBnk_C ASMod_numEngTemp_C ASMod_numExhMnf_C ASMod_numIATS_C ASMod_phiStrtDlv_MAP
      ASMod_tEngStat_C ASMod_tExhMnfUsDfl_C ASMod_tIAT_MAP ASMod_tMnfStat_MAP
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirSys_tFld ASMod_dmAFSCor ASMod_nEng ASMod_qInjCmb EngDa_tFld Epm_numCyl
      InjCrv_phiMI1Des
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ASMod_dmExhMnfDs ASMod_tExhMnfDs ASMod_tExhMnfDsRaw
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ASMod_dmEGMinVal_mp ASMod_facAirMass_mp ASMod_facStrtDlv_mp ASMod_phiDiffStrt_mp ASMod_rAirPerTime_mp ASMod_tCorrIAT_mp
      ASMod_tCorrMnf_mp ASMod_tDiffCldEng_mp ASMod_tDiffIAT_mp ASMod_tEng_mp ASMod_tExhMnfStat_mp ASMod_tIATS_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ASMod_GlbDef
    ""


/end FUNCTION

/begin FUNCTION

    ASMod_Lib
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_cndHtOfs_C ASMod_facCndHtSlp_C ASMod_facVscDynSlp_C ASMod_facVscKinSlp_C ASMod_nuPipeEnv_CUR ASMod_nuPipe_CUR
      ASMod_vscDynOfs_C ASMod_vscKinOfs_C
    /end DEF_CHARACTERISTIC
    /begin REF_CHARACTERISTIC
      ASMod_cpGs_C
    /end REF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      ASMod_rePipe1_mp ASMod_rePipeEnv1_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ASMod_PresPipe
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_facGeoEGPipe_CA ASMod_facPowEGPipe_CUR ASMod_facRhoEtaEGPipe_MAP ASMod_pDiffPipe0_MAP ASMod_swtPresCalc_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ASMod_dmEGFld ASMod_pEGFld ASMod_tEGFld Epm_nEng Exh_pPFltUs InjCtl_qSetUnBal
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ASMod_dVolEGPipe1_mp ASMod_dVolEGPipe_mp ASMod_facPowEGPipe_mp ASMod_facRhoEtaEGPipe_mp ASMod_pDiffEGPipe_mp ASMod_pEGPresPipe_mp
      ASMod_qPresPipe_mp ASMod_tEGPresPipe_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ASMod_TempPipe
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_cpPipe_CA ASMod_htcFreeCnvtPipe_CA ASMod_lDiamPipe_CA ASMod_lLngthPipe_CA ASMod_rArPipe_CA ASMod_TempPipeI.Ki_C
      ASMod_TempPipeI.KiPos_C ASMod_TempPipeI.KiNeg_C ASMod_TempPipeI.WinPos_C ASMod_TempPipeI.WinNeg_C ASMod_tPipeDfl_C ASMod_tWallPipeDfl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ASMod_dmEGFld ASMod_stInit ASMod_stTempModIni ASMod_tEGFld ASMod_tPipeStrt ASMod_tWallFld
      EnvT_t VehV_v
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ASMod_arPipe_mp ASMod_cndHtAir_mp ASMod_cndHtEG_mp ASMod_dtPipe_mp ASMod_dwEGPipe_mp ASMod_dwPipeEnv_mp
      ASMod_dwPipeIn_mp ASMod_dwPipeOut_mp ASMod_dwPipe_mp ASMod_htcArEGPipe_mp ASMod_htcArPipeEnv_mp ASMod_htcEGPipe_mp
      ASMod_htcPipeEnv_mp ASMod_nuPipeEnv_mp ASMod_nuPipe_mp ASMod_rePipeEnv_mp ASMod_rePipe_mp ASMod_tDiffEGPipe_mp
      ASMod_tDiffPipeEnv_mp ASMod_tEGPipeDs_mp ASMod_tMidEGPipe_mp ASMod_tMidPipeEnv_mp ASMod_tWallPipe_mp ASMod_vscDynPipe_mp
      ASMod_vscKinPipe_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ASMod_TempPipeSlw
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_cpPipeSlw_CA ASMod_htcFreeCnvtPipeSlw_CA ASMod_lDiamPipeSlw_CA ASMod_lLngthPipeSlw_CA ASMod_rArPipeSlw_CA ASMod_TempPipeSlwI.Ki_C
      ASMod_TempPipeSlwI.KiPos_C ASMod_TempPipeSlwI.KiNeg_C ASMod_TempPipeSlwI.WinPos_C ASMod_TempPipeSlwI.WinNeg_C ASMod_tPipeDflSlw_C ASMod_tWallPipeDflSlw_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      ASMod_dmEGFld ASMod_stInit ASMod_stTempModIni ASMod_tEGFld ASMod_tPipeStrt ASMod_tWallFld
      EnvT_t VehV_v
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      ASMod_arPipeSlw_mp ASMod_cndHtAirSlw_mp ASMod_cndHtEGSlw_mp ASMod_dtPipeSlw_mp ASMod_dwEGPipeSlw_mp ASMod_dwPipeEnvSlw_mp
      ASMod_dwPipeInSlw_mp ASMod_dwPipeOutSlw_mp ASMod_dwPipeSlw_mp ASMod_htcArEGPipeSlw_mp ASMod_htcArPipeEnvSlw_mp ASMod_htcEGPipeSlw_mp
      ASMod_htcPipeEnvSlw_mp ASMod_nuPipeEnvSlw_mp ASMod_nuPipeSlw_mp ASMod_rePipeEnvSlw_mp ASMod_rePipeSlw_mp ASMod_tDiffEGPipeSlw_mp
      ASMod_tDiffPipeEnvSlw_mp ASMod_tEGPipeSlwDs_mp ASMod_tMidEGPipeSlw_mp ASMod_tMidPipeEnvSlw_mp ASMod_tWallPipeSlw_mp ASMod_vscDynPipeSlw_mp
      ASMod_vscKinPipeSlw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ASMod_TempStrtCalc
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_facTempClg_CUR ASMod_facTimeClg_CUR ASMod_numAirTempStrt_C ASMod_numEngTempStrt_C ASMod_tiCalcIniTempOn_C ASMod_tiClgOfs_C
      ASMod_tiHaValClnt_C ASMod_tiHaValPipe_CA ASMod_tInit_C ASMod_tStrtDfl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirSys_tFld ASMod_stInit ASMod_tWallFld CoEng_st EngDa_tFld
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ASMod_stTempModIni ASMod_tiClg ASMod_tPipeStrt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ASMod_rTempClgCrvIn_mp ASMod_rTempClnt_mp ASMod_rTimePipe_mp ASMod_tAirStrt_mp ASMod_tEngStrt_mp ASMod_tExsClnt_mp
      ASMod_tiClgRef_mp ASMod_tShOffExsClnt_mp ASMod_tShOffPipe_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ASMod_TempTrbCh
    ""

    /begin DEF_CHARACTERISTIC
      ASMod_cpGs_C ASMod_etaTrbCh_MAP ASMod_numAirTempTrbn_C ASMod_rTempAdbt_CUR ASMod_tiTrbnPT1_C ASMod_tTrbnDsRawDfl_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AirSys_tFld Air_pUnFltPCACDs ASMod_dmAFSCor ASMod_dmEGFld ASMod_dmExhMnfDs ASMod_stInit
      ASMod_tEGFld ASMod_tExhMnfDs CoEng_st EnvP_p
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ASMod_tTrbnDs ASMod_tTrbnDsRaw
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ASMod_etaTrbCh_mp ASMod_facTrbnPT1_mp ASMod_pCACDs_mp ASMod_pwrCmpr_mp ASMod_rPresCmpr_mp ASMod_rTempAdbt_mp
      ASMod_tAirTrbn_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ATSAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    ATS_Std
    ""

    /begin DEF_CHARACTERISTIC
      AirCCmprRedTrq_ATS.LimitTypeMsk_C AirCCmprRedTrq_ATS.CnvNorm_C AirCCmprRedTrq_ATS.LowLim_C AirCCmprRedTrq_ATS.UpLim_C AirCCmprRedTrq_ATS.CnvFac_C AirCCmprRedTrq_ATS.CnvOfs_C
      AirCCmprRedTrq_ATS.DfltVal_C AirCCmpr_ATS.LimitTypeMsk_C AirCCmpr_ATS.CnvNorm_C AirCCmpr_ATS.LowLim_C AirCCmpr_ATS.UpLim_C AirCCmpr_ATS.CnvFac_C
      AirCCmpr_ATS.CnvOfs_C AirCCmpr_ATS.DfltVal_C ATS_Standby_Disabled_C ATS_tiTstDemHeal_C ATS_tiTstDemMax_C ATS_TmrBehaviour_C
      ATS_TstDemMaxEngN_C ATS_TstDemMaxVSSCDV_C ECBVlv_ATS.LimitTypeMsk_C ECBVlv_ATS.CnvNorm_C ECBVlv_ATS.LowLim_C ECBVlv_ATS.UpLim_C
      ECBVlv_ATS.CnvFac_C ECBVlv_ATS.CnvOfs_C ECBVlv_ATS.DfltVal_C EGRVlv_ATS.LimitTypeMsk_C EGRVlv_ATS.CnvNorm_C EGRVlv_ATS.LowLim_C
      EGRVlv_ATS.UpLim_C EGRVlv_ATS.CnvFac_C EGRVlv_ATS.CnvOfs_C EGRVlv_ATS.DfltVal_C ETClb_stRCClbActv_ATS.LimitTypeMsk_C ETClb_stRCClbActv_ATS.CnvNorm_C
      ETClb_stRCClbActv_ATS.LowLim_C ETClb_stRCClbActv_ATS.UpLim_C ETClb_stRCClbActv_ATS.CnvFac_C ETClb_stRCClbActv_ATS.CnvOfs_C ETClb_stRCClbActv_ATS.DfltVal_C GlwPlgLVS_ATS.LimitTypeMsk_C
      GlwPlgLVS_ATS.CnvNorm_C GlwPlgLVS_ATS.LowLim_C GlwPlgLVS_ATS.UpLim_C GlwPlgLVS_ATS.CnvFac_C GlwPlgLVS_ATS.CnvOfs_C GlwPlgLVS_ATS.DfltVal_C
      GlwPlgSVS_ATS.LimitTypeMsk_C GlwPlgSVS_ATS.CnvNorm_C GlwPlgSVS_ATS.LowLim_C GlwPlgSVS_ATS.UpLim_C GlwPlgSVS_ATS.CnvFac_C GlwPlgSVS_ATS.CnvOfs_C
      GlwPlgSVS_ATS.DfltVal_C LSU0_ATS.LimitTypeMsk_C LSU0_ATS.CnvNorm_C LSU0_ATS.LowLim_C LSU0_ATS.UpLim_C LSU0_ATS.CnvFac_C
      LSU0_ATS.CnvOfs_C LSU0_ATS.DfltVal_C SigTst_stShOff_ATS.LimitTypeMsk_C SigTst_stShOff_ATS.CnvNorm_C SigTst_stShOff_ATS.LowLim_C SigTst_stShOff_ATS.UpLim_C
      SigTst_stShOff_ATS.CnvFac_C SigTst_stShOff_ATS.CnvOfs_C SigTst_stShOff_ATS.DfltVal_C T15_I_D_ATS_ATS.LimitTypeMsk_C T15_I_D_ATS_ATS.CnvNorm_C T15_I_D_ATS_ATS.LowLim_C
      T15_I_D_ATS_ATS.UpLim_C T15_I_D_ATS_ATS.CnvFac_C T15_I_D_ATS_ATS.CnvOfs_C T15_I_D_ATS_ATS.DfltVal_C ThrVlv_ATS.LimitTypeMsk_C ThrVlv_ATS.CnvNorm_C
      ThrVlv_ATS.LowLim_C ThrVlv_ATS.UpLim_C ThrVlv_ATS.CnvFac_C ThrVlv_ATS.CnvOfs_C ThrVlv_ATS.DfltVal_C TrbCh_ATS.LimitTypeMsk_C
      TrbCh_ATS.CnvNorm_C TrbCh_ATS.LowLim_C TrbCh_ATS.UpLim_C TrbCh_ATS.CnvFac_C TrbCh_ATS.CnvOfs_C TrbCh_ATS.DfltVal_C
      WaHtEl0_ATS.LimitTypeMsk_C WaHtEl0_ATS.CnvNorm_C WaHtEl0_ATS.LowLim_C WaHtEl0_ATS.UpLim_C WaHtEl0_ATS.CnvFac_C WaHtEl0_ATS.CnvOfs_C
      WaHtEl0_ATS.DfltVal_C WaHtEl1_ATS.LimitTypeMsk_C WaHtEl1_ATS.CnvNorm_C WaHtEl1_ATS.LowLim_C WaHtEl1_ATS.UpLim_C WaHtEl1_ATS.CnvFac_C
      WaHtEl1_ATS.CnvOfs_C WaHtEl1_ATS.DfltVal_C WaHtEl2_ATS.LimitTypeMsk_C WaHtEl2_ATS.CnvNorm_C WaHtEl2_ATS.LowLim_C WaHtEl2_ATS.UpLim_C
      WaHtEl2_ATS.CnvFac_C WaHtEl2_ATS.CnvOfs_C WaHtEl2_ATS.DfltVal_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEngLRes VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      ATS_stMonTimeLimit
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ATS_IntvVal_mp ATS_TstStatus_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Avs
    ""


/end FUNCTION

/begin FUNCTION

    BasSvrAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    BasUtil_Std
    ""


/end FUNCTION

/begin FUNCTION

    BiAsiEgr_Evpossr
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_emtv_sens_pws_nok Cxx_emtv_sens_pws_over Cxx_emtv_sens_pws_under
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vxx_emtv_last_ana_psn Vxx_emtv_sens_pws
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EGRVlv_uRaw_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiEgr_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_emtv_last_ana_psn Vxx_emtv_sens_pws
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiiaf_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_maf_h Vbx_df_sens_maf_l Vbx_diag_ena_sens_maf_h Vbx_diag_ena_sens_maf_l Vxx_raw_sens_maf
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiIaf_Mafxxsr
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_diag_ena_sens_maf_vb_h Cxx_diag_ena_sens_maf_vb_l
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      AFS_dmSens
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_df_sens_maf_h Vbx_df_sens_maf_l Vbx_diag_ena_sens_maf_h Vbx_diag_ena_sens_maf_l Vxx_raw_sens_maf
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiIaf_Schedul
    ""

    /begin SUB_FUNCTION
      BiAsiIaf_Mafxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiIap_Ampxxsr
    ""

    /begin DEF_CHARACTERISTIC
      EnvP_pTransf_CUR EnvP_SRC.uMin_C EnvP_SRC.uMax_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_df_sens_amp_h Vbx_df_sens_amp_l Vbx_diag_ena_sens_amp_h Vbx_diag_ena_sens_amp_l Vxx_raw_sens_amp Vxx_sens_amp_v
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      EnvP_pSens_mp EnvP_uRaw_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiAsiIap_Ampxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiIap_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_amp_h Vbx_df_sens_amp_l Vbx_df_sens_map_h Vbx_df_sens_map_l Vbx_diag_ena_sens_amp_h Vbx_diag_ena_sens_amp_l
      Vbx_diag_ena_sens_map_h Vbx_diag_ena_sens_map_l Vbx_eng_map_run Vbx_eng_map_stp Vbx_sens_map_buf Vbx_sens_map_buf_not
      Vbx_sens_map_v_flt_rdy Vbx_sens_map_v_stp Vxx_raw_sens_amp Vxx_raw_sens_map Vxx_raw_sens_spg Vxx_sens_amp_v
      Vxx_sens_map_v Vxx_sens_map_v_avr Vxx_sens_map_v_ctr0 Vxx_sens_map_v_ctr1 Vxx_sens_map_v_flt Vxx_sens_map_v_mv
      Vxx_sens_map_v_stp Vxx_sens_map_v_sum0 Vxx_sens_map_v_sum1
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiIap_Mapxxsr
    ""

    /begin DEF_CHARACTERISTIC
      Air_SRCPCACDs.uMin_C Air_SRCPCACDs.uMax_C Ctb_x_map_v_map Ctp_map_v_map Cxx_map_raw_flt Cxx_map_raw_init
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Air_uRawPCACD Vbx_df_sens_map_h Vbx_df_sens_map_l Vbx_diag_ena_sens_map_h Vbx_diag_ena_sens_map_l Vxx_raw_sens_spg
      Vxx_sens_map_v
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_eng_map_run Vbx_eng_map_stp Vbx_sens_map_buf Vbx_sens_map_buf_not Vbx_sens_map_v_flt_rdy Vbx_sens_map_v_stp
      Vxx_raw_sens_map Vxx_sens_map_v_avr Vxx_sens_map_v_ctr0 Vxx_sens_map_v_ctr1 Vxx_sens_map_v_flt Vxx_sens_map_v_mv
      Vxx_sens_map_v_stp Vxx_sens_map_v_sum0 Vxx_sens_map_v_sum1
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiAsiIap_Mapxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiIap_Schedul
    ""

    /begin SUB_FUNCTION
      BiAsiIap_Ampxxsr BiAsiIap_Mapxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiIat_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_tia_h Vbx_df_sens_tia_l Vbx_diag_ena_sens_tia_h Vbx_diag_ena_sens_tia_l Vxx_raw_sens_tia Vxx_raw_sens_up_it_temp
      Vxx_sens_tia_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiIat_Schedul
    ""

    /begin SUB_FUNCTION
      BiAsiIat_Tiaxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiIat_Tiaxxsr
    ""

    /begin DEF_CHARACTERISTIC
      Air_SRCTAFS.uMin_C Air_SRCTAFS.uMax_C Air_tTransfTAFS_CUR
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_df_sens_tia_h Vbx_df_sens_tia_l Vbx_diag_ena_sens_tia_h Vbx_diag_ena_sens_tia_l Vxx_raw_sens_tia Vxx_raw_sens_up_it_temp
      Vxx_sens_tia_v
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Air_tSensTAFS_mp Air_uRawTAFS_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiIti_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_it_last_ana_psn Vxx_it_sens_pws
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiIti_Itpossr
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_it_sens_pws_nok Cxx_it_sens_pws_over Cxx_it_sens_pws_under
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vxx_it_last_ana_psn Vxx_it_sens_pws
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      ThrVlv_uRaw_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiAsiIti_Itpossr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiIti_Schedul
    ""

    /begin SUB_FUNCTION
      BiAsiIti_Itpossr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiPbt_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_ex_prs_h Vbx_df_sens_ex_prs_l Vbx_diag_ena_sens_ex_prs_h Vbx_diag_ena_sens_ex_prs_l Vbx_sens_ex_prs_frz Vxx_raw_sens_ex_prs
      Vxx_sens_pbt_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAsiPbt_Pbtxxsr
    ""

    /begin DEF_CHARACTERISTIC
      Exh_SRCPTrbnUs.uMin_C Exh_SRCPTrbnUs.uMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Exh_uRawPTrbnUs Vbx_df_sens_ex_prs_h Vbx_df_sens_ex_prs_l Vbx_diag_ena_sens_ex_prs_h Vbx_diag_ena_sens_ex_prs_l Vxx_sens_pbt_v
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiAsiPbt_Pbtxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiPbt_Pbtxxsr_xxx
    ""

    /begin DEF_CHARACTERISTIC
      Cbx_sens_pbt_frz_cfm Cmp_pbt_frz_v_apl_thd Ctb_pbt_frz_n_thd Ctb_pbt_frz_tqi_thd Ctb_x_pbt_v_pbt Ctp_pbt_v_pbt
      Cxx_pbt_frz_dfdec Cxx_pbt_frz_dfinc Cxx_pbt_frz_tia_max Cxx_pbt_raw_flt Cxx_pbt_raw_init
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_sens_ex_prs_frz Vxx_raw_sens_ex_prs
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_eng_pbt_run Vbx_eng_pbt_stp Vbx_sens_pbt_buf Vbx_sens_pbt_buf_not Vbx_sens_pbt_dfth_max Vbx_sens_pbt_dfth_min
      Vbx_sens_pbt_df_frz Vbx_sens_pbt_frz_cfm Vbx_sens_pbt_init_frz Vbx_sens_pbt_v_flt_rdy Vxx_n_mv_pbtxxsr_mp Vxx_sens_pbt_v_apl
      Vxx_sens_pbt_v_avr Vxx_sens_pbt_v_ctr0 Vxx_sens_pbt_v_ctr1 Vxx_sens_pbt_v_flt Vxx_sens_pbt_v_max Vxx_sens_pbt_v_max0
      Vxx_sens_pbt_v_max1 Vxx_sens_pbt_v_min Vxx_sens_pbt_v_min0 Vxx_sens_pbt_v_min1 Vxx_sens_pbt_v_mv Vxx_sens_pbt_v_stp
      Vxx_sens_pbt_v_sum0 Vxx_sens_pbt_v_sum1 Vxx_tqi_raw_pbtxxsr_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiAsiPbt_Pbtxxsr_xxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAsiPbt_Schedul
    ""

    /begin SUB_FUNCTION
      BiAsiPbt_Pbtxxsr BiAsiPbt_Pbtxxsr_xxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAtiPfi_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_rup_h Vbx_df_sens_rup_l Vbx_diag_ena_sens_rup_h Vbx_diag_ena_sens_rup_l Vxx_raw_sens_pft_rel_up_prs Vxx_sens_pft_rel_up_prs_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAtiPfi_Rupxxsr
    ""

    /begin DEF_CHARACTERISTIC
      Ctb_x_rup_v_rup Ctp_rup_v_rup Cxx_rup_raw_flt Cxx_rup_raw_init
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Vxx_sens_pft_rel_up_prs_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_eng_rup_run Vbx_eng_rup_stp Vbx_sens_rup_buf Vbx_sens_rup_buf_not Vbx_sens_rup_v_flt_rdy Vxx_raw_sens_pft_rel_up_prs
      Vxx_sens_rup_v_avr Vxx_sens_rup_v_ctr0 Vxx_sens_rup_v_ctr1 Vxx_sens_rup_v_flt Vxx_sens_rup_v_mv Vxx_sens_rup_v_stp
      Vxx_sens_rup_v_sum0 Vxx_sens_rup_v_sum1
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiAtiPfi_Rupxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAtiPfi_Rupxxxx
    ""

    /begin DEF_CHARACTERISTIC
      Exh_SRCPPFltUs.uMin_C Exh_SRCPPFltUs.uMax_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_df_sens_rup_h Vbx_df_sens_rup_l Vbx_diag_ena_sens_rup_h Vbx_diag_ena_sens_rup_l Vxx_sens_pft_rel_up_prs_v
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Exh_uRawPPFltUs_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiAtiPfi_Rupxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAtiPfi_Schedul
    ""

    /begin SUB_FUNCTION
      BiAtiPfi_Rupxxsr BiAtiPfi_Rupxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAtiTbo_Doc1xxx
    ""

    /begin OUT_MEASUREMENT
      Exh_stPullUpTOxiCatUs Exh_uRawTOxiCatUs Vxx_sens_doc1_utp_v
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAtiTbo_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_raw_sens_doc1_utp Vxx_sens_doc1_utp_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAtiTbo_Schedul
    ""

    /begin SUB_FUNCTION
      BiAtiTbo_Doc1xxx BiAtiTbo_Tdoc1sr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAtiTbo_Tdoc1sr
    ""

    /begin DEF_CHARACTERISTIC
      Ctb_sens_doc1_utp_v Ctp_sens_doc1_utp
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Vxx_sens_doc1_utp_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_raw_sens_doc1_utp Vxx_sens_doc1_utp_v_mv
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAtiTuf_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_raw_sens_pft_utp Vxx_sens_pft_utp_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiAtiTuf_Schedul
    ""

    /begin SUB_FUNCTION
      BiAtiTuf_Utempsr BiAtiTuf_Utpxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAtiTuf_Utempsr
    ""

    /begin DEF_CHARACTERISTIC
      Ctb_sens_pft_utp_v Ctp_sens_pft_utp
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Vxx_sens_pft_utp_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_raw_sens_pft_utp Vxx_sens_pft_utp_v_mv
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiAtiTuf_Utempsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiAtiTuf_Utpxxxx
    ""

    /begin OUT_MEASUREMENT
      Exh_stPullUpTPFltUs Vxx_sens_pft_utp_v
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Exh_uRawTPFltUs_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiAtiTuf_Utpxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiFui_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_wfl_oc_1 Vxx_sens_fuel_temp_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiFui_Schedul
    ""

    /begin SUB_FUNCTION
      BiCbiFui_Tfuxxxx BiCbiFui_Wflxxsr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiFui_Tfuxxxx
    ""

    /begin IN_MEASUREMENT
      FuelT_uRaw
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_sens_fuel_temp_v
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiCbiFui_Tfuxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiFui_Wflxxsr
    ""

    /begin OUT_MEASUREMENT
      FlFWLvl_stRaw Vbx_df_sens_wfl_oc_1
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiRpi_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_sens_rail_prs
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiRpi_Fupxxxx
    ""

    /begin IN_MEASUREMENT
      RailP_pLin
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_sens_rail_prs
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiCbiRpi_Fupxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiRpi_Schedul
    ""

    /begin SUB_FUNCTION
      BiCbiRpi_Fupxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiTbt_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_raw_sens_tbt Vxx_sens_tbt_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiTbt_Schedul
    ""

    /begin SUB_FUNCTION
      BiCbiTbt_Tbtsrxx BiCbiTbt_Tbtxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiTbt_Tbtsrxx
    ""

    /begin DEF_CHARACTERISTIC
      Ctb_sens_tbt_v Ctp_sens_tbt
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Vxx_sens_tbt_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_raw_sens_tbt Vxx_sens_tbt_v_mv
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiCbiTbt_Tbtsrxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiTbt_Tbtxxxx
    ""

    /begin OUT_MEASUREMENT
      Vxx_sens_tbt_v
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiCbiTbt_Tbtxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Cbffwsc
    ""

    /begin DEF_CHARACTERISTIC
      Csx_epm_ctcyl_err
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_ctCyl
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      InjSys_qInrCmb
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Epm_ctCyl_cor
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Cbspvcm
    ""

    /begin OUT_MEASUREMENT
      PFltLd_stRgnThrActv
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Dgdgtdat
    ""

    /begin OUT_MEASUREMENT
      Vxx_rich_prop_up
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_ups_lamb_oc Vbx_df_sens_ups_pump_oc Vbx_df_sens_ups_virt_oc Vbx_df_sens_ups_wire_scg Vbx_df_sens_ups_wire_scw Vbx_df_ups_ecu_chr
      Vbx_df_ups_ecu_itl Vbx_df_ups_ecu_oor Vbx_df_ups_ro2_oor Vbx_df_ups_ro2_slow_trs Vbx_df_ups_uo2_oor Vbx_diag_ena_sens_ups_lamb_oc
      Vbx_diag_ena_sens_ups_pump_oc Vbx_diag_ena_sens_ups_virt_oc Vbx_diag_ena_sens_ups_wire_scg Vbx_diag_ena_sens_ups_wire_scw Vbx_diag_ena_ups_ecu_chr Vbx_diag_ena_ups_ecu_itl
      Vbx_diag_ena_ups_ecu_oor Vbx_diag_ena_ups_ro2_oor Vbx_diag_ena_ups_ro2_slow_trs Vbx_diag_ena_ups_uo2_oor Vbx_raw_sens_ups_rich_valid Vxx_raw_sens_ups_lamb
      Vxx_raw_sens_ups_rich Vxx_rich_prop_up Vxx_sens_prop_up_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Inasiia
    ""

    /begin OUT_MEASUREMENT
      AFS_dm Air_pUnFltPCACDs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Inatipf
    ""

    /begin OUT_MEASUREMENT
      Exh_pPFltUs
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Ouasoeg
    ""

    /begin DEF_CHARACTERISTIC
      AirCtl_stAirCtlBits_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      AirCtl_stAirCtlBits
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiCbiUeg_Ouasoeg
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Schedul
    ""

    /begin SUB_FUNCTION
      BiCbiUeg_Cbffwsc BiCbiUeg_Cbspvcm BiCbiUeg_Dgdgtdat BiCbiUeg_Inasiia BiCbiUeg_Inatipf BiCbiUeg_Ouasoeg
      BiCbiUeg_Uegoxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCbiUeg_Uegoxxx
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_diag_ena_LSU_active
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      LSU_stHtCtl LSU_swtEna LSU_uO2Raw TrbnDsRLam_rLam TrbnDsRLam_rLamRec
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_sens_ups_lamb_oc Vbx_df_sens_ups_pump_oc Vbx_df_sens_ups_virt_oc Vbx_df_sens_ups_wire_scg Vbx_df_sens_ups_wire_scw Vbx_df_ups_ecu_chr
      Vbx_df_ups_ecu_itl Vbx_df_ups_ecu_oor Vbx_df_ups_ro2_oor Vbx_df_ups_ro2_slow_trs Vbx_df_ups_uo2_oor Vbx_diag_ena_sens_ups_lamb_oc
      Vbx_diag_ena_sens_ups_pump_oc Vbx_diag_ena_sens_ups_virt_oc Vbx_diag_ena_sens_ups_wire_scg Vbx_diag_ena_sens_ups_wire_scw Vbx_diag_ena_ups_ecu_chr Vbx_diag_ena_ups_ecu_itl
      Vbx_diag_ena_ups_ecu_oor Vbx_diag_ena_ups_ro2_oor Vbx_diag_ena_ups_ro2_slow_trs Vbx_diag_ena_ups_uo2_oor Vbx_raw_sens_ups_rich_valid Vxx_raw_sens_ups_lamb
      Vxx_raw_sens_ups_rich Vxx_sens_prop_up_v
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCliCoi_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_tco_h Vbx_df_sens_tco_l Vbx_diag_ena_sens_tco_h Vbx_diag_ena_sens_tco_l Vxx_raw_sens_tco Vxx_sens_tco_v
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiCliCoi_Schedul
    ""

    /begin SUB_FUNCTION
      BiCliCoi_Tcoxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiCliCoi_Tcoxxxx
    ""

    /begin DEF_CHARACTERISTIC
      CEngDsT_SRC.uMin_C CEngDsT_SRC.uMax_C CEngDsT_tTransf_CUR
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_df_sens_tco_h Vbx_df_sens_tco_l Vbx_diag_ena_sens_tco_h Vbx_diag_ena_sens_tco_l Vxx_raw_sens_tco Vxx_sens_tco_v
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      CEngDsT_tSens_mp CEngDsT_uRaw_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiCliCoi_Tcoxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiPciApi_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_acel_pdl_sens_v1 Vxx_acel_pdl_sens_v2
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiPciApi_Pedxxxx
    ""

    /begin DEF_CHARACTERISTIC
      APP_uAPP1RawMin_C APP_uAPP2RawMin_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MoCADC_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_acel_pdl_sens_v1 Vxx_acel_pdl_sens_v2
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      APP_uRaw1UnLim_mp APP_uRaw2UnLim_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiPciApi_Schedul
    ""

    /begin SUB_FUNCTION
      BiPciApi_Pedxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiPciBki_Bkixxxx
    ""

    /begin OUT_MEASUREMENT
      Brk_stMnRaw Vbx_sens_brk_pdl_open
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiPciBki_Bkixxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiPciBki_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_sens_brk_pdl_open
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiPciBki_Schedul
    ""

    /begin SUB_FUNCTION
      BiPciBki_Bkixxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiPciCci_Cruslxx
    ""

    /begin OUT_MEASUREMENT
      Vbx_cru_on_off_in Vbx_eprm_rdy Vbx_sl_on_off_in Vxx_cru_sl_whl_cmd_in
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      CrC_stMnRaw_mp CrC_stSLRaw_mp CrC_uRawPan_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiPciCci_Cruslxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiPciCci_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_cru_on_off_in Vbx_eprm_rdy Vbx_sl_on_off_in Vxx_cru_sl_whl_cmd_in
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiPciCci_Schedul
    ""

    /begin SUB_FUNCTION
      BiPciCci_Cruslxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiPciDls_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_raw_sens_bgin_clu_cnt
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiPciDls_Schedul
    ""

    /begin SUB_FUNCTION
      BiPciDls_Seclbxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiPciDls_Seclbxx
    ""

    /begin OUT_MEASUREMENT
      Clth_stRaw Vbx_raw_sens_bgin_clu_cnt
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiPciDls_Seclbxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiSmiSyn_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_crk_chr Vbx_df_crk_cmp Vbx_df_crk_cyc Vbx_df_crk_el Vbx_df_crk_no_norm Vbx_df_crk_no_sig_wit_cam
      Vbx_df_crk_oc Vbx_df_crk_shp Vbx_df_crk_syn Vbx_df_ex_cam_chr Vbx_df_ex_cam_crk_cmp Vbx_df_ex_cam_l_puls
      Vbx_df_ex_cam_syn Vbx_df_in_cam_chr Vbx_df_in_cam_crk_cmp Vbx_df_in_cam_cyc Vbx_df_in_cam_frq_h Vbx_df_in_cam_l_puls
      Vbx_df_in_cam_nok Vbx_df_in_cam_no_sig Vbx_df_in_cam_syn Vbx_diag_ena_crk_chr Vbx_diag_ena_crk_cmp Vbx_diag_ena_crk_cyc
      Vbx_diag_ena_crk_el Vbx_diag_ena_crk_no_norm Vbx_diag_ena_crk_no_sig_wit_cam Vbx_diag_ena_crk_oc Vbx_diag_ena_crk_shp Vbx_diag_ena_crk_syn
      Vbx_diag_ena_ex_cam_chr Vbx_diag_ena_ex_cam_crk_cmp Vbx_diag_ena_ex_cam_l_puls Vbx_diag_ena_ex_cam_syn Vbx_diag_ena_in_cam_chr Vbx_diag_ena_in_cam_crk_cmp
      Vbx_diag_ena_in_cam_cyc Vbx_diag_ena_in_cam_frq_h Vbx_diag_ena_in_cam_l_puls Vbx_diag_ena_in_cam_nok Vbx_diag_ena_in_cam_no_sig Vbx_diag_ena_in_cam_syn
      Vbx_raw_eng_syn Vbx_raw_in_cam_lvl Vbx_raw_run_eng_det Vxx_raw_eng_angl Vxx_raw_in_cam_toth_per Vxx_raw_n
      Vxx_raw_tdc_ctr Vxx_raw_tdc_per
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiSmiSyn_Schedul
    ""

    /begin SUB_FUNCTION
      BiSmiSyn_Synchro
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiSmiSyn_Synchro
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_off_crk_dly
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EpmCaS_nEng EpmCrS_ctInc EpmCrS_stDiagNoSig EpmCrS_tiSeg EpmHCrS_stSigErr EpmHCrS_stSigMode
      Epm_ctCyl Epm_nEng Epm_stOpMode
    /end IN_MEASUREMENT
    /begin LOC_MEASUREMENT
      EpmHCrS_stCrkDlyCnf_mp Vbx_df_crk_chr Vbx_df_crk_cmp Vbx_df_crk_cyc Vbx_df_crk_el Vbx_df_crk_no_norm
      Vbx_df_crk_no_sig_wit_cam Vbx_df_crk_oc Vbx_df_crk_shp Vbx_df_crk_syn Vbx_df_ex_cam_chr Vbx_df_ex_cam_crk_cmp
      Vbx_df_ex_cam_l_puls Vbx_df_ex_cam_syn Vbx_df_in_cam_chr Vbx_df_in_cam_crk_cmp Vbx_df_in_cam_cyc Vbx_df_in_cam_frq_h
      Vbx_df_in_cam_l_puls Vbx_df_in_cam_nok Vbx_df_in_cam_no_sig Vbx_df_in_cam_syn Vbx_diag_ena_crk_chr Vbx_diag_ena_crk_cmp
      Vbx_diag_ena_crk_cyc Vbx_diag_ena_crk_el Vbx_diag_ena_crk_no_norm Vbx_diag_ena_crk_no_sig_wit_cam Vbx_diag_ena_crk_oc Vbx_diag_ena_crk_shp
      Vbx_diag_ena_crk_syn Vbx_diag_ena_ex_cam_chr Vbx_diag_ena_ex_cam_crk_cmp Vbx_diag_ena_ex_cam_l_puls Vbx_diag_ena_ex_cam_syn Vbx_diag_ena_in_cam_chr
      Vbx_diag_ena_in_cam_crk_cmp Vbx_diag_ena_in_cam_cyc Vbx_diag_ena_in_cam_frq_h Vbx_diag_ena_in_cam_l_puls Vbx_diag_ena_in_cam_nok Vbx_diag_ena_in_cam_no_sig
      Vbx_diag_ena_in_cam_syn Vbx_raw_eng_syn Vbx_raw_in_cam_lvl Vbx_raw_run_eng_det Vxx_raw_eng_angl Vxx_raw_in_cam_toth_per
      Vxx_raw_n Vxx_raw_tdc_ctr Vxx_raw_tdc_per
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiVfiAci_Acprssr
    ""

    /begin OUT_MEASUREMENT
      Vxx_raw_ac_prs
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      AirC_uAnaRawClnt_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiVfiAci_Acprssr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiVfiAci_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_raw_ac_prs
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiVfiAci_Schedul
    ""

    /begin SUB_FUNCTION
      BiVfiAci_Acprssr
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiVfiCri_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_sens_igk
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiVfiCri_Keyxxxx
    ""

    /begin DEF_CHARACTERISTIC
      T15_Deb.tiHiLo_C T15_Deb.tiLoHi_C
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_sens_igk
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      T15_st_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BiVfiCri_Keyxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiVfiCri_Schedul
    ""

    /begin SUB_FUNCTION
      BiVfiCri_Keyxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiVfiEmi_Batxxxx
    ""

    /begin DEF_CHARACTERISTIC
      BattU_uSRCMax_C BattU_uSRCMin_C BattU_uTransf_CUR
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      BattU_uRaw BattU_uSens Vbx_df_vb_rly_oc_scg Vbx_df_vb_rly_scw Vbx_diag_ena_vb_rly_oc_scg Vbx_diag_ena_vb_rly_scw
      Vxx_raw_vb
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BiVfiEmi_Batxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiVfiEmi_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_vb_rly_oc_scg Vbx_df_vb_rly_scw Vbx_diag_ena_vb_rly_oc_scg Vbx_diag_ena_vb_rly_scw Vxx_raw_vb
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiVfiEmi_Schedul
    ""

    /begin SUB_FUNCTION
      BiVfiEmi_Batxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BiVfiSlk_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_supl_emul_ecm Vtx_supl_chlg_val Vtx_supl_ini_noi
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BiVfiSlk_Verlogx
    ""

    /begin IN_MEASUREMENT
      ImmCtl_Noise ImmCtl_stEmul
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_supl_emul_ecm Vtx_supl_chlg_val Vtx_supl_ini_noi
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoAsoEgr_Bypxcmd
    ""

    /begin IN_MEASUREMENT
      ECBVlv_r
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_df_egr_byp_h Vbx_df_egr_byp_l Vbx_diag_ena_egr_byp_h Vbx_diag_ena_egr_byp_l
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BoAsoEgr_Bypxcmd
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAsoEgr_Evhbdgx
    ""

    /begin DEF_CHARACTERISTIC
      Cbx_emtv_vb_cor_ena Cxx_emtv_vb_cor
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      EGRVlv_rEGR Vbx_df_emtv_hbdg_el Vbx_df_emtv_hbdg_ovh Vbx_diag_ena_emtv_hbdg_el Vbx_diag_ena_emtv_hbdg_ovh Vxx_emtv_pwm
      Vxx_emtv_pwm_1
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BoAsoEgr_Evhbdgx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAsoEgr_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_egr_byp_h Vbx_df_egr_byp_l Vbx_df_emtv_hbdg_el Vbx_df_emtv_hbdg_ovh Vbx_diag_ena_egr_byp_h Vbx_diag_ena_egr_byp_l
      Vbx_diag_ena_emtv_hbdg_el Vbx_diag_ena_emtv_hbdg_ovh Vxx_emtv_pwm
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoAsoEgr_Schedul
    ""

    /begin SUB_FUNCTION
      BoAsoEgr_Bypxcmd BoAsoEgr_Evhbdgx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAsoIto_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_it_hbdg_el Vbx_df_it_hbdg_ovh Vbx_diag_ena_it_hbdg_el Vbx_diag_ena_it_hbdg_ovh Vxx_it_pwm
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoAsoIto_Ithbdgx
    ""

    /begin DEF_CHARACTERISTIC
      Cbx_it_vb_cor_ena Cxx_it_vb_cor
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      ThrVlv_rTVA Vbx_df_it_hbdg_el Vbx_df_it_hbdg_ovh Vbx_diag_ena_it_hbdg_el Vbx_diag_ena_it_hbdg_ovh Vxx_it_pwm
      Vxx_it_pwm_1
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BoAsoIto_Ithbdgx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAsoIto_Schedul
    ""

    /begin SUB_FUNCTION
      BoAsoIto_Ithbdgx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAsoTco_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_vnt_h Vbx_df_vnt_l Vbx_diag_ena_vnt_h Vbx_diag_ena_vnt_l
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoAsoTco_Schedul
    ""

    /begin SUB_FUNCTION
      BoAsoTco_Vntxcmd
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAsoTco_Vntxcmd
    ""

    /begin IN_MEASUREMENT
      TrbCh_r
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_df_vnt_h Vbx_df_vnt_l Vbx_diag_ena_vnt_h Vbx_diag_ena_vnt_l
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BoAsoTco_Vntxcmd
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAtoEfi_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_efi_inj_oc Vbx_df_efi_inj_scg Vbx_df_efi_inj_scw Vbx_df_efi_sldv_oc Vbx_df_efi_sldv_scg Vbx_df_efi_sldv_scw
      Vbx_diag_ena_efi_inj_oc Vbx_diag_ena_efi_inj_scg Vbx_diag_ena_efi_inj_scw Vbx_diag_ena_efi_sldv_oc Vbx_diag_ena_efi_sldv_scg Vbx_diag_ena_efi_sldv_scw
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoAtoEfi_Injcmdx
    ""

    /begin OUT_MEASUREMENT
      HCIVlv_r Vbx_df_efi_inj_oc Vbx_df_efi_inj_scg Vbx_df_efi_inj_scw Vbx_diag_ena_efi_inj_oc Vbx_diag_ena_efi_inj_scg
      Vbx_diag_ena_efi_inj_scw
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BoAtoEfi_Injcmdx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAtoEfi_Pumpcmd
    ""

    /begin OUT_MEASUREMENT
      HCVlv_st Vbx_df_efi_sldv_oc Vbx_df_efi_sldv_scg Vbx_df_efi_sldv_scw Vbx_diag_ena_efi_sldv_oc Vbx_diag_ena_efi_sldv_scg
      Vbx_diag_ena_efi_sldv_scw
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BoAtoEfi_Pumpcmd
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoAtoEfi_Schedul
    ""

    /begin SUB_FUNCTION
      BoAtoEfi_Injcmdx BoAtoEfi_Pumpcmd
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoCboHtg_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_htg_diag
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCboHtg_Htgxxxx
    ""

    /begin IN_MEASUREMENT
      GlwCtl_swtGlwPlgMode GlwPlg_rGCUFdbk
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_htg_diag
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      BoCboHtg_Htgxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoCboHtg_Schedul
    ""

    /begin SUB_FUNCTION
      BoCboHtg_Htgxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoCboInj_Brutrot
    ""

    /begin OUT_MEASUREMENT
      Vbx_diag_sta_brut_abrt Vbx_diag_sta_brut_ena Vbx_diag_sta_brut_end Vsx_diag_sta_brut_stt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_diag_sta_brut_abrt_1
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCboInj_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_diag_sta_brut_abrt Vbx_diag_sta_brut_ena Vbx_diag_sta_ffit_abrt Vbx_diag_sta_ffit_ena Vsx_diag_sta_brut_stt Vsx_diag_sta_ffit_stt
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCboInj_Ffitrot
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_ffit_vb_min
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      BattU_u Epm_nEng SyC_stSub VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_diag_sta_ffit_abrt Vbx_diag_sta_ffit_ena Vbx_diag_sta_ffit_end Vsx_diag_sta_ffit_stt
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCboInj_Schedul
    ""

    /begin SUB_FUNCTION
      BoCboInj_Brutrot BoCboInj_Ffitrot
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoCboRpr_Drptrot
    ""

    /begin OUT_MEASUREMENT
      Vbx_diag_sta_drpt_abrt Vbx_diag_sta_drpt_ena Vbx_diag_sta_drpt_end Vsx_diag_sta_drpt_stt
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_diag_sta_drpt_abrt_1
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCboRpr_Schedul
    ""

    /begin SUB_FUNCTION
      BoCboRpr_Drptrot
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoCboUeg_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_sens_ups_heat_oc Vbx_df_sens_ups_heat_ovh Vbx_df_sens_ups_heat_scg Vbx_df_sens_ups_heat_scw Vbx_df_ups_tip_oor Vbx_diag_ena_sens_ups_heat_oc
      Vbx_diag_ena_sens_ups_heat_ovh Vbx_diag_ena_sens_ups_heat_scg Vbx_diag_ena_sens_ups_heat_scw Vbx_diag_ena_ups_tip_oor
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCboUeg_Schedul
    ""

    /begin SUB_FUNCTION
      BoCboUeg_Upshtdg
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoCboUeg_Upshtdg
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_lsu_dcyc_diag_ena
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      LSU_dcycHt LSU_swtEna
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_df_sens_ups_heat_oc Vbx_df_sens_ups_heat_ovh Vbx_df_sens_ups_heat_scg Vbx_df_sens_ups_heat_scw Vbx_df_ups_tip_oor Vbx_diag_ena_sens_ups_heat_oc
      Vbx_diag_ena_sens_ups_heat_ovh Vbx_diag_ena_sens_ups_heat_scg Vbx_diag_ena_sens_ups_heat_scw Vbx_diag_ena_ups_tip_oor
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      LSU_stHtcond_mp
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BoCboUeg_Upshtdg
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoCloCoo_Chvcmdx
    ""

    /begin IN_MEASUREMENT
      WaHtEl_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_df_thpl_cmd1_oc Vbx_df_thpl_cmd1_scg Vbx_df_thpl_cmd1_scw Vbx_df_thpl_cmd2_oc Vbx_df_thpl_cmd2_scg Vbx_df_thpl_cmd2_scw
      Vbx_df_thpl_cmd3_oc Vbx_df_thpl_cmd3_scg Vbx_df_thpl_cmd3_scw Vbx_diag_ena_thpl_cmd1_oc Vbx_diag_ena_thpl_cmd1_scg Vbx_diag_ena_thpl_cmd1_scw
      Vbx_diag_ena_thpl_cmd2_oc Vbx_diag_ena_thpl_cmd2_scg Vbx_diag_ena_thpl_cmd2_scw Vbx_diag_ena_thpl_cmd3_oc Vbx_diag_ena_thpl_cmd3_scg Vbx_diag_ena_thpl_cmd3_scw
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCloCoo_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_thpl_cmd1_oc Vbx_df_thpl_cmd1_scg Vbx_df_thpl_cmd1_scw Vbx_df_thpl_cmd2_oc Vbx_df_thpl_cmd2_scg Vbx_df_thpl_cmd2_scw
      Vbx_df_thpl_cmd3_oc Vbx_df_thpl_cmd3_scg Vbx_df_thpl_cmd3_scw Vbx_df_wpmp_tcr_blk Vbx_df_wpmp_tcr_oc Vbx_df_wpmp_tcr_scg
      Vbx_df_wpmp_tcr_scw Vbx_diag_ena_thpl_cmd1_oc Vbx_diag_ena_thpl_cmd1_scg Vbx_diag_ena_thpl_cmd1_scw Vbx_diag_ena_thpl_cmd2_oc Vbx_diag_ena_thpl_cmd2_scg
      Vbx_diag_ena_thpl_cmd2_scw Vbx_diag_ena_thpl_cmd3_oc Vbx_diag_ena_thpl_cmd3_scg Vbx_diag_ena_thpl_cmd3_scw Vbx_diag_ena_wpmp_tcr_blk Vbx_diag_ena_wpmp_tcr_oc
      Vbx_diag_ena_wpmp_tcr_scg Vbx_diag_ena_wpmp_tcr_scw
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCloCoo_Paeautx
    ""

    /begin IN_MEASUREMENT
      TrbChPmp_stFrqErr TrbChPmp_stSCGErr
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      TrbChPmp_st Vbx_df_wpmp_tcr_blk Vbx_df_wpmp_tcr_oc Vbx_df_wpmp_tcr_scg Vbx_df_wpmp_tcr_scw Vbx_diag_ena_wpmp_tcr_blk
      Vbx_diag_ena_wpmp_tcr_oc Vbx_diag_ena_wpmp_tcr_scg Vbx_diag_ena_wpmp_tcr_scw
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoCloCoo_Schedul
    ""

    /begin SUB_FUNCTION
      BoCloCoo_Chvcmdx BoCloCoo_Paeautx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoSmoSmd_Coengxx
    ""

    /begin OUT_MEASUREMENT
      StSys_stStrt
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoSmoSmd_Schedul
    ""

    /begin SUB_FUNCTION
      BoSmoSmd_Coengxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoVfoSup_Actuaxx
    ""

    /begin REF_CHARACTERISTIC
      MRly_ctErlyOpng_C
    /end REF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      MRly_ctErlyOpng_mp MRly_st Vbx_actr_rly_cmd
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vbx_diag_ena_actr_rly_oc Vbx_diag_ena_actr_rly_scg Vbx_diag_ena_actr_rly_scw
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      Vbx_df_actr_rly_oc Vbx_df_actr_rly_scg Vbx_df_actr_rly_scw
    /end LOC_MEASUREMENT
    /begin SUB_FUNCTION
      BoVfoSup_Actuaxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BoVfoSup_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_actr_rly_oc Vbx_df_actr_rly_scg Vbx_df_actr_rly_scw Vbx_df_pws_1_h Vbx_df_pws_1_l Vbx_df_pws_2_h
      Vbx_df_pws_2_l Vbx_df_pws_3_h Vbx_df_pws_3_l Vbx_diag_ena_actr_rly_oc Vbx_diag_ena_actr_rly_scg Vbx_diag_ena_actr_rly_scw
      Vbx_diag_ena_pws_1_h Vbx_diag_ena_pws_1_l Vbx_diag_ena_pws_2_h Vbx_diag_ena_pws_2_l Vbx_diag_ena_pws_3_h Vbx_diag_ena_pws_3_l
      Vxx_raw_pws_1 Vxx_raw_pws_2 Vxx_raw_pws_3
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoVfoSup_Pws3xxx
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_pws_3
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_df_pws_3_h Vbx_df_pws_3_l Vbx_diag_ena_pws_3_h Vbx_diag_ena_pws_3_l Vxx_raw_pws_3
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      CY320_stSensSply4_mp CY320_stSensSply5_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoVfoSup_Pwsxxxx
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_pws_1 Cxx_pws_2
    /end DEF_CHARACTERISTIC
    /begin OUT_MEASUREMENT
      Vbx_df_pws_1_h Vbx_df_pws_1_l Vbx_df_pws_2_h Vbx_df_pws_2_l Vbx_diag_ena_pws_1_h Vbx_diag_ena_pws_1_l
      Vbx_diag_ena_pws_2_h Vbx_diag_ena_pws_2_l Vxx_raw_pws_1 Vxx_raw_pws_2
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      CY320_stSensSply0_mp CY320_stSensSply1_mp CY320_stSensSply2_mp CY320_stSensSply3_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    BoVfoSup_Schedul
    ""

    /begin SUB_FUNCTION
      BoVfoSup_Actuaxx BoVfoSup_Pws3xxx BoVfoSup_Pwsxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    BypCan
    ""


/end FUNCTION

/begin FUNCTION

    BypDrv
    ""


/end FUNCTION

/begin FUNCTION

    BypEtk
    ""


/end FUNCTION

/begin FUNCTION

    BypInt
    ""


/end FUNCTION

/begin FUNCTION

    CalWup
    ""

    /begin DEF_CHARACTERISTIC
      Calwup_swtWakeupEnaCpl_C Calwup_swtWakeupEna_C
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    Can
    ""

    /begin DEF_CHARACTERISTIC
      Cxx_ACC_CANHS_R_01_RB_id Cxx_AIRBAGCrash_RB_id Cxx_BCM_CANHS_RNr_01_RB_id Cxx_BCM_CANHS_RNr_02_RB_id Cxx_BCM_VERLOG_RB_id Cxx_BRAKE_CANHS_RNr_01_RB_id
      Cxx_BRAKE_CANHS_RNr_02_RB_id Cxx_BRAKE_CANHS_RNr_03_RB_id Cxx_BRAKE_CANHS_RNr_04_RB_id Cxx_BRAKE_CANHS_R_01_RB_id Cxx_CLIM_CANHS_R_01_RB_id Cxx_CLUSTER_CANHS_RNr_01_RB_id
      Cxx_CLUSTER_CANHS_R_01_RB_id Cxx_DDCM_CANLSFT_R_01_RB_id Cxx_ECM_CANHS_RNr_01_RB_id Cxx_ECM_CANHS_RNr_02_RB_id Cxx_ECM_VERLOG_RB_id Cxx_FORCE_ECM_CANHS_R_01_RB_id
      Cxx_MMI_ECM_CANHS_RNr_01_RB_id Cxx_NC_CAN_RX_FCT_id Cxx_NC_CAN_RX_PHYS_id Cxx_NC_CAN_TX_id Cxx_SWA_CANHS_RNr_01_RB_id Cxx_TORQUE_AT_CANHS_RNr_01_RB_id
      Cxx_TORQUE_AT_CANHS_RNr_02_RB_id Cxx_TORQUE_ECM_CANHS_RNr_01_RB_id Cxx_TORQUE_ECM_CANHS_RNr_02_RB_id Cxx_TORQUE_ECM_CANHS_R_01_RB_id Cxx_USM_CANHS_RNr_01_RB_id
    /end DEF_CHARACTERISTIC

/end FUNCTION

/begin FUNCTION

    CBBasic
    ""


/end FUNCTION

/begin FUNCTION

    CBBMW
    ""


/end FUNCTION

/begin FUNCTION

    CbCorRic_Dataxxx
    ""

    /begin IN_MEASUREMENT
      FMA_qCor
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_tqi_cor_fma
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      CbCorRic_Dataxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    CbCorRic_Diagxxx
    ""

    /begin LOC_MEASUREMENT
      Vbx_df_tqi_cor_chr
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CbCorRic_Ex
    ""

    /begin IN_MEASUREMENT
      Vxx_egr_tqi_fisa_cor Vxx_tqi_cor_fma
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CbCorRic_Schedul
    ""

    /begin SUB_FUNCTION
      CbCorRic_Dataxxx CbCorRic_Diagxxx CbCorRic_Tqcorxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    CbCorRic_Tqcorxx
    ""

    /begin IN_MEASUREMENT
      Vxx_tqi_cor_fma
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      Vxx_egr_tqi_fisa_cor
    /end OUT_MEASUREMENT
    /begin SUB_FUNCTION
      CbCorRic_Tqcorxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    CBDC
    ""


/end FUNCTION

/begin FUNCTION

    CBEeebd
    ""


/end FUNCTION

/begin FUNCTION

    CBEeepdd
    ""


/end FUNCTION

/begin FUNCTION

    CBEepHal
    ""


/end FUNCTION

/begin FUNCTION

    CBFlash
    ""


/end FUNCTION

/begin FUNCTION

    CBFPrt
    ""


/end FUNCTION

/begin FUNCTION

    CBMain
    ""


/end FUNCTION

/begin FUNCTION

    CBOS
    ""


/end FUNCTION

/begin FUNCTION

    CbRapCtl_Cpcxxxx
    ""


/end FUNCTION

/begin FUNCTION

    CbRapCtl_Ex
    ""

    /begin IN_MEASUREMENT
      Vbx_df_fprs_fct_dirt_lkg Vsx_ff_fct_vld Vsx_fprs_fct_vld
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CbRapCtl_Flowxxx
    ""

    /begin OUT_MEASUREMENT
      Vsx_ff_fct_vld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CbRapCtl_Prsxxxx
    ""

    /begin OUT_MEASUREMENT
      Vbx_df_fprs_fct_dirt_lkg Vsx_fprs_fct_vld
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CbRapCtl_Schedul
    ""

    /begin SUB_FUNCTION
      CbRapCtl_Cpcxxxx CbRapCtl_Flowxxx CbRapCtl_Prsxxxx
    /end SUB_FUNCTION

/end FUNCTION

/begin FUNCTION

    CBReprog
    ""


/end FUNCTION

/begin FUNCTION

    CBTarget
    ""


/end FUNCTION

/begin FUNCTION

    CBTProt
    ""


/end FUNCTION

/begin FUNCTION

    CBUAcc
    ""


/end FUNCTION

/begin FUNCTION

    CBUtil
    ""


/end FUNCTION

/begin FUNCTION

    CBVW
    ""


/end FUNCTION

/begin FUNCTION

    CcpAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    ccp_auto
    ""


/end FUNCTION

/begin FUNCTION

    Ccp_Std
    ""


/end FUNCTION

/begin FUNCTION

    Cic751
    ""


/end FUNCTION

/begin FUNCTION

    Cj125
    ""


/end FUNCTION

/begin FUNCTION

    Cj230
    ""


/end FUNCTION

/begin FUNCTION

    CoEng_Axispoints
    ""


/end FUNCTION

/begin FUNCTION

    CoEng_Mon
    ""

    /begin DEF_CHARACTERISTIC
      CoEng_AftRunShOff_C CoEng_nSoftShOffMax_C CoEng_nSoftShOffMin_C CoEng_qSoftShOffMax_C CoEng_stShutOffInit_C CoEng_stSoftShOff_C
      CoEng_tiSoftShOff_CUR CoEng_vSoftShOffMax_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st CoEng_stShutOffRSA Epm_nEng InjCtl_qSetUnBal VehV_v
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      CoEng_stShutOffPath
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      CoEng_stSoftShOffRls_mp CoEng_stSoftShOff_mp CoEng_tiSoftShOff_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CoEng_StEng
    ""

    /begin DEF_CHARACTERISTIC
      CoEng_nThresCranking_C CoEng_nThresNrml2Strt_C CoEng_tiNrml2Strt_C CoEng_tiPwrStgDiaRdy_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      Epm_nEng StSys_stStrt
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      CoEng_st CoEng_stOld CoEng_tiAfterrun CoEng_tiAfterrunRed CoEng_tiNormal CoEng_tiNormalRed
      CoEng_tiStandby CoEng_tiStandbyRed CoEng_tiStart CoEng_tiStartRed
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CoEng_StrtCtl
    ""

    /begin DEF_CHARACTERISTIC
      CoEng_stStopEna_C CoEng_stStrtEna_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      GlwCtl_tiPreGlwRmn
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      CoEng_stStopEna CoEng_stStrtEna CoEng_tiStrtDly
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CoEOM_Lib
    ""


/end FUNCTION

/begin FUNCTION

    CoES_AVSCoLSU
    ""

    /begin DEF_CHARACTERISTIC
      CoES_MskDewDet_C CoES_MskFMA_C CoES_MskLSU_C CoES_stFuncSel_C CoES_swtAdjMod_C
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      CoEng_st
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      CoES_stAVSCoLSU
    /end OUT_MEASUREMENT
    /begin LOC_MEASUREMENT
      CoES_stAVSCoLSU_mp CoES_stFMAReadRls_mp CoES_stFMAWriteRls_mp CoES_stSig_mp CoES_stTrmMod_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    ComMS
    ""


/end FUNCTION

/begin FUNCTION

    Core_Env
    ""


/end FUNCTION

/begin FUNCTION

    CoTemp_DmAirDesVal
    ""

    /begin DEF_CHARACTERISTIC
      CoTemp_rClgDes_CUR
    /end DEF_CHARACTERISTIC
    /begin IN_MEASUREMENT
      EngDa_tEng
    /end IN_MEASUREMENT
    /begin OUT_MEASUREMENT
      CoTemp_rClgDes
    /end OUT_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Cpu
    ""

    /begin DEF_CHARACTERISTIC
      Cpu_swtClrEnvRAMVals_C
    /end DEF_CHARACTERISTIC
    /begin LOC_MEASUREMENT
      Cpu_rCurCSACons_mp Cpu_rCurSysStackCons_mp Cpu_rCurUsrStackCons_mp Cpu_rMaxCSACons_mp Cpu_rMaxSysStackCons_mp Cpu_rMaxUsrStackCons_mp
    /end LOC_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    CrntCtl_VDSet
    ""

    /begin IN_MEASUREMENT
      FuelT_tFlSys
    /end IN_MEASUREMENT

/end FUNCTION

/begin FUNCTION

    Cy320
    ""


/end FUNCTION

/begin FUNCTION

    DcanAppl_Std
    ""


/end FUNCTION

/begin FUNCTION

    Dcan_Std
    ""


/end FUNCTION

/begin FUNCTION

    ddrc_auto
    ""

    /begin DEF_CHARACTERISTIC
      DDRC_DurDeb.AirC_tiCmprSCBDebOk_C DDRC_DurDeb.AirC_tiCmprSCBDebDef_C DDRC_DurDeb.ThrVlv_tiHBrgUndrVltgDebOk_C DDRC_DurDeb.ThrVlv_tiHBrgUndrVltgDebDef_C DDRC_DurDeb.LSU_titExcMaxDebOk_C DDRC_DurDeb.LSU_titExcMaxDebDef_C
      DDRC_DurDeb.HCInj_tiSCGDebOk_C DDRC_DurDeb.HCInj_tiSCGDebDef_C DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd1DebOk_C DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd1DebDef_C DDRC_DurDeb.GlwPlg_tiDebDiaSumDebOk_C DDRC_DurDeb.GlwPlg_tiDebDiaSumDebDef_C
      DDRC_DurDeb.ECBVlv_tiSCBDebOk_C DDRC_DurDeb.ECBVlv_tiSCBDebDef_C DDRC_DurDeb.TrbCh_tiOLDebOk_C DDRC_DurDeb.TrbCh_tiOLDebDef_C DDRC_DurDeb.GlwPlg_tiOLDebOk_C DDRC_DurDeb.GlwPlg_tiOLDebDef_C
      DDRC_DurDeb.LSU_tiHtrSigDebOk_C DDRC_DurDeb.LSU_tiHtrSigDebDef_C DDRC_DurDeb.EGRVlv_tiSCGDebOk_C DDRC_DurDeb.EGRVlv_tiSCGDebDef_C DDRC_DurDeb.GlwPlg_tiLVSOLDebOk_C DDRC_DurDeb.GlwPlg_tiLVSOLDebDef_C
      DDRC_DurDeb.InjVlv_tiPresMinDebOk_C DDRC_DurDeb.InjVlv_tiPresMinDebDef_C DDRC_DurDeb.ECBVlv_tiSCGDebOk_C DDRC_DurDeb.ECBVlv_tiSCGDebDef_C DDRC_DurDeb.PCV_tiSCGDebOk_C DDRC_DurDeb.PCV_tiSCGDebDef_C
      DDRC_DurDeb.DevLib_tiBattULoDebOk_C DDRC_DurDeb.DevLib_tiBattULoDebDef_C DDRC_DurDeb.WaHtEl_tiOLDebOk_C DDRC_DurDeb.WaHtEl_tiOLDebDef_C DDRC_DurDeb.AFS_tiCorSRCMaxDebOk_C DDRC_DurDeb.AFS_tiCorSRCMaxDebDef_C
      DDRC_DurDeb.HCInj_tiSCBDebOk_C DDRC_DurDeb.HCInj_tiSCBDebDef_C DDRC_DurDeb.ThrVlv_tiOLDebOk_C DDRC_DurDeb.ThrVlv_tiOLDebDef_C DDRC_DurDeb.EGRVlv_tiSCBDebOk_C DDRC_DurDeb.EGRVlv_tiSCBDebDef_C
      DDRC_DurDeb.ThrVlv_tiHBrgShCirOvrLdDebOk_C DDRC_DurDeb.ThrVlv_tiHBrgShCirOvrLdDebDef_C DDRC_DurDeb.MeUn_tiOLDebOk_C DDRC_DurDeb.MeUn_tiOLDebDef_C DDRC_DurDeb.WaHtEl_tiOvrTempDebOk_C DDRC_DurDeb.WaHtEl_tiOvrTempDebDef_C
      DDRC_DurDeb.LSU_tiHtrNplDebOk_C DDRC_DurDeb.LSU_tiHtrNplDebDef_C DDRC_DurDeb.ThrVlv_tiHBrgOvrTempDebOk_C DDRC_DurDeb.ThrVlv_tiHBrgOvrTempDebDef_C DDRC_DurDeb.FuelT_tiMinDebOk_C DDRC_DurDeb.FuelT_tiMinDebDef_C
      DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd2DebOk_C DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd2DebDef_C DDRC_DurDeb.GlwPlg_tiOvrTempDebOk_C DDRC_DurDeb.GlwPlg_tiOvrTempDebDef_C DDRC_DurDeb.ThrVlv_tiHBrgTempOvrCurrDebOk_C DDRC_DurDeb.ThrVlv_tiHBrgTempOvrCurrDebDef_C
      DDRC_DurDeb.WaHtEl_tiSCBDebOk_C DDRC_DurDeb.WaHtEl_tiSCBDebDef_C DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt1DebOk_C DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt1DebDef_C DDRC_DurDeb.AirC_tiCmprRedTrqOLDebOk_C DDRC_DurDeb.AirC_tiCmprRedTrqOLDebDef_C
      DDRC_DurDeb.MeUn_tiSCGDebOk_C DDRC_DurDeb.MeUn_tiSCGDebDef_C DDRC_DurDeb.PCV_tiSRCMinDebOk_C DDRC_DurDeb.PCV_tiSRCMinDebDef_C DDRC_DurDeb.RailP_tiSRCMinDebOk_C DDRC_DurDeb.RailP_tiSRCMinDebDef_C
      DDRC_DurDeb.GlwPlg_tiSCGDebOk_C DDRC_DurDeb.GlwPlg_tiSCGDebDef_C DDRC_DurDeb.EGRVlv_tiHBrgUndrVltgDebOk_C DDRC_DurDeb.EGRVlv_tiHBrgUndrVltgDebDef_C DDRC_DurDeb.MeUn_tiSRCMinDebOk_C DDRC_DurDeb.MeUn_tiSRCMinDebDef_C
      DDRC_DurDeb.EGRVlv_tiHBrgOpnLdDebOk_C DDRC_DurDeb.EGRVlv_tiHBrgOpnLdDebDef_C DDRC_DurDeb.EGRVlv_tiOvrTempDebOk_C DDRC_DurDeb.EGRVlv_tiOvrTempDebDef_C DDRC_DurDeb.LSU_tiHtrMaxDebOk_C DDRC_DurDeb.LSU_tiHtrMaxDebDef_C
      DDRC_DurDeb.EGRVlv_tiHBrgShCirOvrLdDebOk_C DDRC_DurDeb.EGRVlv_tiHBrgShCirOvrLdDebDef_C DDRC_DurDeb.LSU_tiO2MaxDebOk_C DDRC_DurDeb.LSU_tiO2MaxDebDef_C DDRC_DurDeb.ECBVlv_tiOvrTempDebOk_C DDRC_DurDeb.ECBVlv_tiOvrTempDebDef_C
      DDRC_DurDeb.TrbCh_tiSCGDebOk_C DDRC_DurDeb.TrbCh_tiSCGDebDef_C DDRC_DurDeb.EGRCPmp_tiSCGDebOk_C DDRC_DurDeb.EGRCPmp_tiSCGDebDef_C DDRC_DurDeb.LSU_tiOpnLdDebOk_C DDRC_DurDeb.LSU_tiOpnLdDebDef_C
      DDRC_DurDeb.AirC_tiCmprOLDebOk_C DDRC_DurDeb.AirC_tiCmprOLDebDef_C DDRC_DurDeb.GlwPlg_tiLVSSCGDebOk_C DDRC_DurDeb.GlwPlg_tiLVSSCGDebDef_C DDRC_DurDeb.AirC_tiCmprRedTrqSCGDebOk_C DDRC_DurDeb.AirC_tiCmprRedTrqSCGDebDef_C
      DDRC_DurDeb.DevLib_tiBattUHiDebOk_C DDRC_DurDeb.DevLib_tiBattUHiDebDef_C DDRC_DurDeb.GlwPlg_tiDebDiaHiDebOk_C DDRC_DurDeb.GlwPlg_tiDebDiaHiDebDef_C DDRC_DurDeb.ThrVlv_tiSCBDebOk_C DDRC_DurDeb.ThrVlv_tiSCBDebDef_C
      DDRC_DurDeb.FuelT_tiMaxDebOk_C DDRC_DurDeb.FuelT_tiMaxDebDef_C DDRC_DurDeb.GlwPlg_tiDebDiaLoDebOk_C DDRC_DurDeb.GlwPlg_tiDebDiaLoDebDef_C DDRC_DurDeb.Air_tiSRCMinTEGRClrDsDebOk_C DDRC_DurDeb.Air_tiSRCMinTEGRClrDsDebDef_C
      DDRC_DurDeb.GlwPlg_tiLVSSCBDebOk_C DDRC_DurDeb.GlwPlg_tiLVSSCBDebDef_C DDRC_DurDeb.PCV_tiOLDebOk_C DDRC_DurDeb.PCV_tiOLDebDef_C DDRC_DurDeb.MeUn_tiSRCMaxDebOk_C DDRC_DurDeb.MeUn_tiSRCMaxDebDef_C
      DDRC_DurDeb.LSU_tiHtrMinDebOk_C DDRC_DurDeb.LSU_tiHtrMinDebDef_C DDRC_DurDeb.HCVlv_tiSCBDebOk_C DDRC_DurDeb.HCVlv_tiSCBDebDef_C DDRC_DurDeb.EGRVlv_tiHBrgTempOvrCurrDebOk_C DDRC_DurDeb.EGRVlv_tiHBrgTempOvrCurrDebDef_C
      DDRC_DurDeb.LSU_tiShCirDebOk_C DDRC_DurDeb.LSU_tiShCirDebDef_C DDRC_DurDeb.EGRCPmp_tiSCBDebOk_C DDRC_DurDeb.EGRCPmp_tiSCBDebDef_C DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt2DebOk_C DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt2DebDef_C
      DDRC_DurDeb.MeUn_tiOTDebOk_C DDRC_DurDeb.MeUn_tiOTDebDef_C DDRC_DurDeb.PCV_tiSRCMaxDebOk_C DDRC_DurDeb.PCV_tiSRCMaxDebDef_C DDRC_DurDeb.EGRVlv_tiHBrgOvrTempDebOk_C DDRC_DurDeb.EGRVlv_tiHBrgOvrTempDebDef_C
      DDRC_DurDeb.AFS_tiOffsDrftMaxDebOk_C DDRC_DurDeb.AFS_tiOffsDrftMaxDebDef_C DDRC_DurDeb.PCV_tiSCBDebOk_C DDRC_DurDeb.PCV_tiSCBDebDef_C DDRC_DurDeb.ECBVlv_tiOLDebOk_C DDRC_DurDeb.ECBVlv_tiOLDebDef_C
      DDRC_DurDeb.GlwPlg_tiLVSOvrTempDebOk_C DDRC_DurDeb.GlwPlg_tiLVSOvrTempDebDef_C DDRC_DurDeb.EGRVlv_tiHBrgOvrCurrDebOk_C DDRC_DurDeb.EGRVlv_tiHBrgOvrCurrDebDef_C DDRC_DurDeb.ThrVlv_tiOvrTempDebOk_C DDRC_DurDeb.ThrVlv_tiOvrTempDebDef_C
      DDRC_DurDeb.EGRVlv_tiOLDebOk_C DDRC_DurDeb.EGRVlv_tiOLDebDef_C DDRC_DurDeb.AFS_tiRawSRCMinDebOk_C DDRC_DurDeb.AFS_tiRawSRCMinDebDef_C DDRC_DurDeb.AFS_tiOffsDrftMinDebOk_C DDRC_DurDeb.AFS_tiOffsDrftMinDebDef_C
      DDRC_DurDeb.Air_tiSRCMaxTEGRClrDsDebOk_C DDRC_DurDeb.Air_tiSRCMaxTEGRClrDsDebDef_C DDRC_DurDeb.LSU_tiO2MinDebOk_C DDRC_DurDeb.LSU_tiO2MinDebDef_C DDRC_DurDeb.EGRCPmp_tiOLDebOk_C DDRC_DurDeb.EGRCPmp_tiOLDebDef_C
      DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt2DebOk_C DDRC_DurDeb.ThrVlv_tiHBrgShCirBatt2DebDef_C DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt1DebOk_C DDRC_DurDeb.EGRVlv_tiHBrgShCirBatt1DebDef_C DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd2DebOk_C DDRC_DurDeb.ThrVlv_tiHBrgShCirGnd2DebDef_C
      DDRC_DurDeb.WaHtEl_tiSCGDebOk_C DDRC_DurDeb.WaHtEl_tiSCGDebDef_C DDRC_DurDeb.MeUn_tiSCBDebOk_C DDRC_DurDeb.MeUn_tiSCBDebDef_C DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd1DebOk_C DDRC_DurDeb.EGRVlv_tiHBrgShCirGnd1DebDef_C
      DDRC_DurDeb.AirC_tiCmprRedTrqSCBDebOk_C DDRC_DurDeb.AirC_tiCmprRedTrqSCBDebDef_C DDRC_DurDeb.HCInj_tiOLDebOk_C DDRC_DurDeb.HCInj_tiOLDebDef_C DDRC_DurDeb.AFS_tiCorSRCMinDebOk_C DDRC_DurDeb.AFS_tiCorSRCMinDebDef_C
      DDRC_DurDeb.ThrVlv_tiHBrgOvrCurrDebOk_C DDRC_DurDeb.ThrVlv_tiHBrgOvrCurrDebDef_C DDRC_DurDeb.PCV_tiOTDebOk_C DDRC_DurDeb.PCV_tiOTDebDef_C DDRC_DurDeb.LSU_tiCircPmpCurSigDebOk_C DDRC_DurDeb.LSU_tiCircPmpCurSigDebDef_C
      DDRC_DurDeb.HCVlv_tiOLDebOk_C DDRC_DurDeb.HCVlv_tiOLDebDef_C DDRC_DurDeb.AFS_tiRawSRCMaxDebOk_C DDRC_DurDeb.AFS_tiRawSRCMaxDebDef_C DDRC_DurDeb.ThrVlv_tiSCGDebOk_C DDRC_DurDeb.ThrVlv_tiSCGDebDef_C
      DDRC_DurDeb.HCVlv_tiSCGDebOk_C DDRC_DurDeb.HCVlv_tiSCGDebDef_C DDRC_DurDeb.GlwPlg_tiSCBDebOk_C DDRC_DurDeb.GlwPlg_tiSCBDebDef_C DDRC_DurDeb.DSMTst_ExampleDebOk_C DDRC_DurDeb.DSMTst_ExampleDebDef_C
      DDRC_DurDeb.LSU_titExcMinDebOk_C DDRC_DurDeb.LSU_titExcMinDebDef_C DDRC_DurDeb.LSU_tiSPIBattLowMinDebOk_C DDRC_DurDeb.LSU_tiSPIBattLowMinDebDef_C DDRC_DurDeb.AirC_tiCmprSCGDebOk_C DDRC_DurDeb.AirC_tiCmprSCGDebDef_C
      DDRC_DurDeb.ThrVlv_tiHBrgOpnLdDebOk_C DDRC_DurDeb.ThrVlv_tiHBrgOpnLdDebDef_C DDRC_DurDeb.TrbCh_tiSCBDebOk_C DDRC_DurDeb.TrbCh_tiSCBDebDef_C DDRC_DurDeb.RailP_tiSRCMaxDebOk_C DDRC_DurDeb.RailP_tiSRCMaxDebDef_C
      DDRC_DurDeb.IVActr_numEnrgMaxDebOk_C DDRC_DurDeb.IVActr_numEnrgMaxDebDef_C DDRC_DurDeb.RailP_numdpDebOk_C DDRC_DurDeb.RailP_numdpDebDef_C DDRC_DurDeb.IVDia_numCylShCirMeasDebOk_C DDRC_DurDeb.IVDia_numCylShCirMeasDebDef_C
      DDRC_DurDeb.LSU_numPresCompMinDebOk_C DDRC_DurDeb.LSU_numPresCompMinDebDef_C DDRC_DurDeb.IVActr_numEnrgMinDebOk_C DDRC_DurDeb.IVActr_numEnrgMinDebDef_C DDRC_DurDeb.IVPSply_numStopDCDCDebOk_C DDRC_DurDeb.IVPSply_numStopDCDCDebDef_C
      DDRC_DurDeb.LSU_numO2ClbMaxDebOk_C DDRC_DurDeb.LSU_numO2ClbMaxDebDef_C DDRC_DurDeb.IVDia_numCylNoLdDebOk_C DDRC_DurDeb.IVDia_numCylNoLdDebDef_C DDRC_DurDeb.LSU_numTempCompMaxDebOk_C DDRC_DurDeb.LSU_numTempCompMaxDebDef_C
