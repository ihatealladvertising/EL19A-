/begin CHARACTERISTIC

    EGRVlv_HBrgPar.tiDisblDiaTmpDef_C
    "Parmeter structure for H-Bridge Diagnosis / Diagnosis disable time in case of temporary error /heal of ShCirBatt1 / ShCirBatt2 / ShCirGnd1 / ShCirGnd2 / ShCirOvrLd / OvrTemp error."
    VALUE
    0x8006C544
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_HBrgPar.tiDisblDiaPermDef_C
    "Parmeter structure for H-Bridge Diagnosis / Diagnosis disable time in case of permanent ShCirBatt1 / ShCirBatt2 / ShCirGnd1 / ShCirGnd2 / ShCirOvrLd / OvrTemp errors."
    VALUE
    0x8006C546
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_HBrgPar.tiOpnLdDiaEna_C
    "Parmeter structure for H-Bridge Diagnosis / Open load diagnosis enable time"
    VALUE
    0x8006C548
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_HBrgPar.tiMaxOpnLdDiaEna_C
    "Parmeter structure for H-Bridge Diagnosis / Maximum open load diagnosis enable time"
    VALUE
    0x8006C54A
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_HBrgPar.rDtyCycPlausShCirGnd_C
    "Parmeter structure for H-Bridge Diagnosis / Duty cycle during plausibility test due to permanent ShCirGnd1/ShCirGnd2 error."
    VALUE
    0x8006C54C
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_HBrgPar.rDtyCycPlausShCirBatt_C
    "Parmeter structure for H-Bridge Diagnosis / Duty cycle during plausibility test due to permanent ShCirBatt1/ShCirBatt2 error"
    VALUE
    0x8006C54E
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_Pwm.tiPer_C
    "Structure containing calibration and conversion data types for EGR valve / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x8006C550
    Kw_Ws16
    6553.500
    Period
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_Pwm.stLvl_C
    "Structure containing calibration and conversion data types for EGR valve / Reference value for phase relationship in period units"
    VALUE
    0x8006C552
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_Pwm.rMaxDty_C
    "Structure containing calibration and conversion data types for EGR valve / Reference value for maximum duty cycle"
    VALUE
    0x8006C554
    Kw_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_Pwm.rPerUn_C
    "Structure containing calibration and conversion data types for EGR valve / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x8006C556
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_Pwm.tiPh_C
    "Structure containing calibration and conversion data types for EGR valve / Active level (0 or 1)"
    VALUE
    0x8006C558
    Kw_Ws16
    6553.500
    Period
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_PwmOut.rMin_C
    "Structure containing parameters for PWM output power stage error handling for EGR valve actuator / Minimum threshold for the duty cycle"
    VALUE
    0x8006C55A
    Kw_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_PwmOut.rMax_C
    "Structure containing parameters for PWM output power stage error handling for EGR valve actuator / Maximum threshold for the duty cycle"
    VALUE
    0x8006C55C
    Kw_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_PwmOut.tiBtwTstSCB_C
    "Structure containing parameters for PWM output power stage error handling for EGR valve actuator / Time between tests for SCB error"
    VALUE
    0x8006C55E
    Kw_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_PwmOut.tiBtwTstOT_C
    "Structure containing parameters for PWM output power stage error handling for EGR valve actuator / Time between tests for OT error"
    VALUE
    0x8006C560
    Kw_Ws16
    655.3500
    Time_s
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_PwmOut.numTstMax_C
    "Structure containing parameters for PWM output power stage error handling for EGR valve actuator / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006C562
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_PwmOut.swtBattCor_C
    "Structure containing parameters for PWM output power stage error handling for EGR valve actuator / Switch to enable battery correction"
    VALUE
    0x8006C564
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_PwmOut.swtPsInv_C
    "Structure containing parameters for PWM output power stage error handling for EGR valve actuator / Power stage output inversion status"
    VALUE
    0x8006C565
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_rCnv_MAP
    "Transformation curve to convert set point value to duty cycle."
    MAP
    0x8006C566
    Map_Xs16Ys16Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EGRVlv_rEGR
        Prc
        16
        -400.0000
        399.9878

        FORMAT "%8.4"
        EXTENDED_LIMITS -400.0000 399.9878
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        16
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_rOutDfl_C
    "Default value."
    VALUE
    0x8006C7AA
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_stPwrStgDiaDis_C
    "Mask to select power stage diagnosis disable conditions."
    VALUE
    0x8006C7AC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_stPwrStgDis_C
    "Mask to select power stage disable conditions"
    VALUE
    0x8006C7AD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_swtChpSel_C
    "Switch to select the configured Chip for the PWM output signal."
    VALUE
    0x8006C7AE
    Val_Wu8
    3.00000000000
    DevLib_HBrgChpSel
    0.00
    3.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 3.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_swtHwSel_C
    "Switch to select between CJ945/TLE6244 and CJ230/TLE7209 power stages."
    VALUE
    0x8006C7AF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_swtLMSPwrStgOn_C
    "Switch to keep the power stage ON even when LMS is detected."
    VALUE
    0x8006C7B0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_swtOpnLdDiaStrt_C
    "Switch to diagnose for Open load at the start"
    VALUE
    0x8006C7B1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_swtSelOvrCurrErr_C
    "Switch to select Over Current Error detection"
    VALUE
    0x8006C7B2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EGRVlv_tiBattCorFacFlt_C
    "Time constant for the battery voltage correction filter."
    VALUE
    0x8006C7B4
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EngDa_tiEngOffInit_C
    ""
    VALUE
    0x80074700
    Val_Ws16
    32766.00
    TimeEngOn
    1.000000
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EngDa_tiEngOff_C
    ""
    VALUE
    0x80072EE6
    Val_Ws16
    65535.00
    TimeEngOn
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EnvP_pTransf_CUR
    ""
    CURVE
    0x8006BE8E
    Cur_Xs16Ws16
    20000.00
    Pres_hPa
    0.00
    20000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EnvP_uRaw_mp
        Volt
        25
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EnvP_SRC.uMin_C
    " / Threshold for SRC -Min detection"
    VALUE
    0x8006BEF4
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EnvP_SRC.uMax_C
    " / Threshold for SRC -Max detection"
    VALUE
    0x8006BEF6
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EnvT_t_C
    ""
    VALUE
    0x80072EE8
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_facSegTimeAcc_CUR
    "factor to detect an acceleration after testinjection"
    CURVE
    0x8006C944
    Cur_Xs16Ws16
    5.000000
    EpmBCa_FacTstInj
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        3
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_facSegTimeConstHigh_C
    "upper limit to detect a constant enginge speed"
    VALUE
    0x8006C952
    Val_Ws16
    5.000000
    EpmBCa_FacTstInj
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_facSegTimeConstLow_C
    "lower limit to detect a constant enginge speed"
    VALUE
    0x8006C954
    Val_Ws16
    5.000000
    EpmBCa_FacTstInj
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_nTstInjMax_C
    "maximum engine-speed at which testinjections are allowed"
    VALUE
    0x8006C956
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_numInjSer_C
    "number of testinjections in series"
    VALUE
    0x8006C958
    Val_Wu8
    9.000
    OneToOne
    1.000
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_numTstInjMax_C
    "maximum numbers of testinjections"
    VALUE
    0x8006C95A
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_phiSegEndOld_C
    "end of old segment (segment which is not accelerated from a testinjection) - over this segment the time is read from the crankshaft-buffer"
    VALUE
    0x8006C95C
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCa_phiSegLen_C
    "segmentlength which is used to get the segmenttime from the crankshaftbuffer for detecting an acceleration"
    VALUE
    0x8006C95E
    Val_Ws16
    189.9976
    AngleCrS
    9.997559
    199.9951

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin AXIS_PTS

    EpmBCr_nEng_DST
    "Distribution for plausibilisation-curves of a n+1-camshaft-flywheel during backup crankshaft"
    0x8006C964
    Epm_nEng
    Axis_Xs16
    32767.50
    EngN
    5
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    EpmBCr_numSegTeeth_C
    "number of segment teeth on a n+1-camshaft-wheel (normally n)"
    VALUE
    0x8006C970
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_phiSync2Seg_C
    "angle between a sync- and seg-tooth"
    VALUE
    0x8006C972
    Val_Ws16
    360.0000
    AngleCrS
    -180.0000
    180.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_phiTimeoutInt_C
    "angle until a timeout-interrupt occurs if the engine is deaccelerated"
    VALUE
    0x8006C960
    Val_Ws16
    360.0000
    AngleCrS
    0.00
    360.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_phiZero2Sync_CA
    "angle from 0°-position to the sync-mark of the camshaft-wheel"
    VAL_BLK
    0x8006C99E
    ValA_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_rSeg2SegMax_GCUR
    "upper plaus-curve for the ratio between 2 segment-teeth"
    CURVE
    0x8006C974
    CurG_Ws16
    20.00000
    Fact100
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        5
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF EpmBCr_nEng_DST

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_rSeg2SegMin_GCUR
    "lower plaus-curve for the ratio between 2 segment-teeth"
    CURVE
    0x8006C97E
    CurG_Ws16
    20.00000
    Fact100
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        5
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF EpmBCr_nEng_DST

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_rSeg2SyncMax_GCUR
    "upper plaus-curve for the ratio between segment- and sync-teeth"
    CURVE
    0x8006C988
    CurG_Ws16
    20.00000
    Fact100
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        5
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF EpmBCr_nEng_DST

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_rSeg2SyncMin_GCUR
    "lower plaus-curve for the ratio between segment- and sync-teeth"
    CURVE
    0x8006C992
    CurG_Ws16
    20.00000
    Fact100
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        5
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF EpmBCr_nEng_DST

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_stActEdge_C
    "type of camshaft edge (falling, rising, both), that will evaluate in backup camshaft mode"
    VALUE
    0x8006C99C
    Val_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmBCr_swtEnable_C
    "Enable Backup without Crankshaft"
    VALUE
    0x8006C962
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_dSegSeries_CA
    "series of camshaft segments"
    VAL_BLK
    0x8006C9C8
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_facAdapFil_C
    "filterfactor for the camshaft adaption"
    VALUE
    0x8006C9A4
    Val_Ws32
    1.00000000000
    EpmCaS_Fac_Adap
    0.00
    1.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS -2147483.64800 2147483.64700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_facPlausHigh_GCUR
    "factor for the upper limit of the plaus-check of the camshaft-signals"
    CURVE
    0x8006C9D2
    CurG_Ws16
    65.53500
    EpmCaS_Fac_Plaus
    -32.76800
    32.76700

    FORMAT "%8.5"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        3
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF EpmCaS_facPlaus_DST

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_facPlausLow_GCUR
    "factor for the lower limit of the plaus-check of the camshaft-signals"
    CURVE
    0x8006C9D8
    CurG_Ws16
    65.53500
    EpmCaS_Fac_Plaus
    -32.76800
    32.76700

    FORMAT "%8.5"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        3
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF EpmCaS_facPlaus_DST

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin AXIS_PTS

    EpmCaS_facPlaus_DST
    "Distribution values for the camshaft-signal plausibilisation"
    0x8006C9DE
    Epm_nEng
    Axis_Xs16
    32767.50
    EngN
    3
    -16384.00
    16383.50

    
    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    EpmCaS_numEdgeTol_C
    "Number of tolerated camshaft edge failures for camshaft diagnosis and offset angle calculation"
    VALUE
    0x8006C9B0
    Val_Wu8
    30.00
    OneToOne
    0.00
    30.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_numErrSigDef_C
    "Limit of the debounce counter for recognizing a defect when camshaft disturbance occurs"
    VALUE
    0x8006C9B2
    Val_Wu16
    99.98333
    CrSRev2CrSInc
    0.01666667
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 1092.250
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_numErrSigOk_C
    "Limit of the debounce counter for healing a recognized camshaft disturbance"
    VALUE
    0x8006C9B4
    Val_Wu16
    99.98333
    CrSRev2CrSInc
    0.01666667
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 1092.250
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_numNoSigDef_C
    "Limit for debounce counter to recognize the loss of a camshaft signal"
    VALUE
    0x8006C9B6
    Val_Wu16
    99.98333
    CrSRev2CrSInc
    0.01666667
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 1092.250
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_numOfsErr_C
    "number of camshaft revolution until fault path DFC_EpmCaS..OfsErr will set"
    VALUE
    0x8006C9BC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_numSegSerLst_C
    "index of last segmment in EpmCaS_dSegSeries"
    VALUE
    0x8006C9E6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiDiffAdapMax_C
    "maximum angle-difference between real and adapted angle - adaption is running until this angle is reached"
    VALUE
    0x8006C9A8
    Val_Ws16
    5.998535
    AngleCrS
    0.00
    5.998535

    FORMAT "%8.6"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiDiffLim_C
    "maximum angle-difference between real and adapted angle during adaption"
    VALUE
    0x8006C9AA
    Val_Ws16
    50.00977
    AngleCrS
    0.00
    50.00977

    FORMAT "%8.5"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiMntMax_C
    "Maximum twist of the installation position of the camshaft up to which the neutral point of the angle offset diagnosis is shifted."
    VALUE
    0x8006C9AC
    Val_Ws16
    360.0000
    AngleCrS
    0.00
    360.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiNCor_CUR
    "engine-speed dependent angle-correction-value of the camshaft-signal"
    CURVE
    0x8006C9E8
    Cur_Xs16Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        6
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiOfsMax_C
    "max. tolerated angle offset between camshaft and crankshaft"
    VALUE
    0x8006C9BE
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiOfsMin_C
    "min. tolerated offset between camshaft and crankshaft"
    VALUE
    0x8006C9C0
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiOfsTolc_C
    "tolerance of a camshaft edge to calculate the camshaft offset"
    VALUE
    0x8006C9C2
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiSegLenTol_CA
    "tolerance of each segment length"
    VAL_BLK
    0x8006CA02
    ValA_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiSegLen_CA
    "length of camshaft segments"
    VAL_BLK
    0x8006CA16
    ValA_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    
    NUMBER 10

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_phiSegOfs_CA
    "angle between physical zeroposition and start of EpmCaS_dSegSeries_C"
    VAL_BLK
    0x8006CA2A
    ValA_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin AXIS_PTS

    EpmCaS_phiTempCor05_DST
    "distribution for camshaft angle correction depending on temperature"
    0x8006CA2C
    EngDa_tEng
    Axis_Xs16
    6553.500
    Temp_Cels
    3
    -3549.940
    3003.560

    
    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    EpmCaS_phiTempCorI1_GCUR
    "angle correction for first inletcamshaft depending on temperature distribution"
    CURVE
    0x8006CA34
    CurG_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        EngDa_tEng
        Temp_Cels
        3
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560

        AXIS_PTS_REF EpmCaS_phiTempCor05_DST

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_stActEdge_C
    "type of camshaft edges to be detected"
    VALUE
    0x8006CA3A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_stDiagMode_C
    "Disable the camshaft diagnosis in EPM_MODE_OK if a camshaft fault is already detected."
    VALUE
    0x8006C9B8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_stOfsDiagMode_C
    "Disable of camshaft offset in EPM_MODE_OK"
    VALUE
    0x8006C9C4
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_swtForceRefAdap_C
    "Trigger for reference adaptation and check of the installation position of the camshaft"
    VALUE
    0x8006C9AE
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_swtMeasCaS_C
    "Switch for measuring the camshaft raw values"
    VALUE
    0x8006C9BA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_tiGlitchFilter_C
    "filtertime for the camshaft signal"
    VALUE
    0x8006CA3C
    Val_Ws32
    4294967295.00
    OneToOne_us
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_tiOfsPT1_C
    "time factor for filtering camshaft offset"
    VALUE
    0x8006C9C6
    Val_Wu16
    4294901.7590
    TimeDelay_ms
    65.537000015
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 65.537000015 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCaS_tiTimeout_C
    "after the last camshaftedge the system waits this time and then the valid time entries in the camshaftbuffer are cleared"
    VALUE
    0x8006CA40
    Val_Ws32
    42949672950.0
    Time_ms
    -21474836480.0
    21474836470.0

    FORMAT "%13.1"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_dnEngMax_C
    "max. engine deceleration to calculate the diagnosis for a disturbances of the crankshaft signal"
    VALUE
    0x8006CA44
    Val_Ws16
    32767.00
    EngNGrd
    -16383.50
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_facGapCrit1_C
    "factor for gap criteria one"
    VALUE
    0x8006CA58
    Val_Wu8
    15.94
    EPM_FAC_PLAUS
    0.00
    15.94

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 15.94
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_facGapCrit2_C
    "factor for gap criteria two"
    VALUE
    0x8006CA59
    Val_Wu8
    15.94
    EPM_FAC_PLAUS
    0.00
    15.94

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 15.94
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_facGapPlausHigh_CA
    "ratio to calculate the upper limit of the gap plausibility check of increment signal"
    VAL_BLK
    0x8006CA5A
    ValA_Wu8
    15.94
    EPM_FAC_PLAUS
    0.00
    15.94

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 15.94
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_facIncPlausHigh_CA
    "factor crankshaft signal plausibility check high"
    VAL_BLK
    0x8006CA5E
    ValA_Wu8
    15.94
    EPM_FAC_PLAUS
    0.00
    15.94

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 15.94
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_facIncPlausLow_CA
    "factor crankshaft signal plausibility check low"
    VAL_BLK
    0x8006CA62
    ValA_Wu8
    15.94
    EPM_FAC_PLAUS
    0.00
    15.94

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 15.94
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_facScale_C
    "TTMeasure - resolution of measured tooth time"
    VALUE
    0x8006CAA0
    Val_Wu8
    10.00
    OneToOne
    0.00
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_nDiagOff_C
    "engine speed threshold to switch off the crankshaft diagnosis"
    VALUE
    0x8006CA46
    Val_Ws16
    8000.000
    EngN
    0.00
    8000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_nDiagOn_C
    "Engine speed to switch on the crankshaft diagnosis"
    VALUE
    0x8006CA48
    Val_Ws16
    8000.000
    EngN
    0.00
    8000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_nFacScale_C
    "TTMeasure - engine speed threshold to switch the resolution of measured tooth time"
    VALUE
    0x8006CAA2
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_nMaxInc_C
    "max speed for one increment period"
    VALUE
    0x8006CA66
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_nMinInc_C
    "min speed for one one increment period"
    VALUE
    0x8006CA68
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_nThreshRange_CA
    "array of speed thresholds for dynamic plaus"
    VAL_BLK
    0x8006CA6C
    ValA_Ws32
    16319.868465052328
    EngN2tiIncPer
    19.999999000000049
    16339.868464052328

    FORMAT "%19.13"
    EXTENDED_LIMITS 0.001164153160604 2499999.8750000061
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_nTiIncPerAvrg_CA
    "engine speed thresholds to set the number of crankshaft teeth to calculate the average for one tooth time"
    VAL_BLK
    0x8006CA7C
    ValA_Ws16
    16363.00
    EngN
    20.00000
    16383.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_numErrSigGlitMax_C
    "threshold for glitch error entry on crankshaft"
    VALUE
    0x8006CA4A
    Val_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_numErrSigIncDef_C
    "step wide defect debouncing crankshaft disturbance"
    VALUE
    0x8006CA4C
    Val_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_numErrSigMaxDef_C
    "max. number of disturbance until fault report crankshaft disturbance"
    VALUE
    0x8006CA4E
    Val_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_numErrSigMinOK_C
    "min. number of plausible crankshaft revolutions until healing"
    VALUE
    0x8006CA50
    Val_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_numIgnInc_C
    "number of teeth to supress crankshaft signal"
    VALUE
    0x8006CA84
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_numNoSigDef_C
    "number of camshaft revolutions until fault report ""no crankshaft signal"""
    VALUE
    0x8006CA52
    Val_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_numTiIncPerAvrg_CA
    "number of crankshaft teeth to calculate average of tooth time"
    VAL_BLK
    0x8006CA85
    ValA_Wu8
    50.00
    OneToOne
    0.00
    50.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_stDiagT50Reset_C
    "usage of terminal 50 information for crankshaft diagnosis"
    VALUE
    0x8006CA54
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_stTTMeasureOn_C
    "TTMeasure - switch on (=1) of tooth time measure function"
    VALUE
    0x8006CAA4
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_swtEnableDiag_C
    "Switch off crankshaft diagnosis"
    VALUE
    0x8006CA55
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_swtIncSrc_C
    "TTMeasure - raw valuese or by TAA corrected values"
    VALUE
    0x8006CAA5
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_tiGlitchFilter_CA
    "glitch filter time crankshaft signal"
    VAL_BLK
    0x8006CA8C
    ValA_Ws32
    100000.000000
    OneToOne_us
    0.00
    100000.000000

    FORMAT "%13.6"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmCrS_tiIgnSig_C
    "time to supress the crankshaft signal"
    VALUE
    0x8006CA9C
    Val_Ws32
    100000.000000
    OneToOne_ms
    0.00
    100000.000000

    FORMAT "%13.6"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_cylfrstGap_C
    ""
    VALUE
    0x8006CB00
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_cylscndGap_C
    ""
    VALUE
    0x8006CB01
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_numIntfrstGap_C
    ""
    VALUE
    0x8006CB02
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_numIntscndGap_C
    ""
    VALUE
    0x8006CB03
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_phiGap_C
    ""
    VALUE
    0x8006CB04
    Val_Ws32
    720.000000000
    AngleCrS
    0.00
    720.000000000

    FORMAT "%13.9"
    EXTENDED_LIMITS -47185920.0000 47185919.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_swtIAPDvtCorEna_C
    "switch deviation correction algorithm for increment angle prediction enabled"
    VALUE
    0x8006CAA6
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_swtIAPEna_C
    "switch increment angle prediction enabled"
    VALUE
    0x8006CAA7
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmHCrS_swtIASEna_C
    "switch increment angle prediction enabled"
    VALUE
    0x8006CAA8
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSeq_nMaxStrtInt_C
    "max engine speed to perform a start interrupt"
    VALUE
    0x8006CAAA
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSeq_phiDelayMax_C
    "maximum angle which a interrupt is allowed to be delayed during start"
    VALUE
    0x8006CAAC
    Val_Ws16
    180.0000
    AngleCrS
    0.00
    180.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSeq_phiIntBCr_CA
    "interrupt position before TDC during backup crankshaft"
    VAL_BLK
    0x8006CAAE
    ValA_Ws16
    719.9780
    AngleCrS
    0.00
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSeq_phiInt_CA
    "interrupt position related to TDC"
    VAL_BLK
    0x8006CAB2
    ValA_Ws16
    719.9780
    AngleCrS
    0.00
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSeq_phiStrtInt_CA
    "interrupt position related to TDC during start"
    VAL_BLK
    0x8006CAB6
    ValA_Ws16
    719.9780
    AngleCrS
    0.00
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    
    NUMBER 2

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSeq_phiSyncInt_C
    "position of first interrupt for synchronisation at a defined angle"
    VALUE
    0x8006CABA
    Val_Ws16
    719.9780
    AngleCrS
    0.00
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSeq_swtInt_C
    "switch to activate/deactivate functionality of the sequence-manager"
    VALUE
    0x8006CABC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSrv_numTDCMIAPStrt_C
    "Number of TDC's for the MIAP (Multiple Increment Angle Prediction) after engine start"
    VALUE
    0x8006CABE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSrv_numTDCMIAP_C
    "Number of TDC's for the MIAP (Multiple Increment Angle Prediction)"
    VALUE
    0x8006CABF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSyn_dCaSSegMsk_C
    "mask valid information in EpmCaS_dSegSeries_C"
    VALUE
    0x8006CAC0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSyn_dTrigMsk_C
    "trigger mask for temporary segment detection"
    VALUE
    0x8006CAC1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSyn_dTrigRslt_C
    "trigger result for temporary segment detection"
    VALUE
    0x8006CAC2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSyn_phiIncCor_CUR
    "Engine speed depending angle error of crankshaft signal"
    CURVE
    0x8006CAC6
    Cur_Xs16Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        4
        -16384.00
        16383.50

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSyn_phiRRMax_C
    "max. offset angle to detcet a reverse running engine"
    VALUE
    0x8006CAD8
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    EpmSyn_phiTrig_C
    "trigger angle for temporary segment detection"
    VALUE
    0x8006CAC4
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_nNoSyncVerify_C
    "No synchronization during verifikation of phase position"
    VALUE
    0x8006CAF4
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_numConf_CA
    "Actual state of the EPM configuration"
    VAL_BLK
    0x8006CADC
    ValA_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    READ_ONLY
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_numCyl_C
    "Actual number of cylinder"
    VALUE
    0x8006CAE8
    Val_Wu8
    5.000
    OneToOne
    1.000
    6.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_numFireSeg_C
    "firing sequence of the engine"
    VAL_BLK
    0x8006CAE9
    ValA_Wu8
    5.000
    OneToOne
    1.000
    6.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_numReSync_C
    "number of the allowed synchronization cycles"
    VALUE
    0x8006CAF6
    Val_Wu8
    100.0
    OneToOne
    0.00
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_phiGap2Zero_C
    "angle between crankshaft signal gap and zero of angle system in ECU"
    VALUE
    0x8006CAF0
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_phiTdc1_C
    "position of first TDC related to zero of angle system"
    VALUE
    0x8006CAF2
    Val_Ws16
    719.9780
    AngleCrS
    0.00
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_swtBlkInjCaSSync_C
    "no synchronization before gap of crankshaft"
    VALUE
    0x8006CAF7
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_swtOpModeStgy_C
    "If bit 0 is set, the EPM operation mode remains in verification, until the camshaft offset diagnosis delivers a vlaid result."
    VALUE
    0x8006CAF8
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_tiSpd2Zero_C
    "time until engine speed will set to zero"
    VALUE
    0x8006CAFA
    Val_Wu16
    655350.0
    Time_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Epm_tiSpdGrdFlt_C
    "Filtertime for PT1-Filtermodule to calculate filtered enginespeed-gradient"
    VALUE
    0x8006CAFC
    Val_Ws32
    998.99238550
    TimeDelay_ms
    1.0000000689
    999.99238556

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_ASD_CA
    "Limit condition for angle synchronous calculations in ASD-Container"
    VAL_BLK
    0x8006C7B8
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_Common_CA
    "Limit condition for angle synchronous calculations in common-container"
    VAL_BLK
    0x8006C7BB
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_CPP_CA
    "Limit condition for angle synchronous calculations in CPP-Container"
    VAL_BLK
    0x8006C7BE
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_FBC_CA
    "Limit condition for angle synchronous calculations in FBC-container"
    VAL_BLK
    0x8006C7C1
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_Joint_CA
    "Limit condition for angle synchronous calculations in Joint-container"
    VAL_BLK
    0x8006C7C4
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_LiGov_CA
    "Limit condition for angle synchronous calculations in LiGov-container"
    VAL_BLK
    0x8006C7C7
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_Post_CA
    "Limit condition for angle synchronous calculations in SyncPost-container"
    VAL_BLK
    0x8006C7CA
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_Pre_CA
    "Limit condition for angle synchronous calculations in SyncPre-container"
    VAL_BLK
    0x8006C7CD
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_PSC_CA
    "Limit condition for angle synchronous calculations in PSC-Container"
    VAL_BLK
    0x8006C7D0
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_S0_A_CA
    "Limit condition for angle synchronous calculations in S0_A-container"
    VAL_BLK
    0x8006C7D3
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_S0_B_CA
    "Limit condition for angle synchronous calculations in S0_B-container"
    VAL_BLK
    0x8006C7D6
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_S0_Rmt_CA
    "Limit condition for angle synchronous calculations in S0-Remote Container"
    VAL_BLK
    0x8006C7D9
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_S1_A_CA
    "Limit condition for angle synchronous calculations in S1_A-container"
    VAL_BLK
    0x8006C7DC
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_S1_B_CA
    "Limit condition for angle synchronous calculations in S1_B-container"
    VAL_BLK
    0x8006C7DF
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_S1_Rmt_CA
    "Limit condition for angle synchronous calculations in S1-Remote Container"
    VAL_BLK
    0x8006C7E2
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_UnitInjector_CA
    "Limit condition for angle synchronous calculations in UnitInjector-container"
    VAL_BLK
    0x8006C7E5
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_dLimCond_Update_CA
    "Limit condition for angle synchronous calculations in Update-container"
    VAL_BLK
    0x8006C7E8
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_nLimInj_C
    "engine speed threshold to switch between Sx_A and Sx_B container"
    VALUE
    0x8006C7EC
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_nLimThreshHyst_CA
    "engine speed hysteresis to switch the limit conditions"
    VAL_BLK
    0x8006C7EE
    ValA_Wu16
    600.0000
    EngN
    0.00
    600.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 32767.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_nLimThresh_CA
    "engine speed thresholds to switch the limit conditions"
    VAL_BLK
    0x8006C7F4
    ValA_Wu16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 32767.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_numLimInj_C
    "number how often Sx_B container will akivated, before Sx_A container will activated again"
    VALUE
    0x8006C7FA
    Val_Wu8
    254.0
    OneToOne
    1.000
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ESC_stS1FrstSched_C
    "angle synchronous scheduling starts always with a S1 Task (calculation of PILOT injections)"
    VALUE
    0x8006C7FC
    Val_Wu8
    2.00000000000
    ESC_stS1FrstSched_t
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_ctDflLrnAllw_CA
    "Default value for the number of calibration cycles allowed per rail pressure calibration point"
    VAL_BLK
    0x8006C8EC
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_ctDflLrn_CA
    "Default values for the applicative change in the learning cycle counter of the energizing time calibration for ZFC"
    VAL_BLK
    0x8006C8F0
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_ctLrnPerDelta_C
    "Number of learning cycles released per driving distance interval"
    VALUE
    0x8006C8F6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_ctLrnThresQck_C
    "Number of learning cycles for the release of energizing time correction by energizing time calibration in quick calibration"
    VALUE
    0x8006C7FE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_ctLrnThresQIS_C
    "Number of learning cycles for energizing time calibration quick initial search"
    VALUE
    0x8006C800
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_ctLrnThresRC_C
    "Number of learning cycles for the release of energizing time correction in roller dynamometer calibration"
    VALUE
    0x8006C802
    Val_Wu16
    10.00000
    OneToOne
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_ctLrnThres_C
    "Number of learning cycles for the release of energizing time correction by energizing time calibration"
    VALUE
    0x8006C804
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_dpRailLim_CA
    "Maximum rail pressure deviation for ZFC based on the rail pressure calibration point"
    VAL_BLK
    0x8006C806
    ValA_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_dtiDflETFlt0_CA
    "Default values for the filtered energizing time difference of the energizing time calibration for a rail pressure calibration point 0"
    VAL_BLK
    0x8006C8F8
    ValA_Ws16
    1200.000
    InjTimeHiRes_us
    -200.0000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -1638.400 1638.350
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_dtiDflETFlt1_CA
    "Default values for the filtered energizing time difference of the energizing time calibration for a rail pressure calibration point 1"
    VAL_BLK
    0x8006C904
    ValA_Ws16
    1200.000
    InjTimeHiRes_us
    -200.0000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -1638.400 1638.350
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_dtiDflETFlt2_CA
    "Default values for the filtered energizing time difference of the energizing time calibration for a rail pressure calibration point 2"
    VAL_BLK
    0x8006C910
    ValA_Ws16
    1200.000
    InjTimeHiRes_us
    -200.0000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -1638.400 1638.350
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_facFltQck_C
    "Filter constant for the energizing time difference of the energizing time calibration in quick calibration"
    VALUE
    0x8006C80C
    Val_Wu16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 7.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_facFltRC_C
    "Filter constant for the energizing time difference of the energizing time calibration in roller dynamometer calibration"
    VALUE
    0x8006C80E
    Val_Wu16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 7.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_facFlt_C
    "Filter constant for the energizing time difference of energizing time calibration"
    VALUE
    0x8006C810
    Val_Wu16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 7.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_lDelta_C
    "Tolerance for comparing driving distances covered for limiting the learning frequency"
    VALUE
    0x8006C91C
    Val_Ws16
    990.0000
    Length
    10.00000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_lLrnDelta_C
    "Length of the driving distance interval for limiting the learning frequency"
    VALUE
    0x8006C920
    Val_Ws32
    19872000.0000
    Length
    128000.000000
    20000000.0000

    FORMAT "%13.4"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_numCyclMeas_C
    "Number of injection cycles for measuring the energizing time calibration"
    VALUE
    0x8006C812
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_numCyclNoDyn_C
    "Number of injection cycles until the energizing time calibration checks the maximum increase in the engine speed"
    VALUE
    0x8006C814
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_numCyclStartEnergize_C
    "Number of injection cycles until the energizing time calibration is stabilised for the measuring"
    VALUE
    0x8006C816
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_numDflCylCur_CA
    "Test value for the current cylinder of the energizing time calibration for each rail pressure calibration point"
    VAL_BLK
    0x8006C924
    ValA_Wu8
    5.000
    OneToOne
    1.000
    6.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_pRailSet_CA
    "Rail pressure calibration points for energizing time calibration"
    VAL_BLK
    0x8006C818
    ValA_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_qThresPCL_CA
    "PCL quantity threshold of energizing time calibration"
    VAL_BLK
    0x8006C81E
    ValA_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_SigThres_CA
    "ZFC signal threshold based on the rail pressure calibration point"
    VAL_BLK
    0x8006C824
    ValA_Ws16
    200.0000
    OneToOne
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -32768.00 32767.00
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRCClbActv_ATS.LimitTypeMsk_C
    "Actuator test ETClb_stRCClbActv_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BD98
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRCClbActv_ATS.CnvNorm_C
    "Actuator test ETClb_stRCClbActv_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BD99
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRCClbActv_ATS.LowLim_C
    "Actuator test ETClb_stRCClbActv_ATS / Lower limit for monitoring"
    VALUE
    0x8006BD9A
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRCClbActv_ATS.UpLim_C
    "Actuator test ETClb_stRCClbActv_ATS / Upper limit for monitoring"
    VALUE
    0x8006BD9C
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRCClbActv_ATS.CnvFac_C
    "Actuator test ETClb_stRCClbActv_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BDA0
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRCClbActv_ATS.CnvOfs_C
    "Actuator test ETClb_stRCClbActv_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BDA4
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRCClbActv_ATS.DfltVal_C
    "Actuator test ETClb_stRCClbActv_ATS / Default value for standbytest"
    VALUE
    0x8006BDA6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_stRlsCylCorDfl_C
    "Default value for the cylinder specific correction release"
    VALUE
    0x8006C927
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_swtDflLimClbFrq_C
    "Switch for writing the default values for the learning frequency limiting function"
    VALUE
    0x8006C928
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_swtDflQckClb_C
    "Test value for switching over to the quick calibration of the energizing time calibration"
    VALUE
    0x8006C929
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_swtLimClbFrqOff_C
    "Switch for switching the learning frequency limitation OFF (1 = OFF)"
    VALUE
    0x8006C92A
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_swtQckClbActv_C
    "Switch to enable quick calibration by default till enabling the ETClb correction"
    VALUE
    0x8006C82A
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_swtWrDflVal_C
    "Activation for writing the test values for the energizing time calibration when switching from 0 to 1"
    VALUE
    0x8006C82B
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiBstPresCorr0_CUR
    "Correction over boost pressure for the ETClb energizing time in rail pressure point 0"
    CURVE
    0x8006C82C
    Cur_Xs16Ws16
    1000.000
    InjTime_us
    -500.0000
    500.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_pCACDs
        Pres_hPa
        12
        600.0000
        1200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiBstPresCorr1_CUR
    "Correction over boost pressure for the ETClb energizing time in rail pressure point 1"
    CURVE
    0x8006C85E
    Cur_Xs16Ws16
    1000.000
    InjTime_us
    -500.0000
    500.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_pCACDs
        Pres_hPa
        12
        600.0000
        1200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiBstPresCorr2_CUR
    "Correction over boost pressure for the ETClb energizing time in rail pressure point 2"
    CURVE
    0x8006C890
    Cur_Xs16Ws16
    1000.000
    InjTime_us
    -500.0000
    500.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_pCACDs
        Pres_hPa
        12
        600.0000
        1200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiDflETCur_CA
    "Test value of the current energizing time for the energizing time calibration at each rail pressure calibration point"
    VAL_BLK
    0x8006C92C
    ValA_Ws16
    850.0000
    InjTime_us
    150.0000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiETOfsMax_CA
    "Offset of the maximum filtered energizing time to the maximum energizing time for each rail pressure calibration point"
    VAL_BLK
    0x8006C932
    ValA_Ws16
    200.0000
    InjTime_us
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiETOfsMin_CA
    "Offset of the minimum filtered energizing time to the minimum energizing time for each rail pressure calibration point"
    VAL_BLK
    0x8006C938
    ValA_Ws16
    200.0000
    InjTime_us
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiETStepQIS_CA
    "Energizing time increment for increasing or decreasing the energizing time of the energizing time calibration while quick initial search is activ"
    VAL_BLK
    0x8006C8D4
    ValA_Ws16
    1000.000
    InjTime_us
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiETStep_CA
    "Energizing time increment for increasing or decreasing the energizing time of the energizing time calibration"
    VAL_BLK
    0x8006C8DA
    ValA_Ws16
    1000.000
    InjTime_us
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiET_MAX_CA
    "Maximum injection energizing time for the energizing time calibration for each rail pressure calibration point"
    VAL_BLK
    0x8006C8E0
    ValA_Ws16
    13106.80
    InjTime_us
    0.00
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_tiET_MIN_CA
    "Minimum injection energizing time for the energizing time calibration for each rail pressure calibration point"
    VAL_BLK
    0x8006C8E6
    ValA_Ws16
    13106.80
    InjTime_us
    0.00
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_volEffectiveMin_CA
    "Fuel quantity of the effective limit for the energizing time calibration"
    VAL_BLK
    0x8006C8C2
    ValA_Ws16
    100.0000
    InjQntInj
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_vStartClb_CA
    "Minimum vehicle speed for starting the energizing time calibration at each rail pressure calibration point"
    VAL_BLK
    0x8006C8C8
    ValA_Ws16
    200.0000
    Vel
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ETClb_vStopClb_CA
    "Minimum vehicle speed of the energizing time calibration at each rail pressure calibration point"
    VAL_BLK
    0x8006C8CE
    ValA_Ws16
    200.0000
    Vel
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Etc_MaxReqTO_C
    "Maximum time between 2 engine test requests. Value is applicated on 10ms time base (Value of 500 means 5s), but the smallest possible resolution is 100ms. Active tests will be stopped if this times has run out."
    VALUE
    0x8006CB08
    Val_Wu16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Exh_SRCPPFltUs.uMin_C
    " / Threshold for SRC -Min detection"
    VALUE
    0x8006C046
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Exh_SRCPPFltUs.uMax_C
    " / Threshold for SRC -Max detection"
    VALUE
    0x8006C048
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Exh_SRCPTrbnUs.uMin_C
    " / Threshold for SRC -Min detection"
    VALUE
    0x8006BF7A
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Exh_SRCPTrbnUs.uMax_C
    " / Threshold for SRC -Max detection"
    VALUE
    0x8006BF7C
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_ActESpP_C
    "=0: 'no engine speed preprocessing', =1: 'with engine speed preprocessing', =2: 'clear adapted values (EEPROM)'"
    VALUE
    0x8006CC28
    Val_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_BPFac.NumLo_CA
    "band pass coefficients / numerator for lower engine speed range"
    VAL_BLK
    0x8006CB0C
    ValA_Wr32
    30.0000000
    OneToOne
    -15.0000000
    15.0000000

    FORMAT "%10.7"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_BPFac.NumHi_CA
    "band pass coefficients / numerator for upper engine speed range"
    VAL_BLK
    0x8006CB18
    ValA_Wr32
    30.0000000
    OneToOne
    -15.0000000
    15.0000000

    FORMAT "%10.7"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_BPFac.Den1_CA
    "band pass coefficients / denominator 1"
    VAL_BLK
    0x8006CB24
    ValA_Wr32
    20.0000000
    OneToOne
    -10.0000000
    10.0000000

    FORMAT "%10.7"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_BPFac.Den2_CA
    "band pass coefficients / denominator 2"
    VAL_BLK
    0x8006CB30
    ValA_Wr32
    20.0000000
    OneToOne
    -10.0000000
    10.0000000

    FORMAT "%10.7"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_BPFac1NumG_CUR
    "transmission ratio dependent numerator (different band pass amplifications)"
    CURVE
    0x8006CB3C
    Cur_Xs16Ws16
    30.00092
    FBC_BPfac
    -15.00046
    15.00046

    FORMAT "%8.5"
    EXTENDED_LIMITS -60.00183 60.00000
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        PT_rTrq
        TransR
        10
        -15.00000
        15.00000

        FORMAT "%8.5"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_ctPhComp_C
    "compensation of dead time by scheduling FBC_qSet calculation. 0: no dead time, 1: one segment dead time (as for EDC16 master/slave)"
    VALUE
    0x8006CB66
    Val_Ws8
    4.000
    OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS -128.0 127.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_ctSegOffset_C
    "distance between FBC calculation and corresponding TDC"
    VALUE
    0x8006CB67
    Val_Ws8
    1.000
    OneToOne
    2.000
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS -128.0 127.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_ctTDCOfs_C
    "interval between TDC and main interrupt of corresponding injection"
    VALUE
    0x8006CB68
    Val_Ws8
    0.00
    OneToOne
    1.000
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS -128.0 127.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_dqThresSurge_C
    "threshold value to detect surge in fuel quantity demand"
    VALUE
    0x8006CB6A
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_dSegNhiCaS_CA
    "segment value for Epm_nEng > FBC_nThresFbc_C"
    VAL_BLK
    0x8006CB6C
    ValA_Wu16
    10.00000
    Per_Ratio
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 255.9961
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_dSegNloCaS_CA
    "segment value for Epm_nEng < FBC_nThresFbc_C"
    VAL_BLK
    0x8006CB72
    ValA_Wu16
    10.00000
    Per_Ratio
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS 0.00 255.9961
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_DSMUrgencyOffset_C
    "Offset of DSCHED priority in overrun condition."
    VALUE
    0x8006CC29
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_dSyn_C
    "Distance between TDC cyl. 1 to segment value 0 (CrSCD_numSeg)"
    VALUE
    0x8006CB78
    Val_Ws8
    1.000
    OneToOne
    1.000
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS -128.0 127.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_DXAdapLo_C
    "lower threshold of adaption quality"
    VALUE
    0x8006CC2A
    Val_Ws16
    0.7499933
    FBC_Dxs_s16
    0.00
    0.7499933

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.7812500 0.7812262
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_DXAdapUp_C
    "upper threshold of adaption quality"
    VALUE
    0x8006CC2C
    Val_Ws16
    0.7499933
    FBC_Dxs_s16
    0.00
    0.7499933

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.7812500 0.7812262
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_DXalf0_C
    "initial values for FBC_DXSfn, FBC_DXSfp"
    VALUE
    0x8006CC2E
    Val_Ws16
    0.7499933
    FBC_Dxs_s16
    0.00
    0.7499933

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.7812500 0.7812262
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_EnblCpy_C
    "Enables using learn values of adjacent regions while Learning has not yet converged."
    VALUE
    0x8006CC30
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_EnblIpo_C
    "Enable interpolation in speed regions between learning regions."
    VALUE
    0x8006CC31
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_facBPRedNum_C
    "factor by which the bandpass amplification is reduced when there are surges in fuel quantity demand"
    VALUE
    0x8006CB7C
    Val_Wr32
    1.00000000
    OneToOne
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_fSurge_CUR
    "transmission ratio dependent surge frequencies"
    CURVE
    0x8006CB80
    Cur_Xs16Ws16
    20.00000
    FBC_Surge_Frq
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -136.5333 136.5292
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        PT_rTrq
        TransR
        10
        0.00
        20.00000

        FORMAT "%8.5"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_GvrnI.Ki_C
    "I governor / coefficient of integrator"
    VALUE
    0x8006CBAC
    Val_Wr32
    1.00000000
    FBC_GvrnIKi_float
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_GvrnI.KiPos_C
    "I governor / coefficient of integrator"
    VALUE
    0x8006CBB0
    Val_Wr32
    1.00000000
    FBC_GvrnIKi_float
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_GvrnI.KiNeg_C
    "I governor / coefficient of integrator"
    VALUE
    0x8006CBB4
    Val_Wr32
    1.00000000
    FBC_GvrnIKi_float
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_GvrnI.WinPos_C
    "I governor / engine speed window"
    VALUE
    0x8006CBB8
    Val_Wr32
    12200.0000
    EngN_float
    -6100.00000
    6100.00000

    FORMAT "%10.5"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_GvrnI.WinNeg_C
    "I governor / engine speed window"
    VALUE
    0x8006CBBC
    Val_Wr32
    12200.0000
    EngN_float
    -6100.00000
    6100.00000

    FORMAT "%10.5"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_GvrnP.Kp_C
    "P governor / coefficient of proportional part"
    VALUE
    0x8006CBC0
    Val_Wr32
    1.00000000
    FBC_GvrnPKp_float
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nBrIpoRng_CA
    "Size of speed intervalls between learning regions."
    VAL_BLK
    0x8006CC32
    ValA_Ws16
    2000.000
    EngN
    0.00
    2000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nCtlOfsMin_C
    "Offset to 'LIGov_nSetpoint': Threshold for FBC open loop"
    VALUE
    0x8006CBD4
    Val_Ws16
    1000.000
    EngN
    -1000.000
    0.00

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nCtlThresMax_C
    "Speed-threshold for control"
    VALUE
    0x8006CBD6
    Val_Ws16
    6100.000
    EngN
    0.00
    6100.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nGvrnOfsMin_C
    "Offset to 'LIGov_nSetpoint': Threshold for FBC closed loop"
    VALUE
    0x8006CBD8
    Val_Ws16
    1000.000
    EngN
    -1000.000
    0.00

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nGvrnThresMax_C
    "Speed-threshold for govern"
    VALUE
    0x8006CBDA
    Val_Ws16
    6100.000
    EngN
    0.00
    6100.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nHyst_C
    "speed hysteresis"
    VALUE
    0x8006CBDC
    Val_Ws16
    100.0000
    EngN
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nLrnThres_CA
    "engine speed thresholds of learn regions of toothed wheel adaption"
    VAL_BLK
    0x8006CC34
    ValA_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nSurgeOffset_C
    "offset for critcal engine speed (fCas = fSurge)"
    VALUE
    0x8006CBDE
    Val_Ws16
    1000.000
    EngN
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_nThresFbc_C
    "engine speed threshold for segment and band pass values, maximum engine speed without learned toothed wheel adaption"
    VALUE
    0x8006CC3A
    Val_Ws16
    2000.000
    EngN
    0.00
    2000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_PrtnRmp_C
    "Speed intervall of interpolation of learn values to 0 (relative Portion normalized to FBC_nBrIpoRng_CA)."
    VALUE
    0x8006CC3C
    Val_Wr32
    0.500000000
    OneToOne
    0.00
    0.500000000

    FORMAT "%11.9"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qCtlOfsMax_C
    "offset for upper fuel quantity depending threshold for open-loop control"
    VALUE
    0x8006CBE0
    Val_Ws16
    10.00000
    InjMass
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qCtlThresMin_C
    "Quantity-threshold for control"
    VALUE
    0x8006CBE2
    Val_Ws16
    5.000000
    InjMass
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qGvrnThresMax_CUR
    "upper fuel quantity depending threshold for closed-loop control"
    CURVE
    0x8006CBE4
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        4
        0.00
        6100.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qGvrnThresMin_C
    "Quantity-threshold for govern"
    VALUE
    0x8006CBF6
    Val_Ws16
    5.000000
    InjMass
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qLimDia_C
    "correction quantity limitation while reading FBC correction quantities with diagnostic tester"
    VALUE
    0x8006CBF8
    Val_Ws16
    20.00000
    InjMass
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qLim_CUR
    "fuel quantity depending correction quantity limitation (for deactivation of FBC: all values to 0)"
    CURVE
    0x8006CBFA
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjCtl_qSetUnBal
        InjMass
        4
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qRCLim_C
    "limiting quantity for the additive correction quantities from FBC_qRC_CA"
    VALUE
    0x8006CC0C
    Val_Ws16
    5.000000
    InjMass
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_qRC_CA
    "cylinder individuell correction quantity for stimulation of FBC output quantity"
    VAL_BLK
    0x8006CC0E
    ValA_Ws16
    10.00000
    InjMass
    -5.000000
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_rGripThres_C
    "Threshold for detection of ""grip"""
    VALUE
    0x8006CC1A
    Val_Ws16
    1.000000
    TransR
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_stOpModeFrz_C
    "mask for current operation mode (freeze of output of FBC)"
    VALUE
    0x8006CC1C
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_stOpModeInhib_C
    "mask for current operation mode (initializing of output of FBC with zero)"
    VALUE
    0x8006CC20
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_swtInitI_C
    "initialization of I-component in case of transition to 'closed-loop control': '0' initialize with frozen values; '1' initialize with zero"
    VALUE
    0x8006CC24
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_swtRC_C
    "switch for activation of FBC_qRC_CA (1: 'activ'; 0: 'inactiv')"
    VALUE
    0x8006CC25
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_TFConst_C
    "filter coefficient of adaption filter"
    VALUE
    0x8006CC40
    Val_Wr32
    1.00000000
    OneToOne
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_TFLrnConst_C
    "filter coefficient of evaluation filter"
    VALUE
    0x8006CC44
    Val_Wr32
    1.00000000
    OneToOne
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FBC_ThresDyn_C
    "threshold for engine speed dynamic to deactivate adaption"
    VALUE
    0x8006CC48
    Val_Wr32
    1.00000000
    OneToOne
    0.00
    1.00000000

    FORMAT "%10.8"
    EXTENDED_LIMITS -1.00000000E+037 1.00000000E+037
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_bFlTnkDes_C
    "calibration value for fuel level indicator via remote control"
    VALUE
    0x8006CE44
    Val_Wu8
    1.00000000000
    Dspl_bFlTnk_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 1.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_dvolFlConsTnkLoMax_C
    "parameter for min/max-limitation of fuel consumption"
    VALUE
    0x8006CE46
    Val_Ws16
    100.0000
    FlConsum_l_h
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_dvolFlConsTnkLoMin_C
    "parameter for min/max-limitation of fuel consumption"
    VALUE
    0x8006CE48
    Val_Ws16
    5.000000
    FlConsum_l_h
    0.00
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_facStoich_C
    "stochiometric fuel factor"
    VALUE
    0x8006CE30
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_nDeflateMax_C
    "Upper engine speed threshold for deflation of the low pressure stage"
    VALUE
    0x8006CE36
    Val_Ws16
    16383.50
    EngN
    0.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_nDeflateMin_C
    "Lower engine speed threshold for deflation of the low pressure stage"
    VALUE
    0x8006CE38
    Val_Ws16
    16383.50
    EngN
    0.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_pDeflate_C
    "Rail pressure threshold for deflation of the low pressure stage"
    VALUE
    0x8006CE3A
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_pLos_C
    ""
    VALUE
    0x8006CE56
    Val_Ws16
    10000.00
    Pres_hPa
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_rhoFlCnvFac_C
    "customer specific fuel conversion factor"
    VALUE
    0x8006CE32
    Val_Ws16
    999.9000
    RhoFuel
    0.1000000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_stDeflateFin_C
    ""
    VALUE
    0x80072EEA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_swtBFlTnkDes_C
    "remote control switch to select binary fuel level inidicator"
    VALUE
    0x8006CE4A
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_swtRhoFlCnv_C
    "switch for customer specific fuel conversion factor"
    VALUE
    0x8006CE34
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_swtTnkInfo_C
    "constant to switch information origin concerning fuel tank level"
    VALUE
    0x8006CE4B
    Val_Wu8
    1.00000000000
    FlSys_swtTnkInfo_VERB
    0.00
    1.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 1.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_swtVolFlTnkQntDes_C
    "remote control switch to select fuel level inidicator"
    VALUE
    0x8006CE4C
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_tiDeflateDel_C
    "Delay time for deflation of the low pressure stage"
    VALUE
    0x8006CE3C
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_tiDeflate_C
    "Deflation time of low pressure deflation"
    VALUE
    0x8006CE3E
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_tiMaxDeflateTst_C
    "Maximum duration of motortest"
    VALUE
    0x8006CE40
    Val_Ws32
    65530.0000000
    Time_ms
    10.0000000000
    65540.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_volFlConsTnkHi_C
    "this parameter represents the value which must be exceeded to reset error path"
    VALUE
    0x8006CE4E
    Val_Ws16
    655.3500
    Vol
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_volFlTnkQntDes_C
    "calibration value for fuel level indicator via remote control"
    VALUE
    0x8006CE50
    Val_Ws16
    100.0000
    Vol
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_volTnkDelta_C
    "parameter for hysteresis function of tank level"
    VALUE
    0x8006CE52
    Val_Ws16
    100.0000
    Vol
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FlSys_volTnkLo_C
    "parameter for hysteresis function of tank level"
    VALUE
    0x8006CE54
    Val_Ws16
    100.0000
    Vol
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    Fl_volTnkQnt_C
    ""
    VALUE
    0x80072EEC
    Val_Ws16
    32767.00
    Fl_Vol_q0p05
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -1638.400 1638.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_dfacSwtOffMax_C
    "Maximum allowable rate of change of temperature dependent switch off factors"
    VALUE
    0x8006CD78
    Kw_Ws32
    50.0000007451
    Rmp_Fact
    0.00
    50.0000007451

    FORMAT "%13.10"
    EXTENDED_LIMITS -4000.00000000 3999.99999814
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_dqThres_C
    "Threshold for detection of large fuel quantity changes of FMA"
    VALUE
    0x8006CD7C
    Kw_Ws16
    655.3500
    InjMassSec
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_drLamThres_C
    "Threshold for the recognition of strong changes in the Lambda value for FMA"
    VALUE
    0x8006CD7E
    Kw_Ws16
    10.20000
    lambdaSec
    -0.2000000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_facAirSwtOff_CUR
    "Characteristic curve of intake air temperature dependent switch off factor of FMA"
    CURVE
    0x8006CD80
    Kl_Xs16_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_tCACDs
        Temp_Cels
        8
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_facAPSwtOff_CUR
    "Characteristic curve of atmosphere pressure dependent switch off factor of FMA"
    CURVE
    0x8006CDA2
    Kl_Xs16_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EnvP_p
        Pres_hPa
        8
        0.00
        3500.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_facDensCor_C
    "correction factor: fuel density"
    VALUE
    0x8006CC4C
    Kw_Ws16
    0.1999512
    Fact
    0.8000488
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_facEngSwtOff_CUR
    "Characteristic curve of engine temperature dependent switch off factor of FMA"
    CURVE
    0x8006CDC4
    Kl_Xs16_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EngDa_tEng
        Temp_Cels
        8
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_facFlSwtOff_CUR
    "Characteristic curve of fuel temperature dependent switch off factor of FMA"
    CURVE
    0x8006CDE6
    Kl_Xs16_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_t
        Temp_Cels
        8
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_facNQSwtOff_MAP
    "Characteristic map of engine speed / fuel quantity dependent switch off factor of FMA for operating range dependent switch off"
    MAP
    0x8006CC54
    Kf_Xs16_Ys16_Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        4
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        FMA_qCtl_mp
        InjMass
        4
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_IFst.Ki_C
    "FMA integrator gain (fast learning of the map) / Ki_C factor within the window"
    VALUE
    0x8006CC88
    Kw_Ws32
    4.00003045797
    Ki
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_IFst.KiPos_C
    "FMA integrator gain (fast learning of the map) / Ki_C factor above the window"
    VALUE
    0x8006CC8C
    Kw_Ws32
    4.00003045797
    Ki
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_IFst.KiNeg_C
    "FMA integrator gain (fast learning of the map) / Ki_C factor below the window"
    VALUE
    0x8006CC90
    Kw_Ws32
    4.00003045797
    Ki
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_IFst.WinPos_C
    "FMA integrator gain (fast learning of the map) / Upper border of the window"
    VALUE
    0x8006CC94
    Kw_Ws32
    20.0000000000
    InjMass
    0.00
    20.0000000000

    FORMAT "%13.10"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_IFst.WinNeg_C
    "FMA integrator gain (fast learning of the map) / Lower border of the window"
    VALUE
    0x8006CC98
    Kw_Ws32
    20.0000000000
    InjMass
    -20.0000000000
    0.00

    FORMAT "%13.10"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_ISlw.Ki_C
    "FMA integrator gain (slow learning of the map) / Ki_C factor within the window"
    VALUE
    0x8006CC9C
    Kw_Ws32
    4.00003045797
    Ki
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_ISlw.KiPos_C
    "FMA integrator gain (slow learning of the map) / Ki_C factor above the window"
    VALUE
    0x8006CCA0
    Kw_Ws32
    4.00003045797
    Ki
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_ISlw.KiNeg_C
    "FMA integrator gain (slow learning of the map) / Ki_C factor below the window"
    VALUE
    0x8006CCA4
    Kw_Ws32
    4.00003045797
    Ki
    0.00
    4.00003045797

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_ISlw.WinPos_C
    "FMA integrator gain (slow learning of the map) / Upper border of the window"
    VALUE
    0x8006CCA8
    Kw_Ws32
    20.0000000000
    InjMass
    0.00
    20.0000000000

    FORMAT "%13.10"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_ISlw.WinNeg_C
    "FMA integrator gain (slow learning of the map) / Lower border of the window"
    VALUE
    0x8006CCAC
    Kw_Ws32
    20.0000000000
    InjMass
    -20.0000000000
    0.00

    FORMAT "%13.10"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_nThres_C
    "Engine speed threshold for overrun detection of FMA"
    VALUE
    0x8006CE08
    Kw_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_numLimMax_C
    "maximum number of map-points above upper diagnosis threshold"
    VALUE
    0x8006CCB0
    Kw_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_numLimMin_C
    "maximum number of map-points below lower diagnosis threshold"
    VALUE
    0x8006CCB2
    Kw_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_numNGrid_C
    "Number of co-ordinates in engine speed direction"
    VALUE
    0x8006CCB4
    Kw_Wu8
    6.000
    OneToOne
    2.000
    8.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_numQGrid_C
    "Number of co-ordinates in fuel quantity direction"
    VALUE
    0x8006CCB5
    Kw_Wu8
    6.000
    OneToOne
    2.000
    8.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qAdapIni_GMAP
    "Map for initialisation"
    MAP
    0x8006CCB6
    MapG_Ws16
    80.00000
    InjMass
    -40.00000
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        InjCtl_qSetUnBal
        InjMass
        8
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700

        AXIS_PTS_REF FMA_qAdapIni_X_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        Epm_nEng
        EngN
        8
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50

        AXIS_PTS_REF FMA_qAdapIni_Y_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin AXIS_PTS

    FMA_qAdapIni_X_AXIS
    ""
    0x8006CD36
    InjCtl_qSetUnBal
    Axis_Xs16
    327.6700
    InjMass
    8
    0.00
    327.6700

    
    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin AXIS_PTS

    FMA_qAdapIni_Y_AXIS
    ""
    0x8006CD48
    Epm_nEng
    Axis_Xs16
    10000.00
    EngN
    8
    0.00
    10000.00

    
    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    FMA_qIntMax_C
    "Largest allowed value for adapted fuel quantity errors at learning points of FMA, i.e. states of integrators and PT1-elements"
    VALUE
    0x8006CD5A
    Kw_Ws16
    80.00000
    InjMass
    -40.00000
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qIntMin_C
    "Smallest allowed value for adapted fuel quantity errors at learning points of FMA, i.e. states of integrators and PT1-elements"
    VALUE
    0x8006CD5C
    Kw_Ws16
    80.00000
    InjMass
    -40.00000
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qLimMax_C
    "upper threshold for OBD diagnosis"
    VALUE
    0x8006CD5E
    Kw_Ws16
    20.00000
    InjMass
    -10.00000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qLimMin_C
    "lower threshold for OBD diagnosis"
    VALUE
    0x8006CD60
    Kw_Ws16
    20.00000
    InjMass
    -10.00000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qMapMax_C
    "Largest allowed value for adapted fuel quantity errors at learning points of FMA"
    VALUE
    0x8006CD62
    Kw_Ws16
    80.00000
    InjMass
    -40.00000
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qMapMin_C
    "Smallest allowed value for adapted fuel quantity errors at learning points of FMA"
    VALUE
    0x8006CD64
    Kw_Ws16
    80.00000
    InjMass
    -40.00000
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qMax_C
    "Upper limit for fuel quantity correction value of FMA"
    VALUE
    0x8006CD66
    Kw_Ws16
    80.00000
    InjMass
    -40.00000
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qMin_C
    "Lower limit for fuel quantity correction value of FMA"
    VALUE
    0x8006CD68
    Kw_Ws16
    80.00000
    InjMass
    -40.00000
    40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_qThres_C
    "Fuel quantity threshold for overrun detection of FMA"
    VALUE
    0x8006CE0A
    Kw_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_rLamThresMax_C
    "Upper limit for Lambda over-range check for FMA"
    VALUE
    0x8006CE0C
    Kw_Ws16
    10.20000
    lambda
    -0.2000000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_rLamThresMin_C
    "Lower limit for Lambda over-range check for FMA"
    VALUE
    0x8006CE0E
    Kw_Ws16
    10.20000
    lambda
    -0.2000000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_stRgnMsk_C
    "Mask for regeneration detection"
    VALUE
    0x8006CE10
    Kw_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_swtChngValErrMod_C
    "switch for initialisation of LearnMap"
    VALUE
    0x8006CD6A
    Kw_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_swtCorOff_C
    "switch for deactivating fma correction"
    VALUE
    0x8006CC4E
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_swtIC_C
    "Switch for operation mode selection of FMA(Indirect Control - Direct Control)"
    VALUE
    0x8006CC4F
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_swtOnFMA_C
    "Switch for testing switch-off due to regeneration"
    VALUE
    0x8006CE14
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_swtRst_C
    "Switch to reinitialize the error model"
    VALUE
    0x8006CD6B
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiDLamThres_C
    "Wait time for the FMA- dynamic changes in the Lambda value status is reset after the dynamic changes are within the range"
    VALUE
    0x8006CE16
    Kw_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiDynThres_C
    "Waiting time until FMA fuel quantity dynamics status is reset after end of change of fuel quantity"
    VALUE
    0x8006CE18
    Kw_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiFaultRmp_C
    "Duration of ramp switch off of FMA at serious system faults"
    VALUE
    0x8006CE1C
    Kw_Ws32
    40.0000000000
    Time_s
    0.00
    40.0000000000

    FORMAT "%13.10"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiLamDT1_C
    "Time delay for differentiation of Lambda value for detection of large changes in the Lambda for FMA"
    VALUE
    0x8006CE20
    Kw_Ws32
    3.9980384506
    TimeDelay_s
    0.0010000000689
    3.9990384507

    FORMAT "%12.10"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiLamThres_C
    "Wait time for Lambda over-range check status to be reset after the Lambda is within the range"
    VALUE
    0x8006CE24
    Kw_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiOvrRun_C
    "Waiting time until FMA overrun status is reset after end of overrun"
    VALUE
    0x8006CE26
    Kw_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiPT1Fst_C
    "Time constant of PT1-filter for filtering of actual injection quantity error (fast learning of map)"
    VALUE
    0x8006CD6C
    Kw_Ws32
    4294.9662960
    TimeDelay_s
    0.0010000000689
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiPT1Slw_C
    "Time constant of PT1-filter for filtering of actual injection quantity error (slow learning of map)"
    VALUE
    0x8006CD70
    Kw_Ws32
    4294.9662960
    TimeDelay_s
    0.0010000000689
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiQDT1_C
    "Time delay of differentiation of fuel quantity for detection of large fuel quantity changes of FMA"
    VALUE
    0x8006CE28
    Kw_Ws32
    3.9980384506
    TimeDelay_s
    0.0010000000689
    3.9990384507

    FORMAT "%12.10"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiQLam_C
    "Delay time to allow adaption after reset"
    VALUE
    0x8006CE2C
    Kw_Ws16
    20.00000
    Time_s
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_tiSwtPar_C
    "Operating time of FMA for switch over from fast learning to slow learning"
    VALUE
    0x8006CD74
    Kw_Ws32
    1000000.00000
    Time_s
    0.00
    1000000.00000

    FORMAT "%13.5"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_trqLimMax_C
    "maximum fma correction torque"
    VALUE
    0x8006CC50
    Kw_Ws16
    40.00000
    Trq
    40.00000
    80.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FMA_trqLimMin_C
    "minimum fma correction torque"
    VALUE
    0x8006CC52
    Kw_Ws16
    40.00000
    Trq
    -80.00000
    -40.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FrmInf_swtDfltCal_C
    "Switch to enable/disable default calibration data to be read instead of reading from the actual CAN HW buffers by ReceiveMessage function"
    VALUE
    0x8006CEB1
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_RmpSlp.Pos_C
    "Structure containing ramp slopes for response in case of errors in the fuel temperature sensor / Slope if the ramp has to be increased"
    VALUE
    0x8006CF38
    Kw_Ws32
    3276798.99750
    RmpTemp
    1.00097656250
    3276799.99847

    FORMAT "%13.5"
    EXTENDED_LIMITS -3276800.00000 3276799.99847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_RmpSlp.Neg_C
    "Structure containing ramp slopes for response in case of errors in the fuel temperature sensor / negative ramp slope"
    VALUE
    0x8006CF3C
    Kw_Ws32
    3276798.99750
    RmpTemp
    1.00097656250
    3276799.99847

    FORMAT "%13.5"
    EXTENDED_LIMITS -3276800.00000 3276799.99847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_SRC.uMin_C
    "Structure to hold SRC thresholds for adc voltage value of fuel temperature / Threshold for SRC -Min detection"
    VALUE
    0x8006CECE
    Kw_Ws16
    200.0000
    Volt
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_SRC.uMax_C
    "Structure to hold SRC thresholds for adc voltage value of fuel temperature / Threshold for SRC -Max detection"
    VALUE
    0x8006CED0
    Kw_Ws16
    3200.000
    Volt
    2000.000
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_swtSensPrs_C
    "Switch to decide whether the fuel temperature sensor is present or not"
    VALUE
    0x8006CF40
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_swtTempSel_C
    "Switch to select the temperature for fuel system evaluation"
    VALUE
    0x8006CF41
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_tDflFlSys_C
    "Fuel System temperature default value"
    VALUE
    0x8006CF42
    Kw_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_tiLPFiltPT1_C
    "Filter time constant for fuel temperature"
    VALUE
    0x8006CF44
    Kw_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_TransStg.Dfl_C
    "Structure containing fixed replacement values and the status word to decide the response in case of errors fuel temperature sensor / Fixed replacement value"
    VALUE
    0x8006CF48
    Kw_Ws16
    250.0000
    Temp_Cels
    -50.04000
    199.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_TransStg.stSensId_C
    "Structure containing fixed replacement values and the status word to decide the response in case of errors fuel temperature sensor / Sensor Id word"
    VALUE
    0x8006CF4A
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    FuelT_tTransf_CUR
    "Transformation curve to convert voltage to physical temperture"
    CURVE
    0x8006CED2
    Cur_Xs16Ws16
    250.0000
    Temp_Cels
    -50.04000
    199.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_uRaw
        Volt
        25
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlbDa_lDrvWhlCirc_C
    ""
    VALUE
    0x8006C234
    Kw_Ws16
    65.53500
    Length_fine
    -32.76800
    32.76700

    FORMAT "%8.5"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_dwEnrgSlp_CUR
    "Negative slope for the ramp of the energy integrator"
    CURVE
    0x8006CF88
    Cur_Xs16Ws16
    499.9846
    GlwCtl_RmpSqrVltg_1000_s
    0.00
    499.9846

    FORMAT "%8.4"
    EXTENDED_LIMITS -504.1231 504.1077
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_wIntegEnrg_mp
        SqrVltg_s
        6
        0.00
        500.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -3276.800 3276.700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_nPre_C
    "Engine speed threshold for transition to start glow"
    VALUE
    0x8006D2C8
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_nPst_C
    "Upper speed threshold for end of post-glow"
    VALUE
    0x8006D2CA
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_nRdy_C
    "Engine speed threshold for transition from Startglow to Readinessglow"
    VALUE
    0x8006D2CC
    Val_Ws16
    6000.000
    EngN
    0.00
    6000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_nThresPre_C
    "Engine speed threshold for transition from Preglow to start glow"
    VALUE
    0x8006D2CE
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_numAirTempPwrCtl_C
    ""
    VALUE
    0x8006CFA2
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_numAirTempStM_C
    "Index for selecting temperature value of the air temperature field"
    VALUE
    0x8006D2D0
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_numEngTempStM_C
    "Index for selecting temperature value of the engine temperature field"
    VALUE
    0x8006D2D1
    Val_Wu8
    2.00000000000
    EngTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_numInjQnt_C
    "Switch for selecting the desired injection quantity"
    VALUE
    0x8006D2D2
    Val_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_qPstAdj_C
    "Correction value of injection quantity for transition ""PostGlow"" to ""NoPostGlow"""
    VALUE
    0x8006D2D4
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_qPst_CUR
    "Injection quantity threshold value for post-glow"
    CURVE
    0x8006D2D6
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        8
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_qThresFlQnt_C
    "Injection quantity threshold for leaving intermediate glow"
    VALUE
    0x8006D2F8
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_qThresFl_C
    "Lower threshold of injected fuel quantity without intermediate glow"
    VALUE
    0x8006D2FA
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_swtClgMode_C
    "Switch for cooling timer, cooling in no glow"
    VALUE
    0x8006CFA3
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_swtEnrgPreEnaVal_C
    "Switch for pre-glow with defined energy entry"
    VALUE
    0x8006CFA4
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_swtEnrgPstEna_C
    "Switch for activation of energy integrator in Post Glow"
    VALUE
    0x8006CFA5
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_swtRlsPshDisbl_C
    "Switch to deactivate ""Push disable"""
    VALUE
    0x8006CFA6
    Val_Wu8
    0.00
    OneToOne
    1.000
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_swtSelUOut_C
    "Switch for selection of glow plug voltage for readiness glow"
    VALUE
    0x8006CFA7
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_swtStrt_C
    "Switch value for voltage selection in the start-up glow state"
    VALUE
    0x8006CFA8
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_swtWakeUpPrs_C
    "Switch for deactivation of WakeUp-behaviour"
    VALUE
    0x8006D2FC
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tAdjMax_C
    "Maximum value temperature limitation adjustment"
    VALUE
    0x8006D2FE
    Val_Ws16
    100.0000
    TempDiff_Kelv_1K
    -50.00000
    50.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tAdjMin_C
    "Minimum value torque limitation adjustment"
    VALUE
    0x8006D300
    Val_Ws16
    100.0000
    TempDiff_Kelv_1K
    -50.00000
    50.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tDflEng_C
    "Default value for engine temperature"
    VALUE
    0x8006D302
    Val_Ws16
    250.0000
    Temp_Cels_1deg
    -50.14000
    199.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -33041.14 32493.86
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiChk_C
    "Blocking time for intermediate glow state"
    VALUE
    0x8006D304
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiClgHi_C
    "Duration of the glow plug cooling timer of the higher engine temperature"
    VALUE
    0x8006CFAC
    Val_Ws32
    327460.000000
    Time_ms
    0.00
    327460.000000

    FORMAT "%13.6"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiClgLo_C
    "Duration of the glow plug cooling timer at lower engine temperatures"
    VALUE
    0x8006CFB0
    Val_Ws32
    327460.000000
    Time_ms
    0.00
    327460.000000

    FORMAT "%13.6"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiDebPre_C
    "Debounce time to end pre glow if threshold engine speed is reached"
    VALUE
    0x8006D306
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiDebT50_C
    "Debounce time for transition to go to START GLOW state"
    VALUE
    0x8006D308
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiGlwMax_C
    "Maximum duration of intermediate glow"
    VALUE
    0x8006D30A
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiHiPreGlwPrectl_CUR
    "Time for Preconditioning of the Glow Plugs"
    CURVE
    0x8006CFB4
    Cur_Xs16Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        5
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiPre1_MAP
    "Pre glow time(1) as a function of battery voltage and coolant temperature"
    MAP
    0x8006D30C
    Map_Xs16Ys16Ws16
    335500.0
    GlwCtl_Time_ms
    0.00
    335500.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Air_tAFS
        Temp_Cels
        4
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        CEngDsT_t
        Temp_Cels
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiPre2_MAP
    "Pre glow time(2) as a function of atmospheric pressure and coolant temperature"
    MAP
    0x8006D354
    Map_Xs16Ys16Ws16
    335500.0
    GlwCtl_Time_ms
    0.00
    335500.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EnvP_p
        Pres_hPa
        4
        0.00
        3500.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEngAdj
        Temp_Cels_1deg
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiPreGlwPsh_CUR
    "Curve for the activation duration of the glow indicator lamp during pushing"
    CURVE
    0x8006CF4C
    Cur_Xs16Ws16
    335500.0
    GlwCtl_Time_ms
    0.00
    335500.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        8
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiPreGlw_CUR
    "Curve for the activation duration of the glow indicator lamp"
    CURVE
    0x8006CF6E
    Cur_Xs16Ws16
    335500.0
    GlwCtl_Time_ms
    0.00
    335500.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        4
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiPst_MAP
    "Map for calculation of post glow time"
    MAP
    0x8006D39C
    Map_Xs16Ys16Ws16
    3276700.
    GlwCtl_Time_ms
    0.00
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        8
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        EnvP_p
        Pres_hPa
        6
        0.00
        3500.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiRdy1_C
    "Duration of readiness glow, phase 1"
    VALUE
    0x8006CFCC
    Val_Ws32
    6553500.00000
    GlwCtl_Time_ms
    0.00
    6553500.00000

    FORMAT "%13.5"
    EXTENDED_LIMITS -214748364800. 214748364700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiRdy_CUR
    "Duration of readiness glow"
    CURVE
    0x8006D41C
    Cur_Xs16Ws16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiStrt_C
    "Duration of start glow"
    VALUE
    0x8006D436
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiThresFl1_CUR
    "Threshold time curve for No glow to intermediate glow transition"
    CURVE
    0x8006D438
    Cur_Xs16Ws16
    327460.0
    Time_ms
    0.00
    327460.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tAirStM_mp
        Temp_Cels_1deg
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiThresFl2_C
    "Threshold time for transition from Intermediate glow to No glow"
    VALUE
    0x8006D452
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tiThresFlNoPst_C
    "Debounce time duration when Injection quantity is less then threshold"
    VALUE
    0x8006D454
    Val_Ws16
    327670.0
    Time_ms
    0.00
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tStrt_C
    "Upper threshold of coolant temperature for start glow"
    VALUE
    0x8006D456
    Val_Ws16
    250.0000
    Temp_Cels_1deg
    -50.14000
    199.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -33041.14 32493.86
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_tThresSwtTClg_C
    "Temperature threshold for selecting the glow plug cooling time"
    VALUE
    0x8006CFD0
    Val_Ws16
    250.0000
    Temp_Cels_1deg
    -50.14000
    199.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -33041.14 32493.86
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uGlwPlgHiPreGlwPrectl_CUR
    "Voltage for pre-glow with energy entry during preconditioning-phase"
    CURVE
    0x8006CFD2
    Cur_Xs16Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_wIntegEnrg_mp
        SqrVltg_s
        8
        0.00
        3275.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -3276.800 3276.700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uGlwPlgHiPreGlw_CUR
    "Voltage for Pre Glow with energy entry"
    CURVE
    0x8006CFF4
    Cur_Xs16Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_wIntegEnrg_mp
        SqrVltg_s
        8
        0.00
        3275.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -3276.800 3276.700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uHiPreGlwOfs_C
    "Offset compensation value for voltage looses during pushing"
    VALUE
    0x8006D016
    Val_Ws16
    5000.000
    Volt_Batt
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uNomGlwPlg_C
    "Nominal voltage for the glow plugs"
    VALUE
    0x8006D018
    Val_Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uOutItm_MAP
    "Glow plug voltage at intermediate glow"
    MAP
    0x8006D01A
    Map_Xs16Ys16Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        6
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_qInjQnt
        InjMass
        6
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uOut_CUR
    "Glow plug voltage depending on the operating point"
    CURVE
    0x8006D07E
    Cur_Xs16Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        6
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uOut_MAP
    "Glow plug voltage depending on the operating point"
    MAP
    0x8006D098
    Map_Xs16Ys16Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        11
        0.00
        10000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_qInjQnt
        InjMass
        9
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uPresPstCor_MAP
    "Pressure dependent correction voltage for post glow"
    MAP
    0x8006D18A
    Map_Xs16Ys16Ws16
    21280.00
    Volt_Batt
    -20780.00
    500.0000

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EnvP_p
        Pres_hPa
        4
        0.00
        3500.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uPstCor_MAP
    "Correction voltage for post glow"
    MAP
    0x8006D1D2
    Map_Xs16Ys16Ws16
    21280.00
    Volt_Batt
    -20780.00
    500.0000

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EpmCrS_ctRevStrt
        OneToOne
        6
        0.00
        20000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uStrt_C
    "Glow plug voltage for start-up glow"
    VALUE
    0x8006D236
    Val_Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uThresHiOvrVltg_C
    "Upper battery voltage hysteresis limit for overvoltage"
    VALUE
    0x8006CF80
    Val_Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uThresHiUndrVltg_C
    "Upper battery voltage hysteresis limit for undervoltage"
    VALUE
    0x8006CF82
    Val_Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uThresLoOvrVltg_C
    "Lower battery voltage hysteresis limit for overvoltage"
    VALUE
    0x8006CF84
    Val_Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uThresLoUndrVltg_C
    "Lower battery voltage hysteresis limit for undervoltage"
    VALUE
    0x8006CF86
    Val_Ws16
    20780.00
    Volt_Batt
    0.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_uTIndPstCor_MAP
    "Correction voltage for post glow dependent from air temperature"
    MAP
    0x8006D238
    Map_Xs16Ys16Ws16
    41560.00
    Volt_Batt
    -20780.00
    20780.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tAirPwrCtl_mp
        Temp_Cels_1deg
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        6
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwCtl_wEnrgPre_CUR
    "Threshold for energy entry depending on engine temperature"
    CURVE
    0x8006D29C
    Cur_Xs16Ws16
    500.0000
    SqrVltg_s
    0.00
    500.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        GlwCtl_tEng
        Temp_Cels_1deg
        10
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -33041.14 32493.86
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgLVS_ATS.LimitTypeMsk_C
    "Actuator test GlwPlgLVS_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BDA8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgLVS_ATS.CnvNorm_C
    "Actuator test GlwPlgLVS_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BDA9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgLVS_ATS.LowLim_C
    "Actuator test GlwPlgLVS_ATS / Lower limit for monitoring"
    VALUE
    0x8006BDAA
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgLVS_ATS.UpLim_C
    "Actuator test GlwPlgLVS_ATS / Upper limit for monitoring"
    VALUE
    0x8006BDAC
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgLVS_ATS.CnvFac_C
    "Actuator test GlwPlgLVS_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BDB0
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgLVS_ATS.CnvOfs_C
    "Actuator test GlwPlgLVS_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BDB4
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgLVS_ATS.DfltVal_C
    "Actuator test GlwPlgLVS_ATS / Default value for standbytest"
    VALUE
    0x8006BDB6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgSVS_ATS.LimitTypeMsk_C
    "Actuator test GlwPlgSVS_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BDB8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgSVS_ATS.CnvNorm_C
    "Actuator test GlwPlgSVS_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BDB9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgSVS_ATS.LowLim_C
    "Actuator test GlwPlgSVS_ATS / Lower limit for monitoring"
    VALUE
    0x8006BDBA
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgSVS_ATS.UpLim_C
    "Actuator test GlwPlgSVS_ATS / Upper limit for monitoring"
    VALUE
    0x8006BDBC
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgSVS_ATS.CnvFac_C
    "Actuator test GlwPlgSVS_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BDC0
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgSVS_ATS.CnvOfs_C
    "Actuator test GlwPlgSVS_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BDC4
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlgSVS_ATS.DfltVal_C
    "Actuator test GlwPlgSVS_ATS / Default value for standbytest"
    VALUE
    0x8006BDC6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_dcycPwmInMax_C
    ""
    VALUE
    0x8006D480
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_dcycPwmInMin_C
    ""
    VALUE
    0x8006D482
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_DigOut.tiBtwTstSCB_C
    "Structure containing parameters for Digital output power stage error handling for glow plug digital actuator / Time between tests for SCB error"
    VALUE
    0x8006D458
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_DigOut.tiBtwTstOT_C
    "Structure containing parameters for Digital output power stage error handling for glow plug digital actuator / Time between tests for OT error"
    VALUE
    0x8006D45A
    Kw_Ws16
    300.0000
    Time_s
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_DigOut.numTstMax_C
    "Structure containing parameters for Digital output power stage error handling for glow plug digital actuator / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006D45C
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_numTstMax_C
    "Maximum number of test impulses"
    VALUE
    0x8006D45E
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_Pwm.tiPer_C
    "Structure containing calibration and conversion data types for glow plug actuator / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x8006D460
    Kw_Ws16
    310.0000
    OneToOne
    0.00
    310.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_Pwm.stLvl_C
    "Structure containing calibration and conversion data types for glow plug actuator / Reference value for phase relationship in period units"
    VALUE
    0x8006D462
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_Pwm.rMaxDty_C
    "Structure containing calibration and conversion data types for glow plug actuator / Reference value for maximum duty cycle"
    VALUE
    0x8006D464
    Kw_Ws16
    10000.00
    OneToOne
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_Pwm.rPerUn_C
    "Structure containing calibration and conversion data types for glow plug actuator / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x8006D466
    Kw_Ws16
    999.0000
    OneToOne
    1.000000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_Pwm.tiPh_C
    "Structure containing calibration and conversion data types for glow plug actuator / Active level (0 or 1)"
    VALUE
    0x8006D468
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rLVSCod_C
    "Duty cycle for low voltage system GCU coding"
    VALUE
    0x8006D46A
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rLVSMax_C
    "Upper limit for duty cycle for low voltage system diagnosis"
    VALUE
    0x8006D46C
    Kw_Ws16
    85.00000
    DtyCyc
    15.00000
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rLVSMin_C
    "Lower limit for duty cycle for low voltage system diagnosis"
    VALUE
    0x8006D46E
    Kw_Ws16
    85.00000
    DtyCyc
    15.00000
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rLVSPsAct_C
    ""
    VALUE
    0x8006F240
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rThresDiaHi_C
    ""
    VALUE
    0x8006D484
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rThresDiaLo_C
    ""
    VALUE
    0x8006D486
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rThresDiaSumHi_C
    ""
    VALUE
    0x8006D488
    Kw_Ws16
    105.0000
    DtyCyc
    0.00
    105.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_rThresDiaSumLo_C
    ""
    VALUE
    0x8006D48A
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_stPsDiaDisbl_C
    "Application parameter to disable diagnosis of power stage for glow plug digital actuator under certain battery and engine conditions"
    VALUE
    0x8006D470
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_stPsDisbl_C
    "Application parameter to disable power stage for glow plug digital actuator under certain battery and engine conditions"
    VALUE
    0x8006D471
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_swtBattCorEna_C
    "Switch value to enable battery voltage correction in ECU"
    VALUE
    0x8006D472
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_swtCodRdy_C
    ""
    VALUE
    0x8006D473
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_tiBtwTstOT_C
    "Time between two tests when power stage is defective"
    VALUE
    0x8006D474
    Kw_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_tiBtwTstSCB_C
    "Time between two tests when power stage is defective"
    VALUE
    0x8006D476
    Kw_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_tiDelRLVSPs_C
    ""
    VALUE
    0x8006D48C
    Val_Ws16
    327660.0
    Time_ms
    0.00
    327660.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_uBattLim_C
    "Minimum value of battery voltage needed to detect No-load error of power stages"
    VALUE
    0x8006D478
    Kw_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_uHysLsp_C
    "Lower Hysterisis threshold"
    VALUE
    0x8006D47A
    Kw_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_uHysRsp_C
    "Upper Hysterisis threshold"
    VALUE
    0x8006D47C
    Kw_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    GlwPlg_uRef_C
    "Correction voltage in case battery correction is required"
    VALUE
    0x8006D47E
    Kw_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_Pwm.tiPer_C
    " / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x8006C21A
    Kw_Ws16
    9.900000
    Period
    0.1000000
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_Pwm.stLvl_C
    " / Reference value for phase relationship in period units"
    VALUE
    0x8006C21C
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_Pwm.rMaxDty_C
    " / Reference value for maximum duty cycle"
    VALUE
    0x8006C21E
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_Pwm.rPerUn_C
    " / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x8006C220
    Kw_Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_Pwm.tiPh_C
    " / Active level (0 or 1)"
    VALUE
    0x8006C222
    Kw_Ws16
    3276.700
    Period
    0.00
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_PwmOut.rMin_C
    " / Minimum threshold for the duty cycle"
    VALUE
    0x8006C224
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_PwmOut.rMax_C
    " / Maximum threshold for the duty cycle"
    VALUE
    0x8006C226
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_PwmOut.tiBtwTstSCB_C
    " / Time between tests for SCB error"
    VALUE
    0x8006C228
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_PwmOut.tiBtwTstOT_C
    " / Time between tests for OT error"
    VALUE
    0x8006C22A
    Kw_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_PwmOut.numTstMax_C
    " / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006C22C
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_PwmOut.swtBattCor_C
    " / Switch to enable battery correction"
    VALUE
    0x8006C22E
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_PwmOut.swtPsInv_C
    " / Power stage output inversion status"
    VALUE
    0x8006C22F
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_stPsDiaDisbl_C
    ""
    VALUE
    0x8006C230
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCIVlv_stPsDisbl_C
    ""
    VALUE
    0x8006C231
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCUn_dqDem_C
    ""
    VALUE
    0x8006C238
    Val_Ws32
    429496729.500
    HCMassPerTime
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCUn_stInjOn_C
    ""
    VALUE
    0x8006C23C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCVlv_DigOut.tiBtwTstSCB_C
    " / Time between tests for SCB error"
    VALUE
    0x8006D48E
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCVlv_DigOut.tiBtwTstOT_C
    " / Time between tests for OT error"
    VALUE
    0x8006D490
    Kw_Ws16
    1000.000
    Time_s
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCVlv_DigOut.numTstMax_C
    " / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006D492
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCVlv_stPsDiaDisbl_C
    ""
    VALUE
    0x8006D494
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HCVlv_stPsDisbl_C
    ""
    VALUE
    0x8006D495
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HESrv_swtPOpVis_C
    "Bank selection for working point indication in INCA for twin-flow systems"
    VALUE
    0x8006D496
    Val_Wu8
    1.00000000000
    HESrv_SwtPOpVis
    0.00
    1.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 1.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    HESrv_swtScndFlwActv_C
    "Switch-off of the second flow of a twin-flow system"
    VALUE
    0x8006D497
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    ImmCtl_stEnaEmul_C
    ""
    VALUE
    0x80074702
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_numInjMaxSys_C
    "Maximum number of injections allowed determined by the system"
    VALUE
    0x80074704
    Val_Wu8
    6.000
    OneToOne
    0.00
    6.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_numInjRtmLim_CUR
    "curve for limitation of number of injections due to runtime"
    CURVE
    0x80074706
    Cur_Xs16Ws16
    4.000000
    OneToOne
    1.000000
    5.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        Epm_nEng
        EngN
        8
        0.00
        5000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -16384.00 16383.50
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_phiDiffBnk_C
    ""
    VALUE
    0x80074728
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_phiMIMax_C
    ""
    VALUE
    0x8007472A
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_phiPiIMax_C
    "Earliest absolute start of energizing of a PiI"
    VALUE
    0x8007472C
    Val_Ws16
    99.99756
    AngleCrS
    0.00
    99.99756

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_phiPoIMin_C
    ""
    VALUE
    0x8007472E
    Val_Ws16
    1439.978
    AngleCrS
    -720.0000
    719.9780

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_qMin_CUR
    "Curve for calculating the minimum quantity 2 of an injection"
    CURVE
    0x80074730
    Cur_Xs16Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_rRtmLimEngSpdHys_C
    "engine speed hysteresis for limitation of number of injections due to runtime"
    VALUE
    0x80074772
    Val_Ws16
    50.00000
    Prc
    0.00
    50.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_rTrqInrLimMax_C
    ""
    VALUE
    0x80072EEE
    Val_Ws16
    655.3600
    Prc_Fact100
    -327.6800
    327.6800

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_rTrqInrLimMin_C
    ""
    VALUE
    0x80072EF0
    Val_Ws16
    655.3600
    Prc_Fact100
    -327.6800
    327.6800

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_stInjCharComp_C
    ""
    VALUE
    0x80072EF2
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_stInjCharShOffTst_CA
    ""
    VAL_BLK
    0x80072EF3
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_stMI1DurCSCFrz_C
    ""
    VALUE
    0x80072EF9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_stMI1QntCSCCorActv_C
    ""
    VALUE
    0x80072EFA
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_stStMShOffTst_C
    ""
    VALUE
    0x80072EFB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_tiPoI1SpltDiffMin_C
    "Minimum time difference between splitted injections of PoI1"
    VALUE
    0x8006F244
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_tiPseElec_C
    ""
    VALUE
    0x80074774
    Val_Ws16
    65535.00
    InjTime_us_RSA
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCrv_tiPseHyd_MAP
    ""
    MAP
    0x80074776
    Map_Xs16Ys16Ws16
    0.00
    InjTime_us_RSA
    0.00
    0.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        10
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCrv_qPause_mp
        InjMass_RSA
        8
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjCtl_qRaw_C
    ""
    VALUE
    0x80072EFC
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjSys_ctAirTempRailRgnSel_C
    "Index to select the Air Temperature for Rail pressure Setpoint calculation during regeneration mode for EOM1-EOM7"
    VALUE
    0x8006DDCE
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjSys_ctAirTempRailSel_C
    "Index to select the Air Temperature for Rail pressure Setpoint calculation for EOM0"
    VALUE
    0x8006DDCF
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjSys_ctAirTempRgnSel_C
    "Index to select intake air temperature for the injection system in Regeneration mode"
    VALUE
    0x8006DDD0
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjSys_ctAirTempSel_C
    "Index to select intake air temperature for the injection system"
    VALUE
    0x8006DDD1
    Val_Wu8
    2.00000000000
    AirTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjSys_ctEngTempRgnSel_C
    "Index to select engine temperature for the injection system in Regeneration mode"
    VALUE
    0x8006DDD2
    Val_Wu8
    2.00000000000
    EngTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjSys_ctEngTempSel_C
    "Index to select engine temperature for the injection system"
    VALUE
    0x8006DDD3
    Val_Wu8
    2.00000000000
    EngTempFldSel
    0.00
    2.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 2.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjSys_qOutrCmb_C
    ""
    VALUE
    0x80072EFE
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_ctSyncStrtPls_C
    "Debounce counter synchronisation for start plausibility"
    VALUE
    0x8006DDD4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_nStrtLim_C
    "Engine speed threshold at start for pressure build up"
    VALUE
    0x8006DDD6
    Val_Ws16
    5000.000
    EngN
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_stShOffStrt_C
    "Switch to decide which reversible shutoff conditions will be checked"
    VALUE
    0x8006DDD8
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_stSta_C
    "parameter for stimulation of InjCrv_stSta"
    VALUE
    0x80072F00
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_swtStrtPls_C
    "Switch to deactivate the start plausibility"
    VALUE
    0x8006DDDC
    Val_Wu8
    7.000
    OneToOne
    0.00
    7.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_tiRailStrtPls_C
    "Debounce time for pressure build up for start plausibility"
    VALUE
    0x8006DDDE
    Val_Ws16
    387680.0
    Time_ms
    -327680.0
    60000.00

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_tiShOffStrtPls_C
    "Debounce time for shut off recognition for start plausibility"
    VALUE
    0x8006DDE0
    Val_Ws16
    387680.0
    Time_ms
    -327680.0
    60000.00

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjUn_tiSpdStrtPls_C
    "Debounce time for engine speed recognition for start plausibility"
    VALUE
    0x8006DDE2
    Val_Ws16
    387680.0
    Time_ms
    -327680.0
    60000.00

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_facAddBalRls_MAP
    "Release map for computing the fuel quantity correction compensation"
    MAP
    0x8006DDE4
    Map_Xs16Ys16Ws16
    1.000000
    Fact
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        4
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjCtl_qSetUnBal
        InjMass
        4
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_facBalMax_C
    "Maximum correction factor for FBC intervention"
    VALUE
    0x8006DE18
    Val_Ws16
    3.999878
    Fact
    0.00
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_nETMaxLim_C
    "Maximum engine speed for limiting the MI energizing time"
    VALUE
    0x8006DE1A
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_numBnkTDC_CA
    "Injection bank in which the cylinder is located (=x-1 for MVxy in the ""Brunnerplan"")"
    VAL_BLK
    0x8006E468
    ValA_Wu8
    4.000
    OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_numECUTDC_CA
    "Control unit in which the cylinder is located (=0 for single ecu or master)"
    VAL_BLK
    0x8006E46E
    ValA_Wu8
    4.000
    OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_numInjChrgBalRC_C
    "Remote value for the limitation of the number of injections by the charge balance"
    VALUE
    0x8006DE36
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_numInjChrgBal_CUR
    "Curve for max. number of injections based on the buffer capacitor charge balance"
    CURVE
    0x8006DE38
    Cur_Xs16Ws16
    8.000000
    OneToOne
    0.00
    8.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjVlv_numInjChrgBalRaw_mp
        NumInjChrgBalRaw
        10
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_numInjDesRC_C
    "Remote value for the demanded number of injections for the charge balance caused shut off of injections"
    VALUE
    0x8006DE62
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_numPrep_C
    "Number of activations pre actuator for InjVlv_Prep"
    VALUE
    0x8006E486
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_numPsTDC_CA
    "assignment of cylinder number to number of power stage (=y-1 for MVxy in the ""Brunnerplan"")"
    VAL_BLK
    0x8006E474
    ValA_Wu8
    4.000
    OneToOne
    0.00
    4.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_pMin_C
    "Injector pressure threshold for releasing/inhibiting the injection"
    VALUE
    0x8006E4D6
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_pMin_CUR
    "Threshold for releasing/inhibiting injections based on coolant temperature"
    CURVE
    0x8006E4D8
    Cur_Xs16Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        EngDa_tEng
        Temp_Cels
        8
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_pPrepMax_C
    "Upper rail pressure limit for injection valve preparation"
    VALUE
    0x8006E488
    Val_Ws16
    500000.0
    Pres_Rail
    0.00
    500000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin AXIS_PTS

    InjVlv_pRailZFCETCor_AXIS
    "Shared rail pressure axis for ZFC energizing time correction maps"
    0x8006E54E
    RailP_pCurr_mp
    Axis_Xs16
    600000.0
    Pres_Rail
    6
    200000.0
    800000.0

    
    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    InjVlv_pwrDCDCMax_CUR
    "Curve for max. allowed power output of 1 DCDC converter"
    CURVE
    0x8006DE64
    Cur_Xs16Ws16
    150000.0
    Pwr_PA
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -163840.0 163835.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        BattU_u
        Volt_Batt
        10
        -655360.0
        655340.0

        FORMAT "%8.1"
        EXTENDED_LIMITS -655360.0 655340.0
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_pwrDCDCOvrLdMax_CUR
    "Curve for max. allowed power output of 1 DCDC converter in overload state"
    CURVE
    0x8006DE8E
    Cur_Xs16Ws16
    150000.0
    Pwr_PA
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -163840.0 163835.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        BattU_u
        Volt_Batt
        10
        -655360.0
        655340.0

        FORMAT "%8.1"
        EXTENDED_LIMITS -655360.0 655340.0
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_PZOSW_C
    "Software Version"
    VALUE
    0x8006E544
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_qPoI1Min_C
    "Minimum fuel quantity for post injection 1"
    VALUE
    0x8006E484
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin AXIS_PTS

    InjVlv_qZFCETCor_AXIS
    "Co-ordinates of the quantity for correction factor group maps of the ZFC energizing time correction"
    0x8006E55C
    InjVlv_qInZFCETGMap_mp
    Axis_Xs16
    3.000000
    InjMass
    6
    0.00
    3.000000

    
    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    DEPOSIT ABSOLUTE

        /* AsapCFm - KWP2000 */

/end AXIS_PTS

/begin CHARACTERISTIC

    InjVlv_rChrgBalInjHys_C
    "Hysteresis threshold to select max. number of injections by charge balance of buffer C"
    VALUE
    0x8006DEB8
    Val_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_rOvrLdRlx_C
    "ratio of overload to relaxmode (resolution is 0.1, value must be 10 times higher than expected factor)"
    VALUE
    0x8006DEBA
    Val_Wu8
    24.90
    FACT_Rlx
    0.1000
    25.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 25.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_rZFCETDif0_GMAP
    "Group map for evaluation factor for energizing time correction by zero fuel calibration in the rail pressure calibration point 0"
    MAP
    0x8006E56A
    MapG_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        RailP_pCurr_mp
        Pres_Rail
        6
        200000.0
        800000.0

        FORMAT "%8.1"
        EXTENDED_LIMITS -3276800. 3276700.

        AXIS_PTS_REF InjVlv_pRailZFCETCor_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        InjVlv_qInZFCETGMap_mp
        InjMass
        6
        0.00
        3.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -327.6800 327.6700

        AXIS_PTS_REF InjVlv_qZFCETCor_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_rZFCETDif1_GMAP
    "Group map for evaluation factor for energizing time correction by zero fuel calibration in the rail pressure calibration point 1"
    MAP
    0x8006E5B2
    MapG_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        RailP_pCurr_mp
        Pres_Rail
        6
        200000.0
        800000.0

        FORMAT "%8.1"
        EXTENDED_LIMITS -3276800. 3276700.

        AXIS_PTS_REF InjVlv_pRailZFCETCor_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        InjVlv_qInZFCETGMap_mp
        InjMass
        6
        0.00
        3.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -327.6800 327.6700

        AXIS_PTS_REF InjVlv_qZFCETCor_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_rZFCETDif2_GMAP
    "Group map for evaluation factor for energizing time correction by zero fuel calibration in the rail pressure calibration point 2"
    MAP
    0x8006E5FA
    MapG_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        RailP_pCurr_mp
        Pres_Rail
        6
        200000.0
        800000.0

        FORMAT "%8.1"
        EXTENDED_LIMITS -3276800. 3276700.

        AXIS_PTS_REF InjVlv_pRailZFCETCor_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        InjVlv_qInZFCETGMap_mp
        InjMass
        6
        0.00
        3.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -327.6800 327.6700

        AXIS_PTS_REF InjVlv_qZFCETCor_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_rZFCETMsk_GMAP
    "Overall evaluation factor group map of energizing time correction by ZFC"
    MAP
    0x8006E642
    MapG_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        COM_AXIS
        RailP_pCurr_mp
        Pres_Rail
        6
        200000.0
        800000.0

        FORMAT "%8.1"
        EXTENDED_LIMITS -3276800. 3276700.

        AXIS_PTS_REF InjVlv_pRailZFCETCor_AXIS

    /end AXIS_DESCR

    /begin AXIS_DESCR

        COM_AXIS
        InjVlv_qInZFCETGMap_mp
        InjMass
        6
        0.00
        3.000000

        FORMAT "%8.6"
        EXTENDED_LIMITS -327.6800 327.6700

        AXIS_PTS_REF InjVlv_qZFCETCor_AXIS

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_stInjCharComp_C
    "status of compensation of injections"
    VALUE
    0x8006E47C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_stInjCoRC_C
    "state: injection coorinator remote state"
    VALUE
    0x8006E47A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_stInjRls_CA
    "status of released injections"
    VAL_BLK
    0x8006E47D
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_stInputZFCETGMap_C
    "Selection of the fuel quantity for display in the group maps InjVlv_rZFCETDif0_GMAP, ...Dif1_GMAP, ...Msk_GMAP"
    VALUE
    0x8006E68A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_stPrepRC_C
    "Remote value for InjVlv_stPrep"
    VALUE
    0x8006E48A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_stZFCETCorActv_C
    "Activation status of ZFC energizing time correction (0 = no correction)"
    VALUE
    0x8006E68B
    Val_Wu8
    0.00
    OneToOne
    0.00
    0.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtAgTi2AgMode_C
    "switch to choose between MIAP and constant extrapolation for calculation of start of energising"
    VALUE
    0x8006E548
    Val_Wu8
    10.0000000000
    InjVlv_AgTi2AgMode
    0.00
    10.0000000000

    FORMAT "%13.10"
    EXTENDED_LIMITS 0.00 10.0000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtEnaAgDiff_C
    "ON/OFF switch for calculating the differential angle (1 = ON, 0 = OFF)"
    VALUE
    0x8006E549
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtInjCoRC_C
    "switch: state of injection coordinator is set by remote"
    VALUE
    0x8006E47B
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtInputETMAP_C
    "Selection of input values for displaying InjVlv_tiET_MAP on the application tool"
    VALUE
    0x8006DECC
    Val_Wu8
    15.00
    OneToOne
    0.00
    15.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtNumInjRC_C
    "switch to activate remote control values for number of injections"
    VALUE
    0x8006DEBB
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtPrepRC_C
    "Switch: activating remote value for InjVlv_stPrep"
    VALUE
    0x8006E48B
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtSOERngChk_C
    "Switch for activation of injector specific SOE correction"
    VALUE
    0x8006E53C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtTiMI1ET_C
    "Switch for remote control value of the MI energizing time"
    VALUE
    0x8006DE1C
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtTiPiI1ET_C
    "Switch for remote control value of the PiI1energizing time"
    VALUE
    0x8006DE22
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtTiPiI2ET_C
    "Switch for remote control value of the PiI2 energizing time"
    VALUE
    0x8006DE26
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtTiPiI3ET_C
    "Switch for remote control value of the PiI3 energizing time"
    VALUE
    0x8006DE2A
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtTiPoI1ET_C
    "Switch for the remote control value of the PoI1 energizing time"
    VALUE
    0x8006DE2E
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtTiPoI2ET_C
    "Switch for remote control value of the PoI2 energizing time"
    VALUE
    0x8006DE32
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_swtZFCCorOvrRunOn_C
    "Minimum ZFC energizing time correction"
    VALUE
    0x8006E68C
    Val_Wu8
    0.00
    OneToOne
    0.00
    0.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiChrgPrep_CUR
    "Curve: voltage dependent charge time of injection valve preparation"
    CURVE
    0x8006E48C
    Cur_Xs16Ws16
    100.0000
    InjTime_us
    80.00000
    180.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_tActr
        Temp_Cels
        4
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiDisChPrep_CUR
    "Curve: voltage dependent discharge time of injection valve preparation"
    CURVE
    0x8006E49E
    Cur_Xs16Ws16
    100.0000
    InjTime_us
    80.00000
    180.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_tActr
        Temp_Cels
        4
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiETMax_C
    "Maximum MI energizing time"
    VALUE
    0x8006DE1E
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiETMinLow_C
    "Minimum energizing time"
    VALUE
    0x8006E54A
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiETPoI2_MAP
    ""
    MAP
    0x8006DECE
    Map_Xs16Ys16Ws16
    3000.000
    InjTime_us
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjVlv_pInET_mp
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjVlv_volInET_mp
        InjQntInj
        20
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiETPrep_CUR
    "Curve: temperature dependent activation time for injection valve preparation"
    CURVE
    0x8006E4B0
    Cur_Xs16Ws16
    7800.000
    InjTime_us
    100.0000
    7900.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_tActr
        Temp_Cels
        4
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiET_MAP
    "Map for converting from injection quantity to energizing time. Applies to all injections."
    MAP
    0x8006E19A
    Map_Xs16Ys16Ws16
    3000.000
    InjTime_us
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjVlv_pInET_mp
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjVlv_volInET_mp
        InjQntInj
        20
        0.00
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiMI1ET_C
    "Remote control value of the MI energizing time"
    VALUE
    0x8006DE20
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiOfsSOEHyd_CUR
    ""
    CURVE
    0x8006E4FA
    Cur_Xs16Ws16
    400.0000
    InjTime_us
    0.00
    400.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        16
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiOvrLdMax_C
    "maximum overload time"
    VALUE
    0x8006DEBC
    Val_Wu16
    3599.000
    Time_Second
    1.000000
    3600.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiPause_C
    "Physically determined minimum time between 2 injections"
    VALUE
    0x8006E54C
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiPiI1ET_C
    "Remote control value of the PiI1 energizing time"
    VALUE
    0x8006DE24
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiPiI2ET_C
    "Remote control value of the PiI2 energizing time"
    VALUE
    0x8006DE28
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiPiI3ET_C
    "Remote control value of the PiI3 energizing time"
    VALUE
    0x8006DE2C
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiPoI1ET_C
    "Remote control value of the PoI1 energizing time"
    VALUE
    0x8006DE30
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiPoI2ET_C
    "Remote control value of the PoI2 energizing time"
    VALUE
    0x8006DE34
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiSOERngThresMax_C
    "Upper boundary of permitted area for SOE"
    VALUE
    0x8006E53E
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiSOERngThresMin_C
    "Lower boundary of permitted area for SOE"
    VALUE
    0x8006E540
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiWaitActv_C
    "minimal waiting period till overload mode is released (since the first scheduling of the function)"
    VALUE
    0x8006DEBE
    Val_Ws16
    32767.00
    Time_Second
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiWup2On_C
    "Time between dynamic interrupt and start of energizing"
    VALUE
    0x8006E466
    Val_Ws16
    1400.000
    InjTime_us
    100.0000
    1500.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiZFCETCorMax_C
    "Maximum ZFC energizing time correction"
    VALUE
    0x8006E68E
    Val_Ws16
    600.0000
    InjTime_us
    -300.0000
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tiZFCETCorMin_C
    "Minimum ZFC energizing time correction"
    VALUE
    0x8006E690
    Val_Ws16
    600.0000
    InjTime_us
    -300.0000
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_tPrepMax_C
    "Upper temperature limit for injection valve preparation"
    VALUE
    0x8006E4C2
    Val_Ws16
    100.0000
    Temp_Cels
    -50.04000
    49.96000

    FORMAT "%8.5"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_uUpPrep_CUR
    "Curve: temperature dependent set-up voltage for injection valve preparation"
    CURVE
    0x8006E4C4
    Cur_Xs16Ws16
    130.0000
    Vltg_PA
    80.00000
    210.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_tActr
        Temp_Cels
        4
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_wInj_CUR
    "curve for actuator energy consumption per injection"
    CURVE
    0x8006DEC0
    Cur_Xs16Ws16
    100.0000
    W_PA
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        InjVlv_uSetUpAvrg_mp
        Vltg_PA
        2
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    InjVlv_xOvrLdRlxThresh_C
    "maximum threshold to allow again the release of the overload mode after integrator has reached 100% in relax mode"
    VALUE
    0x8006DECA
    Val_Ws16
    100.0000
    Prc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -400.0000 399.9878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_chRC_C
    "Remote control for IVActr_ch"
    VALUE
    0x8006D4F8
    Val_Ws16
    65535.00
    Charge_PA
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrChCor_C
    "correction factor of the actuator energy by charging the actuator"
    VALUE
    0x8006D498
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrCor_C
    "correction factor for actuator energy"
    VALUE
    0x8006D49A
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrDisChCor_C
    "correction factor for the discharging energy of the actuator"
    VALUE
    0x8006D49C
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrDvtAvrgRC_C
    "remote control value for the average factor of actor energy deviation"
    VALUE
    0x8006D49E
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrDvtMax_C
    "maximum value for actuator energie deviation"
    VALUE
    0x8006D4A0
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrDvtMin_C
    "minimum value for actuator energy deviation"
    VALUE
    0x8006D4A2
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrMax_C
    "upper boarder of the energy deviation factor to realize the energy drift"
    VALUE
    0x8006D4A4
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrMin_C
    "lower boader of energy consumption factor to realize energy drift"
    VALUE
    0x8006D4A6
    Val_Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_facWActrTemp_CUR
    "curve for temperature correction of expected actor energy consumption"
    CURVE
    0x8006D4A8
    Cur_Xs16Ws16
    511.9922
    Fact1
    -256.0000
    255.9922

    FORMAT "%8.4"
    EXTENDED_LIMITS -256.0000 255.9922
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_tActr
        Temp_Cels
        5
        -273.1400
        136.3600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_numFacWVldMin_C
    "minimal number of valid actuator energy correction factor values for averaging"
    VALUE
    0x8006D4BE
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_pRailLnkRC_C
    "remote value for linked rail pressure of measured injection"
    VALUE
    0x8006D4FA
    Val_Ws16
    6553500.
    Pres_Rail
    -3276800.
    3276700.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_resCalcChShunt_C
    "Shunt on piezo actuator"
    VALUE
    0x8006D4FC
    Val_Ws16
    0.00
    Resist_1
    20.00000
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_stActrEnrgRC_C
    "remote control value for state of actor energy"
    VALUE
    0x8006D4C0
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_stChRC_C
    "Remote value for IVActr_stCh"
    VALUE
    0x8006D4FE
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_stTiDisChRC_C
    "remote value for status of piezo actuator discharging time"
    VALUE
    0x8006D4FF
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_stTiETMeasRC_C
    "remote value for status of measured energizing time"
    VALUE
    0x8006D500
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_stUChrgUpRC_C
    "remote switch for status of piezo actuator voltage after charging"
    VALUE
    0x8006D501
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_stUDisChStopRC_C
    "remote value for status of piezo actuator voltage after discharging"
    VALUE
    0x8006D502
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_stUUpRC_C
    "remote value for status of piezo actuator voltage up-level"
    VALUE
    0x8006D503
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtActrEnrgEnaRC_C
    "switch to enable remote control for bitpositions of state of actor energy"
    VALUE
    0x8006D4C2
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtActrEnrgRC_C
    "switch for activating the remote control of actor energy calculation"
    VALUE
    0x8006D4C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtChRC_C
    "remote switch for piezo actuator charge after actuator charging"
    VALUE
    0x8006D504
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtEnaWActrCor_C
    "switch for enabeling actuator energy correction"
    VALUE
    0x8006D4C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtFacWActrDvtAvrgRC_C
    "switch to activate the remote value of the average deviation factor of actor energy"
    VALUE
    0x8006D4C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtGetMeasRC_C
    "Global activation of Remote Control in piezo actuator measurement function."
    VALUE
    0x8006D505
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtNewMeasRC_C
    "remote control value to aktivate modul (activation will happen in case of new measurement)"
    VALUE
    0x8006D4C7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtPRailLnkRC_C
    "remote switch for linked rail pressure of measured injection"
    VALUE
    0x8006D506
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtTiChrgLnkRC_C
    "remote switch for linked piezo actuator setpoint charging time"
    VALUE
    0x8006D507
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtTiDisChLnkRC_C
    "remote switch for linked piezo actuator setpoint discharging time"
    VALUE
    0x8006D508
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtTiDisChRC_C
    "remote switch for piezo actuator discharging time"
    VALUE
    0x8006D509
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtTiETMeasRC_C
    "remote switch for measured energizing time"
    VALUE
    0x8006D50A
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtUChrgUpRC_C
    "remote switch for status of piezo actuator voltage after charging"
    VALUE
    0x8006D50B
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtUDisChStopRC_C
    "remote switch for piezo actuator voltage after discharging"
    VALUE
    0x8006D50C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtUUpLnkRC_C
    "remote switch for linked piezo actuator setpoint voltage up-level"
    VALUE
    0x8006D50D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_swtUUpRC_C
    "remote switch for piezo actuator voltage up-level"
    VALUE
    0x8006D50E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tActrDfl_C
    "default temperature of actuator"
    VALUE
    0x8006D540
    Val_Ws16
    220.0000
    Temp_Cels
    -40.04000
    179.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tActr_CUR
    "determination curve of temperature of actuator"
    CURVE
    0x8006D542
    Cur_Xs16Ws16
    220.0000
    Temp_Cels
    -40.04000
    179.9600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        CEngDsT_t
        Temp_Cels
        4
        -50.14000
        199.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiActrMeasTOut_C
    "Timeout's label for measurement duration surveillance"
    VALUE
    0x8006D50F
    Val_Ws8
    0.08000
    Time_s
    0.02000
    0.1000

    FORMAT "%6.4"
    EXTENDED_LIMITS -1.280 1.270
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiChrgLnkRC_C
    "remote value for linked charging time setpoint"
    VALUE
    0x8006D510
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiDisChLnkRC_C
    "remote value for linked piezo actuator setpoint discharging time"
    VALUE
    0x8006D512
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiDisChRC_C
    "remote value for piezo actuator discharging time"
    VALUE
    0x8006D514
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiEnrgIntegAdjMax_C
    "maximum timegap since the last integrator adjustment, the charge measurement is still valid"
    VALUE
    0x8006D4C8
    Val_Wu32
    4294967295.00
    OneToOne_ms
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiETMeasRC_C
    "remote value for measured energizing time"
    VALUE
    0x8006D516
    Val_Ws16
    26214.00
    InjTime_us
    -13107.20
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiMax_C
    "Max Time limitation"
    VALUE
    0x8006D518
    Val_Ws16
    13106.80
    InjTime_us
    0.00
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_tiMin_C
    "Min Time limitation"
    VALUE
    0x8006D51A
    Val_Ws16
    13106.80
    InjTime_us
    0.00
    13106.80

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_uActrLin_CUR
    "linearisation curve for actuator voltage"
    CURVE
    0x8006D51C
    Cur_Xs16Ws16
    655.3500
    Vltg_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_uActrRaw_mp
        Volt
        2
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_uBotDfl_C
    "default voltage value for discharged actor"
    VALUE
    0x8006D4CC
    Val_Ws16
    655.3500
    Vltg_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_uChrgUpRC_C
    "remote value for piezo actuator voltage after charging"
    VALUE
    0x8006D526
    Val_Ws16
    655.3500
    Vltg_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_UCh_SRC.uMin_C
    "Class instance for charge voltage: signal range check / Threshold for SRC -Min detection"
    VALUE
    0x8006D528
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_UCh_SRC.uMax_C
    "Class instance for charge voltage: signal range check / Threshold for SRC -Max detection"
    VALUE
    0x8006D52A
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_uDisChStopRC_C
    "remote value for piezo actuator voltage after discharging"
    VALUE
    0x8006D52C
    Val_Ws16
    655.3500
    Vltg_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_uUpLnkRC_CA
    "Spezific cylinder Remote-Wert for linked actuator set voltage Up-Niveau"
    VAL_BLK
    0x8006D52E
    ValA_Ws16
    250.0000
    Vltg_PA
    0.00
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_uUpRC_C
    "remote value for piezo actuator voltage up-level"
    VALUE
    0x8006D53A
    Val_Ws16
    655.3500
    Vltg_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_Vltg_SRC.uMin_C
    "Class instance for actuator voltage signal range check / Threshold for SRC -Min detection"
    VALUE
    0x8006D53C
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_Vltg_SRC.uMax_C
    "Class instance for actuator voltage signal range check / Threshold for SRC -Max detection"
    VALUE
    0x8006D53E
    Kw_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_wActrChDfl_C
    "raw acutator charge energy default value"
    VALUE
    0x8006D4CE
    Val_Ws16
    655.3500
    W_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_wActrDisChDfl_C
    "raw acutator discharge energy default value"
    VALUE
    0x8006D4D0
    Val_Ws16
    655.3500
    W_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_wActrNom_CUR
    "curve nominal actuator energy consumption"
    CURVE
    0x8006D4D2
    Cur_Xs16Ws16
    655.3500
    W_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_uChUpInCur_mp
        Vltg_PA
        8
        -250.0000
        250.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_wActrPlausMax_C
    "upper limit for plausibilisation of actor energy consumption"
    VALUE
    0x8006D4F4
    Val_Ws16
    655.3500
    W_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVActr_wActrPlausMin_C
    "lower limit for plausibilisation of the actor energy consumption"
    VALUE
    0x8006D4F6
    Val_Ws16
    655.3500
    W_PA
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_facCtNVCEna_C
    "scaling-factor for NVC-learning counter"
    VALUE
    0x8006D67C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_facNVCDflI_C
    "default value of NVC-I-governor"
    VALUE
    0x8006D67E
    Val_Ws16
    1.000000
    Fact
    -0.5000000
    0.5000000

    FORMAT "%9.7"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_facNVCInPI_C
    "weighting-factor for NVC-PI-governor input"
    VALUE
    0x8006D680
    Val_Ws16
    2.000000
    Fact
    -1.000000
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_facNVCMax_C
    "upper limit of NVC-factor"
    VALUE
    0x8006D682
    Val_Ws16
    3.900024
    Fact
    0.00
    3.900024

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_facNVCMin_C
    "lower limit of NVC-factor"
    VALUE
    0x8006D684
    Val_Ws16
    3.900024
    Fact
    0.00
    3.900024

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_facNVCRC_CA
    "remote values for NVC-factor"
    VAL_BLK
    0x8006D686
    ValA_Ws16
    1.000000
    Fact
    0.5000000
    1.500000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_INVC_CSTR.Ki_C
    "NVC-I-governor (paramenters) / Ki_C factor within the window"
    VALUE
    0x8006D694
    Kw_Ws32
    24414.0624943
    Ki_Vltg_PA2Fact
    -12207.0312500
    12207.0312443

    FORMAT "%13.7"
    EXTENDED_LIMITS -12207.0312500 12207.0312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_INVC_CSTR.KiPos_C
    "NVC-I-governor (paramenters) / Ki_C factor above the window"
    VALUE
    0x8006D698
    Kw_Ws32
    24414.0624943
    Ki_Vltg_PA2Fact
    -12207.0312500
    12207.0312443

    FORMAT "%13.7"
    EXTENDED_LIMITS -12207.0312500 12207.0312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_INVC_CSTR.KiNeg_C
    "NVC-I-governor (paramenters) / Ki_C factor below the window"
    VALUE
    0x8006D69C
    Kw_Ws32
    24414.0624943
    Ki_Vltg_PA2Fact
    -12207.0312500
    12207.0312443

    FORMAT "%13.7"
    EXTENDED_LIMITS -12207.0312500 12207.0312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_INVC_CSTR.WinPos_C
    "NVC-I-governor (paramenters) / Upper border of the window"
    VALUE
    0x8006D6A0
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_INVC_CSTR.WinNeg_C
    "NVC-I-governor (paramenters) / Lower border of the window"
    VALUE
    0x8006D6A4
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_mskInjCharNVC_C
    "NVC-learning condition: byte to mask out not allowed injections"
    VALUE
    0x8006D6A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_mskStUChrgUpNVC_C
    "NVC-learning condition: byte to mask out status bits of chargeup voltage"
    VALUE
    0x8006D6A9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_mskStUUpNVC_C
    "NVC-learning condition: byte to mask out status bits of nominal voltage"
    VALUE
    0x8006D6AA
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_numClsIVAMax_C
    "highest permitted IVA-class"
    VALUE
    0x8006D678
    Val_Wu8
    0.00
    OneToOne
    8.000
    8.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_numClsIVAMin_C
    "lowest permitted IVA-class"
    VALUE
    0x8006D679
    Val_Wu8
    0.00
    OneToOne
    2.000
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_numCylRC_C
    "number of cylinder (function of parameter of IVAdj_NVCGovInit)"
    VALUE
    0x8006D6AB
    Val_Wu8
    5.000
    OneToOne
    0.00
    5.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_pMaxNVC_C
    "NVC-learning condition: upper limit of rail-pressure"
    VALUE
    0x8006D6AC
    Val_Ws16
    2500000.
    Pres_Rail
    0.00
    2500000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_pMinNVC_C
    "NVC-learning condition: lower limit of rail-pressure"
    VALUE
    0x8006D6AE
    Val_Ws16
    2500000.
    Pres_Rail
    0.00
    2500000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_PNVC_CSTR.Kp_C
    "NVC-P-governor (parameters) / Proportional factor Kp_C within window"
    VALUE
    0x8006D6B0
    Kw_Ws32
    1599.99999963
    Kp_Vltg_PA2Fact
    -800.000000000
    799.999999627

    FORMAT "%13.9"
    EXTENDED_LIMITS -800.000000000 799.999999627
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_PNVC_CSTR.KpPos_C
    "NVC-P-governor (parameters) / Proportional factor Kp_C above positive window border"
    VALUE
    0x8006D6B4
    Kw_Ws32
    1599.99999963
    Kp_Vltg_PA2Fact
    -800.000000000
    799.999999627

    FORMAT "%13.9"
    EXTENDED_LIMITS -800.000000000 799.999999627
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_PNVC_CSTR.KpNeg_C
    "NVC-P-governor (parameters) / Proportional factor Kp_C below negative window border"
    VALUE
    0x8006D6B8
    Kw_Ws32
    1599.99999963
    Kp_Vltg_PA2Fact
    -800.000000000
    799.999999627

    FORMAT "%13.9"
    EXTENDED_LIMITS -800.000000000 799.999999627
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_PNVC_CSTR.WinPos_C
    "NVC-P-governor (parameters) / Positive window border"
    VALUE
    0x8006D6BC
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_PNVC_CSTR.WinNeg_C
    "NVC-P-governor (parameters) / Negative window border"
    VALUE
    0x8006D6C0
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_stGovInitRC_C
    "selection of action of IVAdj_NVCGovInit (function parameter of IVAdj_NVCGovInit)"
    VALUE
    0x8006D6C4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_stQntAdj_MAP
    "Status map (index and weighting factor) for the injector quantity adjustment"
    MAP
    0x8006D554
    Map_Xs16Ys16Ws16
    32767.00
    OneToOne
    0.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        6
        0.00
        1800000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        InjVlv_volMI1Cor_mp
        InjQntInj
        8
        0.00
        100.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_stRawValRepl_C
    "Substitute values for injector adjustment"
    VAL_BLK
    0x8006D5D4
    ValA_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    
    NUMBER 12

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_swtDiaIVAdj_C
    "switch to activate supervision of missing injector-adjustment programming"
    VALUE
    0x8006D604
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_swtFacNVCRC_C
    "remote switch for NVC-factor"
    VALUE
    0x8006D6C5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_swtNVCGovInitRC_C
    "Remote-Switch for activating IVAdj_NVCGovInit test-process"
    VALUE
    0x8006D6C6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_swtRawValRepl_C
    "Switch for substituting the injector adjustment values (0 = EEPROM, 1 = substitute values)"
    VALUE
    0x8006D605
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_tActrMaxNVC_C
    "NVC-learning condition: upper limit of actuator temperature"
    VALUE
    0x8006D6C8
    Val_Ws16
    250.0000
    Temp_Cels
    -50.14000
    199.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_tActrMinNVC_C
    "NVC-learning condition: lower limit of actuator-temperature"
    VALUE
    0x8006D6CA
    Val_Ws16
    250.0000
    Temp_Cels
    -50.14000
    199.8600

    FORMAT "%8.4"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_tiMeasUUpThresNVC_C
    "NVC-learning condition: threshold for measurement period of injector-voltage"
    VALUE
    0x8006D6CC
    Val_Ws16
    10000.00
    InjTime_us
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_tiPIDisChThresNVC_C
    "NVC-learning condition: threshold of dischrage-time governor input"
    VALUE
    0x8006D6CE
    Val_Ws16
    50.00000
    InjTime_us
    0.00
    50.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_uDiffNVCSet_CUR
    "voltage difference reference curve of nominal value"
    CURVE
    0x8006D6D0
    Cur_Xs16Ws16
    250.0000
    Vltg_PA
    0.00
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVAdj_pDiffNVCSetCURIn_mp
        Pres_Rail
        20
        -3276800.
        3276700.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_uPIVltgThresNVC_C
    "NVC-learning condition: threshhold for voltage-governor input"
    VALUE
    0x8006D722
    Val_Ws16
    20.00000
    Vltg_PA
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_valSrcPtrRC_C
    "value for Source-Pointer (function parameter of IVAdj_NVCGovInit)"
    VALUE
    0x8006D724
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjLim_C
    "symmetric limitation of the quantity adjustment"
    VALUE
    0x8006D606
    Val_Ws16
    128.0000
    InjQntInj
    0.00
    128.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMax0_C
    "Upper limit values of the quantity adjustment for the 0-quantisation increments (0d=00b)"
    VAL_BLK
    0x8006D608
    ValA_Ws16
    6.300000
    InjQntInj
    0.00
    6.300000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMax1_C
    "Upper limit values of the quantity adjustment for the 1-quantisation increments (1d=01b)"
    VAL_BLK
    0x8006D616
    ValA_Ws16
    9.450000
    InjQntInj
    0.00
    9.450000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMax2_C
    "Upper limit values of the quantity adjustment for the 2-quantisation increments (2d=10b)"
    VAL_BLK
    0x8006D624
    ValA_Ws16
    15.75000
    InjQntInj
    0.00
    15.75000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMax3_C
    "Upper limit values of the quantity adjustment for the 3-quantisation increments (3d=11b)"
    VAL_BLK
    0x8006D632
    ValA_Ws16
    31.50000
    InjQntInj
    0.00
    31.50000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMin0_C
    "Lower limit values of the quantity adjustment for the 0-quantisation increments (0d=00b)"
    VAL_BLK
    0x8006D640
    ValA_Ws16
    6.400000
    InjQntInj
    -6.400000
    0.00

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMin1_C
    "Lower limit values of the quantity adjustment for the 1-quantisation increments (1d=01b)"
    VAL_BLK
    0x8006D64E
    ValA_Ws16
    9.600000
    InjQntInj
    -9.600000
    0.00

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMin2_C
    "Lower limit values of the quantity adjustment for the 2-quantisation increments (2d=10b)"
    VAL_BLK
    0x8006D65C
    ValA_Ws16
    16.00000
    InjQntInj
    -16.00000
    0.00

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVAdj_volQntAdjMin3_C
    "Lower limit values of the quantity adjustment for the 3-quantisation increments (3d=11b)"
    VAL_BLK
    0x8006D66A
    ValA_Ws16
    32.00000
    InjQntInj
    -32.00000
    0.00

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 7

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_facUDiffUpPlausMax_C
    "Voltage governor input plausibility limit"
    VALUE
    0x8006DBB0
    Val_Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_facVltgTempCor_CUR
    "Curve: actuator temperature compensation of actuator voltage"
    CURVE
    0x8006D902
    Cur_Xs16Ws16
    0.2099609
    Fact
    1.000000
    1.209961

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVActr_tActr
        Temp_Cels
        10
        -40.04000
        179.9600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_iChrgRC_CA
    "Remote value for charge-up-current"
    VAL_BLK
    0x8006D92C
    ValA_Ws16
    20000.00
    Curr
    0.00
    20000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    
    NUMBER 6

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_iChrg_MAP
    "MAP: Calculation of charge current from charging time and voltage"
    MAP
    0x8006D938
    Map_Xs16Ys16Ws16
    20000.00
    Curr
    0.00
    20000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_uChrgMapIn_mp
        Vltg_PA
        25
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_tiChrg
        InjTime_us
        6
        -13107.20
        13106.80

        FORMAT "%8.2"
        EXTENDED_LIMITS -13107.20 13106.80
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_iDisCh_MAP
    "Map: calculation of discharge current from discharge time and voltage"
    MAP
    0x8006D75C
    Map_Xs16Ys16Ws16
    60000.00
    Curr
    -30000.00
    30000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_uUpMapIn_mp
        Vltg_PA
        25
        -327.6800
        327.6700

        FORMAT "%8.4"
        EXTENDED_LIMITS -327.6800 327.6700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_tiDisCh
        InjTime_us
        6
        0.00
        400.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -13107.20 13106.80
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_iPIMax_C
    "Upper limit for dischargecurrent pulse pause time"
    VALUE
    0x8006D728
    Val_Ws16
    20000.00
    Curr
    -10000.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_iPIMin_C
    "Lower limit for dischargecurrent pulse pause time"
    VALUE
    0x8006D72A
    Val_Ws16
    20000.00
    Curr
    -10000.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_ITGov_CSTR.Ki_C
    "I-prameter of discharge time governor / Ki_C factor within the window"
    VALUE
    0x8006D72C
    Kw_Ws32
    4999999.99884
    Ki_InjTime_us2Curr
    -2500000.00000
    2499999.99884

    FORMAT "%13.5"
    EXTENDED_LIMITS -2500000.00000 2499999.99884
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_ITGov_CSTR.KiPos_C
    "I-prameter of discharge time governor / Ki_C factor above the window"
    VALUE
    0x8006D730
    Kw_Ws32
    4999999.99884
    Ki_InjTime_us2Curr
    -2500000.00000
    2499999.99884

    FORMAT "%13.5"
    EXTENDED_LIMITS -2500000.00000 2499999.99884
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_ITGov_CSTR.KiNeg_C
    "I-prameter of discharge time governor / Ki_C factor below the window"
    VALUE
    0x8006D734
    Kw_Ws32
    4999999.99884
    Ki_InjTime_us2Curr
    -2500000.00000
    2499999.99884

    FORMAT "%13.5"
    EXTENDED_LIMITS -2500000.00000 2499999.99884
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_ITGov_CSTR.WinPos_C
    "I-prameter of discharge time governor / Upper border of the window"
    VALUE
    0x8006D738
    Kw_Ws32
    1717986918.00
    InjTime_us
    -858993459.200
    858993458.800

    FORMAT "%13.3"
    EXTENDED_LIMITS -858993459.200 858993458.800
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_ITGov_CSTR.WinNeg_C
    "I-prameter of discharge time governor / Lower border of the window"
    VALUE
    0x8006D73C
    Kw_Ws32
    1717986918.00
    InjTime_us
    -858993459.200
    858993458.800

    FORMAT "%13.3"
    EXTENDED_LIMITS -858993459.200 858993458.800
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_IVltgGov_CSTR.Ki_C
    "I-values if actuator voltage governor / Ki_C factor within the window"
    VALUE
    0x8006DBB4
    Kw_Ws32
    1999999.99953
    Ki_Vltg_PA2Vltg_PA
    -1000000.00000
    999999.999534

    FORMAT "%13.5"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_IVltgGov_CSTR.KiPos_C
    "I-values if actuator voltage governor / Ki_C factor above the window"
    VALUE
    0x8006DBB8
    Kw_Ws32
    1999999.99953
    Ki_Vltg_PA2Vltg_PA
    -1000000.00000
    999999.999534

    FORMAT "%13.5"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_IVltgGov_CSTR.KiNeg_C
    "I-values if actuator voltage governor / Ki_C factor below the window"
    VALUE
    0x8006DBBC
    Kw_Ws32
    1999999.99953
    Ki_Vltg_PA2Vltg_PA
    -1000000.00000
    999999.999534

    FORMAT "%13.5"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_IVltgGov_CSTR.WinPos_C
    "I-values if actuator voltage governor / Upper border of the window"
    VALUE
    0x8006DBC0
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_IVltgGov_CSTR.WinNeg_C
    "I-values if actuator voltage governor / Lower border of the window"
    VALUE
    0x8006DBC4
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_mskTGov_C
    "Inhibit mask for discharge time governor"
    VALUE
    0x8006D740
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_mskVltgGov_C
    "Inhibit mask for vlotage governor"
    VALUE
    0x8006DBC8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_pRC_CA
    "Remote value of IVCtl_p (injection type specific)"
    VAL_BLK
    0x8006DAA6
    ValA_Ws16
    2100000.
    Pres_Rail
    0.00
    2100000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    
    NUMBER 8

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PTGov_CSTR.Kp_C
    "P-parameters for discharge time governor / Proportional factor Kp_C within window"
    VALUE
    0x8006D744
    Kw_Ws32
    327679.999924
    Kp_InjTime_us2Curr
    -163840.000000
    163839.999924

    FORMAT "%13.6"
    EXTENDED_LIMITS -163840.000000 163839.999924
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PTGov_CSTR.KpPos_C
    "P-parameters for discharge time governor / Proportional factor Kp_C above positive window border"
    VALUE
    0x8006D748
    Kw_Ws32
    327679.999924
    Kp_InjTime_us2Curr
    -163840.000000
    163839.999924

    FORMAT "%13.6"
    EXTENDED_LIMITS -163840.000000 163839.999924
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PTGov_CSTR.KpNeg_C
    "P-parameters for discharge time governor / Proportional factor Kp_C below negative window border"
    VALUE
    0x8006D74C
    Kw_Ws32
    327679.999924
    Kp_InjTime_us2Curr
    -163840.000000
    163839.999924

    FORMAT "%13.6"
    EXTENDED_LIMITS -163840.000000 163839.999924
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PTGov_CSTR.WinPos_C
    "P-parameters for discharge time governor / Positive window border"
    VALUE
    0x8006D750
    Kw_Ws32
    1717986918.00
    InjTime_us
    -858993459.200
    858993458.800

    FORMAT "%13.3"
    EXTENDED_LIMITS -858993459.200 858993458.800
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PTGov_CSTR.WinNeg_C
    "P-parameters for discharge time governor / Negative window border"
    VALUE
    0x8006D754
    Kw_Ws32
    1717986918.00
    InjTime_us
    -858993459.200
    858993458.800

    FORMAT "%13.3"
    EXTENDED_LIMITS -858993459.200 858993458.800
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PVltgGov_CSTR.Kp_C
    "P-Values of actuator voltage governor / Proportional factor Kp_C within window"
    VALUE
    0x8006DBCC
    Kw_Ws32
    131071.999969
    Kp_Vltg_PA2Vltg_PA
    -65536.0000000
    65535.9999695

    FORMAT "%13.7"
    EXTENDED_LIMITS -65536.0000000 65535.9999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PVltgGov_CSTR.KpPos_C
    "P-Values of actuator voltage governor / Proportional factor Kp_C above positive window border"
    VALUE
    0x8006DBD0
    Kw_Ws32
    131071.999969
    Kp_Vltg_PA2Vltg_PA
    -65536.0000000
    65535.9999695

    FORMAT "%13.7"
    EXTENDED_LIMITS -65536.0000000 65535.9999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PVltgGov_CSTR.KpNeg_C
    "P-Values of actuator voltage governor / Proportional factor Kp_C below negative window border"
    VALUE
    0x8006DBD4
    Kw_Ws32
    131071.999969
    Kp_Vltg_PA2Vltg_PA
    -65536.0000000
    65535.9999695

    FORMAT "%13.7"
    EXTENDED_LIMITS -65536.0000000 65535.9999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PVltgGov_CSTR.WinPos_C
    "P-Values of actuator voltage governor / Positive window border"
    VALUE
    0x8006DBD8
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_PVltgGov_CSTR.WinNeg_C
    "P-Values of actuator voltage governor / Negative window border"
    VALUE
    0x8006DBDC
    Kw_Ws32
    42949672.9500
    Vltg_PA
    -21474836.4800
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_swtIChrgRC_C
    "Switch:The charge-up current limit is set to remote values IVCtl_iChrgRC_CA"
    VALUE
    0x8006DAB6
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_swtPRC_C
    "Switch: IVCtl_p is set by remote value IVCtl_pRC_CA (injection type specific)"
    VALUE
    0x8006DAB7
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_tiChrg_CUR
    "curve: calculation of IVCtl_tiChrg from IVCtl_p"
    CURVE
    0x8006D8CA
    Cur_Xs16Ws16
    400.0000
    InjTime_us
    0.00
    400.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        4
        -3276800.
        3276700.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_tiDiffOBDDvt_C
    "Allowed control deviation of discharge time for OBD monitoring"
    VALUE
    0x8006D758
    Val_Ws16
    100.0000
    InjTime_us
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_tiDisCh_CUR
    "curve: calculation of IVCtl_tiDisCh from IVCtl_p"
    CURVE
    0x8006D8DC
    Cur_Xs16Ws16
    400.0000
    InjTime_us
    0.00
    400.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        RailP_pFlt
        Pres_Rail
        4
        -3276800.
        3276700.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_tiPseChrg_CUR
    "curve: calculation of IVCtl_tiPseChrg from IVCtl_tiChrg"
    CURVE
    0x8006D8EE
    Cur_Xs16Ws16
    18.00000
    Time_PzoChrgPse
    2.000000
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_tiChrg
        InjTime_us
        2
        0.00
        400.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -13107.20 13106.80
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_tiPseDisCh_CUR
    "curve: calculation of IVCtl_tiPseDisCh from IVCtl_tiDisCh"
    CURVE
    0x8006D8F8
    Cur_Xs16Ws16
    18.00000
    Time_PzoChrgPse
    2.000000
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_tiDisCh
        InjTime_us
        2
        0.00
        400.0000

        FORMAT "%8.4"
        EXTENDED_LIMITS -13107.20 13106.80
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_tiStrtMax_C
    "switching time to actuator start voltage"
    VALUE
    0x8006DCC8
    Val_Ws16
    60000.00
    Time_ms
    0.00
    60000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uCorPreCtl_CUR
    "Curve for pre-control voltage"
    CURVE
    0x8006DAB8
    Cur_Xs16Ws16
    20.00000
    Vltg_PA
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        20
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uDiffUpOBDDvt_C
    "OBD limit for IVCtl_VltgGov"
    VALUE
    0x8006DBE0
    Val_Ws16
    20.00000
    Vltg_PA
    0.00
    20.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uPIMax_C
    "limitation of maximum parameter for PI"
    VALUE
    0x8006DBE2
    Val_Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uPIMin_C
    "limitation of minimum parameter for PI"
    VALUE
    0x8006DBE4
    Val_Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress0_CUR
    "Curve of setpoint voltage for IVA-class 0"
    CURVE
    0x8006DBE8
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress10_CUR
    "Curve of setpoint voltage for IVA-class 10"
    CURVE
    0x8006DBF6
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress11_CUR
    "Curve of setpoint voltage for IVA-class 11"
    CURVE
    0x8006DC04
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress12_CUR
    "Curve of setpoint voltage for IVA-class 12"
    CURVE
    0x8006DC12
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress13_CUR
    "Curve of setpoint voltage for IVA-class 13"
    CURVE
    0x8006DC20
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress14_CUR
    "Curve of setpoint voltage for IVA-class 14"
    CURVE
    0x8006DC2E
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress15_CUR
    "Curve of setpoint voltage for IVA-class 15"
    CURVE
    0x8006DC3C
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        -3276800.
        3276700.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress1_CUR
    "Curve of setpoint voltage for IVA-class 1"
    CURVE
    0x8006DC4A
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress2_CUR
    "Curve of setpoint voltage for IVA-class 2"
    CURVE
    0x8006DC58
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress3_CUR
    "Curve of setpoint voltage for IVA-class 3"
    CURVE
    0x8006DC66
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress4_CUR
    "Curve of setpoint voltage for IVA-class 4"
    CURVE
    0x8006DC74
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress5_CUR
    "Curve of setpoint voltage for IVA-class 5"
    CURVE
    0x8006DC82
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress6_CUR
    "Curve of setpoint voltage for IVA-class 6"
    CURVE
    0x8006DC90
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress7_CUR
    "Curve of setpoint voltage for IVA-class 7"
    CURVE
    0x8006DC9E
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress8_CUR
    "Curve of setpoint voltage for IVA-class 8"
    CURVE
    0x8006DCAC
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uSetPress9_CUR
    "Curve of setpoint voltage for IVA-class 9"
    CURVE
    0x8006DCBA
    Cur_Xs16Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        3
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uUpOBDMax_CUR
    "Curve: rail pressure dependend upper OBD-limit for Up-voltage"
    CURVE
    0x8006DB0A
    Cur_Xs16Ws16
    200.0000
    Vltg_PA
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        20
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uUpOBDMin_CUR
    "Curve: rail pressure dependend llower OBD-limit for Up-voltage"
    CURVE
    0x8006DB5C
    Cur_Xs16Ws16
    200.0000
    Vltg_PA
    0.00
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVCtl_p
        Pres_Rail
        20
        0.00
        2100000.

        FORMAT "%8.0"
        EXTENDED_LIMITS -3276800. 3276700.
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVCtl_uUpStrt_C
    "Start-up voltage of piezo actuator"
    VALUE
    0x8006DCCA
    Val_Ws16
    210.0000
    Vltg_PA
    0.00
    210.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_facUPlaus_CA
    "factor for calculation of thres hold of actuator voltage plausibility check"
    VAL_BLK
    0x8006DD22
    ValA_Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_numMinCylOk_C
    "minimum number of intact cylinders required for engine operation"
    VALUE
    0x8006DCCC
    Val_Wu8
    8.000
    OneToOne
    0.00
    8.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_numTst_C
    "Number of test activations per cylinder"
    VALUE
    0x8006DD2A
    Val_Wu8
    19.00
    OneToOne
    1.000
    20.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_pTstMax_C
    "rail pressure limit for IVDia_Tst"
    VALUE
    0x8006DD2C
    Val_Ws16
    500000.0
    Pres_Rail
    0.00
    500000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_stDFCChp_C
    "DFC pattern of chip errors"
    VALUE
    0x8006DCCD
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_stDFCCylNoCls_C
    "DFC pattern of non classifible short circuit"
    VALUE
    0x8006DCCE
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_stErrDFC_CA
    "table for assigning a DFC to an error pattern calibrated in the pattern and select matrix"
    VAL_BLK
    0x8006DCD0
    ValA_Wu8
    255.000000000
    IVDia_stErrDFC
    0.00
    255.000000000

    FORMAT "%13.9"
    EXTENDED_LIMITS 0.00 255.000000000
    
    NUMBER 16

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_stErrMskPattern_CA
    "pattern matrix of injector diagnosis"
    VAL_BLK
    0x8006DCE0
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    
    NUMBER 16

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_stErrMskSelect_CA
    "select matrix of injector diagnosis"
    VAL_BLK
    0x8006DD00
    ValA_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    
    NUMBER 16

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_stTstActvRC_C
    "remote value for activation of short circuit and open load test"
    VALUE
    0x8006DD2E
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_stTstRC_C
    "remote value for IVDia_stTst"
    VALUE
    0x8006DD2F
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_swtStTstActvRC_C
    "switch for setting IVDia_stTstActv by remote value IVDia_stTstActvRC_C"
    VALUE
    0x8006DD30
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_swtStTstRC_C
    "switch for setting IVDia_stTst by remote value IVDia_stTstRC_C"
    VALUE
    0x8006DD31
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_tiChrgTst_C
    "charge time for IVDia_Tst"
    VALUE
    0x8006DD32
    Val_Ws16
    100.0000
    InjTime_us
    80.00000
    180.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_tiDisChTst_C
    "discharge time for IVDia_Tst"
    VALUE
    0x8006DD34
    Val_Ws16
    100.0000
    InjTime_us
    80.00000
    180.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_tiETTst_C
    "energizing time for IVDia_Tst"
    VALUE
    0x8006DD36
    Val_Ws16
    920.0000
    InjTime_us
    80.00000
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_uShCirChSwtThres_C
    "Bank voltage threshold to detect charge switch short circuit"
    VALUE
    0x8006DD20
    Val_Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_uUpHi1Thres_C
    ""
    VALUE
    0x8006DD28
    Val_Ws16
    500.0000
    Vltg_PA
    -250.0000
    250.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVDia_uUpTst_C
    "Up-Voltage for IVDia_Tst and IVH_SOPTst"
    VALUE
    0x8006DD38
    Val_Ws16
    100.0000
    Vltg_PA
    50.00000
    150.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVH_iChrgSOPT_C
    "Charging current for SOPT test energizings"
    VALUE
    0x8006DD3A
    Val_Ws16
    7500.000
    Curr
    1500.000
    9000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVH_iDisChSOPT_C
    "Discharge current for SOPT test energizings"
    VALUE
    0x8006DD3C
    Val_Ws16
    7500.000
    Curr
    1500.000
    9000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVH_tiBusyMax_C
    "maximum allowed busy duration (exceed the limit cause a busyerror detection)"
    VALUE
    0x8006DD46
    Val_Ws16
    800.0000
    InjTime_us
    0.00
    800.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVH_tiChrgSOPT_C
    "Charging time for SOPT test energizings"
    VALUE
    0x8006DD3E
    Val_Ws16
    150.0000
    InjTime_us
    50.00000
    200.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVH_tiETSOPT_C
    "Energizing time for IVH_SOPTst"
    VALUE
    0x8006DD40
    Val_Ws16
    200.0000
    InjTime_us
    100.0000
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVH_tiPseChrgSOPT_C
    "Charging pause times for SOPT test energizings"
    VALUE
    0x8006DD42
    Val_Ws16
    26.30000
    Time_PzoChrgPse
    3.700000
    30.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVH_tiPseDisChSOPT_C
    "Discharging pause times for SOPT test energizings"
    VALUE
    0x8006DD44
    Val_Ws16
    26.30000
    Time_PzoChrgPse
    3.700000
    30.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_cntSegDwnRunUpTst_C
    "number of segments for run down phase of run up test"
    VALUE
    0x8006DD84
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_cntSegUpRunUpTst_C
    "number of segments for run up phase of run up test"
    VALUE
    0x8006DD86
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_cntSegWaitRunUpTst_C
    "number of segment to wait after number of segments for up phase were reached"
    VALUE
    0x8006DD88
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_nEngDiffComprTst_C
    "Allowed engine speed acceleration/deceleration as a condition for the measurement to begin"
    VALUE
    0x8006DD6C
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_nMaxRunUpTst_C
    "maximum engine speed to release run up test"
    VALUE
    0x8006DD8A
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_nMinComprTst_C
    "Minimum engine speed for the compression test to run"
    VALUE
    0x8006DD6E
    Val_Ws16
    10000.00
    EngN
    0.00
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_nMinRunUpTst_C
    "minimum engine speed to release run up test"
    VALUE
    0x8006DD8C
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_nStrtRunUpTst_C
    "speed threshold for start of run up phase"
    VALUE
    0x8006DD8E
    Val_Ws16
    9980.000
    EngN
    20.00000
    10000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_numSegOfs2_C
    "segmentoffset for the cylinder specific engine speed determination for mode B and C"
    VALUE
    0x8006DD80
    Val_Wu8
    11.00
    OneToOne
    0.00
    11.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_phiMI1DesRunUpTst_C
    "desired SOE angle-component of main injection 1 during run up test from dataset"
    VALUE
    0x8006DD90
    Val_Ws16
    49.98779
    AngleCrS
    -9.997559
    39.99023

    FORMAT "%8.5"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_phiPiI1DesRunUpTst_C
    "desired SOE angle-component of pilot injection 1 during run up test"
    VALUE
    0x8006DD92
    Val_Ws16
    99.99756
    AngleCrS
    0.00
    99.99756

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_phiPiI2DesRunUpTst_C
    "desired SOE angle-component of pilot injection 2 during run up test from dataset"
    VALUE
    0x8006DD94
    Val_Ws16
    99.99756
    AngleCrS
    0.00
    99.99756

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_phiPreTDCComprTst1_C
    "Farthest angle before TDC"
    VALUE
    0x8006DD70
    Val_Ws16
    299.9927
    AngleCrS
    -197.9956
    101.9971

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_phiPreTDCComprTst2_C
    "Nearest angle before TDC"
    VALUE
    0x8006DD72
    Val_Ws16
    299.9927
    AngleCrS
    -197.9956
    101.9971

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_phiPstTDCComprTst3_C
    "Nearest angle after TDC"
    VALUE
    0x8006DD74
    Val_Ws16
    330.0073
    AngleCrS
    -138.0103
    191.9971

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_phiPstTDCComprTst4_C
    "Farthest angle after TDC"
    VALUE
    0x8006DD76
    Val_Ws16
    330.0073
    AngleCrS
    -138.0103
    191.9971

    FORMAT "%8.4"
    EXTENDED_LIMITS -720.0000 719.9780
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_pSetPntRunUpTst_C
    "rail pressure setpoint during run up test"
    VALUE
    0x8006DD96
    Val_Ws16
    1800000.
    Pres_Rail
    0.00
    1800000.

    FORMAT "%8.0"
    EXTENDED_LIMITS -3276800. 3276700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_qPiI1DesRunUpTst_C
    "desired quantity of pilot injection 1 during run up test"
    VALUE
    0x8006DD98
    Val_Ws16
    10.00000
    InjMass
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_qPiI2DesRunUpTst_C
    "measured desired quantity of pilot injection 2 during run up test from dataset"
    VALUE
    0x8006DD9A
    Val_Ws16
    10.00000
    InjMass
    0.00
    10.00000

    FORMAT "%8.5"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_qSetUnBalRunUpTst_C
    "current injection quantity for run up test out of dataset"
    VALUE
    0x8006DD9C
    Val_Ws16
    327.6700
    InjMass
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_rEGRVlvRunUpTst_C
    "ratio of EGR during run up test"
    VALUE
    0x8006DD9E
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_rThrVlvRunUpTst_C
    "ratio of throttle valve during run up test from dataset"
    VALUE
    0x8006DDA0
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_rTrbChRunUpTst_C
    "ratio of turbo charger during run up test"
    VALUE
    0x8006DDA2
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_stCylChk_C
    "switch for the cylinder specific engine speed"
    VALUE
    0x8006DD81
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_stInjCharRunUpTst_C
    "injection characteristic during run up test"
    VALUE
    0x8006DDA4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_stMskCoEOMOpModeRunUpTst_C
    "status of operation mode during run up test"
    VALUE
    0x8006DDA6
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_swtNoChkRefRunUpTst_C
    "switch to disable some parts of monitoring of running conditions during run up test"
    VALUE
    0x8006DDA8
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_swtTrqLimRunUpTst_C
    "switch for limitation of torque"
    VALUE
    0x8006DDA9
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_tClntMinRunUpTst_C
    ""
    VALUE
    0x8006DDAA
    Val_Ws16
    3053.600
    Temp_Cels
    -50.04000
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_tiMaxComprTst_C
    "Maximum time duration of the compression test"
    VALUE
    0x8006DD78
    Val_Ws32
    42949672950.0
    Time_ms
    -21474836480.0
    21474836470.0

    FORMAT "%13.1"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_tiMaxRunUpTst_C
    "maximum running time for run up test"
    VALUE
    0x8006DDAC
    Val_Ws32
    65530.0000000
    Time_ms
    10.0000000000
    65540.0000000

    FORMAT "%13.7"
    EXTENDED_LIMITS -21474836480.0 21474836470.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_tiPiI1DesRunUpTst_C
    "desired SOE time-component of pilot injection 1 during run up test out of dataset"
    VALUE
    0x8006DDB0
    Val_Ws16
    13000.00
    InjTime_us
    0.00
    13000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_tiPiI2DesRunUpTst_C
    "desired SOE time-component of pilot injection 2 during run up test out of dataset"
    VALUE
    0x8006DDB2
    Val_Ws16
    13000.00
    InjTime_us
    0.00
    13000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -13107.20 13106.80
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_tiWaitRunUpTst_C
    "time for stabilization of railpressure during run up test"
    VALUE
    0x8006DDB4
    Val_Ws16
    65530.00
    Time_ms
    10.00000
    65540.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPlaus_uMinBattComprTst_C
    "Minimum battery voltage to start the compression test"
    VALUE
    0x8006DD7C
    Val_Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSIC_ctIntegAdjMax_C
    "upper limit of integrator adjustment"
    VALUE
    0x8006DD48
    Val_Wu8
    254.0
    OneToOne
    1.000
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSIC_uIntegLin_CUR
    "linearisation curve for voltage out put of integrator"
    CURVE
    0x8006DD4A
    Cur_Xs16Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVPSIC_uRawIntegLin_mp
        Volt
        2
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSIC_Vltg_SRC.uMin_C
    "class instance for injection valve powerstage IC apmlifyer adjunstment signal range check / Threshold for SRC -Min detection"
    VALUE
    0x8006DD54
    Kw_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSIC_Vltg_SRC.uMax_C
    "class instance for injection valve powerstage IC apmlifyer adjunstment signal range check / Threshold for SRC -Max detection"
    VALUE
    0x8006DD56
    Kw_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_stBufErrRC_C
    "remote value for IVPSply_stBufErr"
    VALUE
    0x8006DD62
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_stDCDCCoRC_C
    "remote value for IVPSply_stDCDCCo"
    VALUE
    0x8006DD63
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_swtDCDCErrRC_C
    "remote switch: simulate SPI errors on start of dc/dc converters"
    VALUE
    0x8006DD64
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_swtEnaDfcChSwt_C
    "enable the prevention of the start of DC/DC-converter because of a saved charging switch error"
    VALUE
    0x8006DD65
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_swtStBufErrRC_C
    "switch: IVPSply_stBufErr is set by remote value IVPSply_stBufErrRC_C"
    VALUE
    0x8006DD66
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_swtStDCDCCoRC_C
    "switch: IVPSply_stDCDCCo is set by remote value IVPSply_stDCDCCoRC_C"
    VALUE
    0x8006DD67
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_tiDCDCWait_C
    "Watchdog time waiting for charged buffer capacitor"
    VALUE
    0x8006DD68
    Val_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    IVPSply_uBufLin_CUR
    "linerisation curve for buffer voltage measurement"
    CURVE
    0x8006DD58
    Cur_Xs16Ws16
    282.2100
    Vltg_PA
    0.00
    282.2100

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        IVPSply_uBufRaw_mp
        Volt
        2
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU0_ATS.LimitTypeMsk_C
    "Actuator test LSU0_ATS / Tester demand monitoring enable mask for actuators"
    VALUE
    0x8006BDC8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU0_ATS.CnvNorm_C
    "Actuator test LSU0_ATS / Conversion norm used for conversion to/from internal scaling"
    VALUE
    0x8006BDC9
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU0_ATS.LowLim_C
    "Actuator test LSU0_ATS / Lower limit for monitoring"
    VALUE
    0x8006BDCA
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU0_ATS.UpLim_C
    "Actuator test LSU0_ATS / Upper limit for monitoring"
    VALUE
    0x8006BDCC
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU0_ATS.CnvFac_C
    "Actuator test LSU0_ATS / Factor used for conversion to/from internal scaling"
    VALUE
    0x8006BDD0
    Val_Ws32
    4294967295.00
    OneToOne
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU0_ATS.CnvOfs_C
    "Actuator test LSU0_ATS / Offset used for conversion to/from internal scaling"
    VALUE
    0x8006BDD4
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU0_ATS.DfltVal_C
    "Actuator test LSU0_ATS / Default value for standbytest"
    VALUE
    0x8006BDD6
    Val_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_AirPerTimeI.Ki_C
    "Structure for Air mass integration during overrun / Ki_C factor within the window"
    VALUE
    0x8006E80C
    Kw_Ws32
    4.99980524182
    Ki
    0.00
    4.99980524182

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_AirPerTimeI.KiPos_C
    "Structure for Air mass integration during overrun / Ki_C factor above the window"
    VALUE
    0x8006E810
    Kw_Ws32
    4.99980524182
    Ki
    0.00
    4.99980524182

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_AirPerTimeI.KiNeg_C
    "Structure for Air mass integration during overrun / Ki_C factor below the window"
    VALUE
    0x8006E814
    Kw_Ws32
    4.99980524182
    Ki
    0.00
    4.99980524182

    FORMAT "%13.11"
    EXTENDED_LIMITS -1000000.00000 999999.999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_AirPerTimeI.WinPos_C
    "Structure for Air mass integration during overrun / Upper border of the window"
    VALUE
    0x8006E818
    Kw_Ws32
    250.000000000
    AirMassPerTime
    223.000000000
    473.000000000

    FORMAT "%13.9"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_AirPerTimeI.WinNeg_C
    "Structure for Air mass integration during overrun / Lower border of the window"
    VALUE
    0x8006E81C
    Kw_Ws32
    250.000000000
    AirMassPerTime
    223.000000000
    473.000000000

    FORMAT "%13.9"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_BattHiDeb.tiHiLo_C
    "Debounce structure for high battery voltage check / Time for a High to Low transition"
    VALUE
    0x8006E694
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_BattHiDeb.tiLoHi_C
    "Debounce structure for high battery voltage check / Time for a Low to High transition"
    VALUE
    0x8006E696
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctMeasPresCompMax_C
    "Maximum value for the measurement counter for adaptive pressure compensation"
    VALUE
    0x8006EF30
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctSclFacDynChk_C
    "Scaling parameter for the debounce counts of O2 dynamic plausibility error when short diagnosis for LSU is active"
    VALUE
    0x8006EE8C
    Val_Wu8
    99.00
    OneToOne
    1.000
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctSclFacHtCoup_C
    "Scaling parameter for the debounce counts of heater coupling error when short diagnosis for LSU is active"
    VALUE
    0x8006E7D4
    Val_Wu8
    99.00
    OneToOne
    1.000
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctSclFacO2Clb_C
    "Scaling parameter for the debounce counts of O2 calibration errors when short diagnosis for LSU is active"
    VALUE
    0x8006E6F0
    Val_Wu8
    99.00
    OneToOne
    1.000
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctSclFacO2Plaus_C
    "Scaling parameter for the debounce counts of O2 plausibility errors when short diagnosis for LSU is active"
    VALUE
    0x8006EE8D
    Val_Wu8
    99.00
    OneToOne
    1.000
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctSclFacRiClb_C
    "Scaling parameter for the debounce counts of Ri calibration errors when short diagnosis for LSU is active"
    VALUE
    0x8006E76C
    Val_Wu8
    99.00
    OneToOne
    1.000
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctSclFacWireIP_C
    "Scaling parameter for the debounce counts of shunting error when short diagnosis for LSU is active"
    VALUE
    0x8006E7D5
    Val_Wu8
    99.00
    OneToOne
    1.000
    100.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ctWaitPresCompMax_C
    "Maximum value for the wait counter for adaptive pressure compensation"
    VALUE
    0x8006EF31
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_d2rIni_C
    "Initialization value for evaluation filter used in LSU adaptation"
    VALUE
    0x8006E820
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dcycHtMin_C
    "Protection duty cycle for heater"
    VALUE
    0x8006E8A0
    Val_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dcycMaxErr_C
    "Maximum heater duty cycle limitation in case of open load or short to ground errors of heater powerstage."
    VALUE
    0x8006E6C8
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dcycMax_C
    "Maximum heater duty cycle limitation in case of no open load and short to ground errors of heater powerstage."
    VALUE
    0x8006E6CA
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dcycMinGrad_C
    "Minimum change of duty cycle for activation of heater coupling check"
    VALUE
    0x8006E7D6
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_DcycRmp.Pos_C
    "Duty cycle ramp structure for lsu heater / Slope if the ramp has to be increased"
    VALUE
    0x8006E8A4
    Kw_Ws32
    327679.999847
    RmpDtyCyc
    0.00
    327679.999847

    FORMAT "%13.6"
    EXTENDED_LIMITS -327680.000000 327679.999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_DcycRmp.Neg_C
    "Duty cycle ramp structure for lsu heater / negative ramp slope"
    VALUE
    0x8006E8A8
    Kw_Ws32
    327679.999847
    RmpDtyCyc
    0.00
    327679.999847

    FORMAT "%13.6"
    EXTENDED_LIMITS -327680.000000 327679.999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dcycStrt_CUR
    "Inlet air temperature dependant curve for staring heater duty cycle calculation"
    CURVE
    0x8006E8AC
    Cur_Xs16Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_tAirStrt_mp
        Temp_Cels
        5
        -73.14000
        126.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dcycTstImp_C
    "The test dutycycle for sending the test impulse in case of short to battery error of non SPI (ex. BUK138) powerstages"
    VALUE
    0x8006E6CC
    Val_Ws16
    655.3500
    DtyCyc
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dmEGHtCoupActv_C
    "Exhaust flow upper threshold for preventing heater disable during shunting detection and heater coupling check"
    VALUE
    0x8006E7D8
    Val_Ws16
    1000.000
    AirMassPerTime
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dnEngSpdThresHi_C
    "Maximum allowed absolute gradient of engine speed to activate adaptive pressure compensation"
    VALUE
    0x8006EF32
    Val_Ws16
    2500.000
    EngNGrd
    0.00
    2500.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dNumHtCoup_C
    "Number of activations of heater coupling check needed for significant result"
    VALUE
    0x8006E7DA
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dpExhGsRefAvrgThres_C
    "Threshold for difference between p_0 and p_x to activate adaptive pressure compensation"
    VALUE
    0x8006EF34
    Val_Ws16
    550.0000
    Pres_hPa
    0.00
    550.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_dpExhGsThresHi_C
    "Maximum allowed absolute gradient of exhaust pressure to activate adaptive pressure compensation"
    VALUE
    0x8006EF36
    Val_Ws16
    450.0000
    PreshPa_sec
    0.00
    450.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_EvalMaxVal_C
    "Evaluation filter output maximum threshold above which it is decided that measured oxygen signal is disturbed during LSU adaptation"
    VALUE
    0x8006E822
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_EvalMinVal_C
    "Evaluation filter output minimum threshold below which it is decided that measured oxygen signal is not disturbed during LSU adaptation"
    VALUE
    0x8006E824
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facO2TempCorIni_C
    "Default temperature correction factor of the LSU"
    VALUE
    0x8006E826
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facO2TempCorMaxDvt_C
    "Maximum allowable deviation of temperature correction factor"
    VALUE
    0x8006E828
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facPresCompLean_CUR
    "Pressure compensation factor curve for lean combustion"
    CURVE
    0x8006EF38
    Cur_Xs16Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_pExhGasLstVal_mp
        Pres_hPa
        8
        -32768.00
        32767.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facPresCompRich_CUR
    "Pressure compensation factor curve rich combustion"
    CURVE
    0x8006EF5A
    Cur_Xs16Ws16
    7.999878
    Fact
    -4.000000
    3.999878

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_pExhGasLstVal_mp
        Pres_hPa
        8
        -32768.00
        32767.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -32768.00 32767.00
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facSclFacTExcMax_C
    "Scaling parameter for the debounce durations of heater control deviation MAX error when short diagnosis for LSU is active"
    VALUE
    0x8006E8C2
    Val_Wu16
    6.989990
    Fact
    1.000000
    7.989990

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 7.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facSclFacTExcMin_C
    "Scaling parameter for the debounce durations of heater control deviation MIN error when short diagnosis for LSU is active"
    VALUE
    0x8006E8C4
    Val_Wu16
    6.989990
    Fact
    1.000000
    7.989990

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 7.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facTempDepNom_C
    ""
    VALUE
    0x8006E82A
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_facUToRi_C
    "Factor for conversion of Ri voltage into Ri resistance"
    VALUE
    0x8006E76E
    Val_Ws16
    32.76750
    VoltToRes
    -16.38400
    16.38350

    FORMAT "%8.5"
    EXTENDED_LIMITS -16.38400 16.38350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_mAirAdapActv_C
    "Air mass accumulation threshold above which overrun learning is started"
    VAL_BLK
    0x8006E82C
    ValA_Ws16
    6553.500
    AirMass_2
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_mAirMaxTst_C
    "Upper air mass threshold for enabling O2 plausibility check when LSU service test diagnosis is active"
    VAL_BLK
    0x8006EE8E
    ValA_Ws16
    6553.500
    AirMassPerCyl
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_mAirMax_C
    "Upper air mass threshold for enabling O2 plausibility check"
    VAL_BLK
    0x8006EE94
    ValA_Ws16
    6553.500
    AirMassPerCyl
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_mAirMinTst_C
    "Lower air mass threshold for enabling O2 plausibility check when LSU service test diagnosis is active"
    VAL_BLK
    0x8006EE9A
    ValA_Ws16
    6553.500
    AirMassPerCyl
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_mAirMin_C
    "Lower air mass threshold for enabling O2 plausibility check"
    VAL_BLK
    0x8006EEA0
    ValA_Ws16
    6553.500
    AirMassPerCyl
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_mAirPlausEnaTst_CA
    "Air mass threshold for enabling plausibility of O2 in the current engine operating point in short diagnosis."
    VAL_BLK
    0x8006EEA6
    ValA_Ws16
    6553.500
    AirMass_2
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_mAirPlausEna_CA
    "Air mass threshold for enabling plausibility of O2 in the current engine operating point"
    VAL_BLK
    0x8006EEA8
    ValA_Ws16
    6553.500
    AirMass_2
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nHtCtlEna_C
    "Minimum engine speed for activation of heater ramp"
    VALUE
    0x8006E8C6
    Val_Ws16
    16383.50
    EngN
    0.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMaxClb1_C
    "Upper engine speed threshold in first operating point to enable CJ125 calibration"
    VALUE
    0x8006E880
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMaxClb2_C
    "Upper engine speed threshold in second operating point to enable CJ125 calibration"
    VALUE
    0x8006E882
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMaxTst_C
    "Upper engine speed threshold for enabling O2 plausibility check when short diagnosis for LSU is active."
    VAL_BLK
    0x8006EEAA
    ValA_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMax_C
    "Upper engine speed threshold for enabling O2 plausibility check"
    VAL_BLK
    0x8006EEB0
    ValA_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMinChkDyn_C
    "Engine speed above which O2 dynamics is activated"
    VALUE
    0x8006EEB6
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMinClb1_C
    "Lower engine speed threshold in first operating point to enable CJ125 calibration"
    VALUE
    0x8006E884
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMinClb2_C
    "Lower engine speed threshold in second operating point to enable CJ125 calibration"
    VALUE
    0x8006E886
    Val_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMinTst_C
    "Lower engine speed threshold for enabling O2 plausibility check when short diagnosis for LSU is active"
    VAL_BLK
    0x8006EEB8
    ValA_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_nMin_C
    "Lower engine speed threshold for enabling O2 plausibility check"
    VAL_BLK
    0x8006EEBE
    ValA_Ws16
    32767.50
    EngN
    -16384.00
    16383.50

    FORMAT "%8.2"
    EXTENDED_LIMITS -16384.00 16383.50
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numAirTempSel_C
    "Index of air temperature field to be selected for starter dutycycle calculation- 0:CACDsT, 1:AFST, 2:EnvT"
    VALUE
    0x8006E8C8
    Val_Wu8
    2.000
    OneToOne
    0.00
    2.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numCalcRegrThres_C
    "Threshold for n to calculate regression"
    VALUE
    0x8006EF7C
    Val_Wu8
    10.00
    OneToOne
    0.00
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numCoefRegrThres_C
    "Threshold for R² to activate adaptive pressure compensation"
    VALUE
    0x8006EF7E
    Val_Ws16
    1.000000
    Fact100
    0.00
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numEGFld_CA
    "Array for selecting the modelled pressure for the corresponding Lambda sensor"
    VAL_BLK
    0x8006EF80
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numEGSel_CA
    "Array for position of exhaust manifold for flow model selection"
    VAL_BLK
    0x8006E7DC
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numPresVltgMax_C
    "Predicted maximum input of exhaust pressure * LSU voltage"
    VALUE
    0x8006EF84
    Val_Ws32
    429496729.500
    VoltPres
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numRegrDfl_CA
    "Default value for number of inputs to the regression"
    VAL_BLK
    0x8006EF88
    ValA_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numRegrThres_C
    "Threshold for n to activate adaptive pressure compensation"
    VALUE
    0x8006EF8A
    Val_Ws16
    3000.000
    OneToOne
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numSqrtRegr_CUR
    "Curve to calculate square roo"
    CURVE
    0x8006EF8C
    Cur_Xs16Ws16
    6.553500
    Fact_10000
    -3.276800
    3.276700

    FORMAT "%8.6"
    EXTENDED_LIMITS -3.276800 3.276700
    READ_ONLY

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_numArgSqrt_mp
        Fact_10000
        7
        -3.276800
        3.276700

        FORMAT "%8.6"
        EXTENDED_LIMITS -3.276800 3.276700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numStdTempAdap_C
    "Number of adaptations at standard temperature before an adaptation can take place at lower temperature"
    VALUE
    0x8006E82E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numSumPresDfl_CA
    "Default value for the sum of mean values pExhGs"
    VAL_BLK
    0x8006EFAC
    ValA_Ws32
    429496729.500
    PreshPa_FnReso
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numSumPresSqDfl_CA
    "Default value for the sum of square mean values pExhGs"
    VAL_BLK
    0x8006EFB0
    ValA_Ws32
    4294967295.00
    PreshPa_Sq
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numSumPresVltgDfl_CA
    "Default value for the sum of mean values pExhGs * mean values uO2RawOfsCor"
    VAL_BLK
    0x8006EFB4
    ValA_Ws32
    429496729.500
    VoltPres
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numSumVltgDfl_CA
    "Default value for the sum of mean values uO2RawOfsCor"
    VAL_BLK
    0x8006EFB8
    ValA_Ws32
    429496729.500
    Volt_FnReso1
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_numSumVltgSqDfl_CA
    "Default value for the sum of square mean values uO2RawOfsCor"
    VAL_BLK
    0x8006EFBC
    ValA_Ws32
    4294967295.00
    Volt_Sq
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_OvrRunDeb.tiHiLo_C
    "Debounce structure for over run condition / Time for a High to Low transition"
    VALUE
    0x8006E698
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_OvrRunDeb.tiLoHi_C
    "Debounce structure for over run condition / Time for a Low to High transition"
    VALUE
    0x8006E69A
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_pExhGsSqMax_C
    "Predicted maximum square input of exhaust pressure at LSU"
    VALUE
    0x8006EFC0
    Val_Ws32
    4294967295.00
    PreshPa_Sq
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_pExhO2MaxDiaDis_C
    "Exhaust gas pressure threshold above which O2 SRC max is disabled"
    VALUE
    0x8006E6F2
    Val_Ws16
    65535.00
    Pres_hPa
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_pExhPresOfs_C
    "Offset of exhaust pressure considered while adaptive pressure compensation"
    VALUE
    0x8006EFC4
    Val_Ws16
    6553.500
    PreshPa_FnReso
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_pKPresCompMax_C
    "Maximum allowed k-value"
    VALUE
    0x8006EFC6
    Val_Ws16
    3000.000
    Pres_hPa
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_pKPresCompMin_C
    "Minimum allowed k-value"
    VALUE
    0x8006EFC8
    Val_Ws16
    3000.000
    Pres_hPa
    0.00
    3000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Pwm.tiPer_C
    "LSU heater PWM signal structure / Reference value for period duration (small type to limit dynamic range)"
    VALUE
    0x8006E6CE
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Pwm.stLvl_C
    "LSU heater PWM signal structure / Reference value for phase relationship in period units"
    VALUE
    0x8006E6D0
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Pwm.rMaxDty_C
    "LSU heater PWM signal structure / Reference value for maximum duty cycle"
    VALUE
    0x8006E6D2
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Pwm.rPerUn_C
    "LSU heater PWM signal structure / us per Pwmout_tiPeriod unit (1==us, 1000=ms)"
    VALUE
    0x8006E6D4
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Pwm.tiPh_C
    "LSU heater PWM signal structure / Active level (0 or 1)"
    VALUE
    0x8006E6D6
    Kw_Ws16
    65535.00
    OneToOne
    -32768.00
    32767.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_PwmOut.rMin_C
    "Structure containing the calibration parameters for heater powerstage diagnosis / Minimum threshold for the duty cycle"
    VALUE
    0x8006E6D8
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_PwmOut.rMax_C
    "Structure containing the calibration parameters for heater powerstage diagnosis / Maximum threshold for the duty cycle"
    VALUE
    0x8006E6DA
    Kw_Ws16
    100.0000
    DtyCyc
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_PwmOut.tiBtwTstSCB_C
    "Structure containing the calibration parameters for heater powerstage diagnosis / Time between tests for SCB error"
    VALUE
    0x8006E6DC
    Kw_Ws16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_PwmOut.tiBtwTstOT_C
    "Structure containing the calibration parameters for heater powerstage diagnosis / Time between tests for OT error"
    VALUE
    0x8006E6DE
    Kw_Ws16
    327.6700
    Time_s
    0.00
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_PwmOut.numTstMax_C
    "Structure containing the calibration parameters for heater powerstage diagnosis / Maximum number of tests allowed on permanent defect"
    VALUE
    0x8006E6E0
    Kw_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_PwmOut.swtBattCor_C
    "Structure containing the calibration parameters for heater powerstage diagnosis / Switch to enable battery correction"
    VALUE
    0x8006E6E2
    Kw_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_PwmOut.swtPsInv_C
    "Structure containing the calibration parameters for heater powerstage diagnosis / Power stage output inversion status"
    VALUE
    0x8006E6E3
    Kw_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qDiffMax_C
    "Tolerance range for the injection quantity inorder to detect steady state while dynamics check"
    VALUE
    0x8006EEC4
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMaxClb1_C
    "Upper fuel quantity threshold in first operating point to enable CJ125 calibration [mg/stroke]"
    VALUE
    0x8006E888
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMaxClb2_C
    "Upper fuel quantity threshold in second operating point to enable CJ125 calibration"
    VALUE
    0x8006E88A
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMaxTst_C
    "Upper injection quantity threshold for enabling O2 plausibility check when short diagnosis for LSU is active."
    VAL_BLK
    0x8006EEC6
    ValA_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMax_C
    "Upper injection quantity threshold for enabling O2 plausibility check"
    VAL_BLK
    0x8006EECC
    ValA_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMinClb1_C
    "Lower fuel quantity threshold in first operating point to enable CJ125 calibration [mg/stroke]"
    VALUE
    0x8006E88C
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMinClb2_C
    "Lower fuel quantity threshold in second operating point to enable CJ125 calibration"
    VALUE
    0x8006E88E
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMinTst_C
    "Lower injection quantity threshold for enabling O2 plausibility check when short diagnosis of LSU is active"
    VAL_BLK
    0x8006EED2
    ValA_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qMin_C
    "Lower injection quantity threshold for enabling O2 plausibility check"
    VAL_BLK
    0x8006EED8
    ValA_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qThresChkDyn_C
    "Injection quantity limit above which O2 dynamics check state changes to check_op_point"
    VALUE
    0x8006EEDE
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_qThresOvrRun_C
    "Minimum injection quantity for detecting over run during dynamics check"
    VALUE
    0x8006EEE0
    Val_Ws16
    655.3500
    InjMass
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_resRiClbDvtMax_C
    "Limiter maximum threshold for LSU_resRiClbRaw_mp"
    VALUE
    0x8006E770
    Val_Ws16
    6553.500
    Resist
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_resRiClbDvtMin_C
    "Limiter minimum threshold for LSU_resRiClbRaw_mp"
    VALUE
    0x8006E772
    Val_Ws16
    6553.500
    Resist
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_resRiClbMax_C
    "maximum limit for Ri calibration error"
    VALUE
    0x8006E774
    Val_Ws16
    6553.500
    Resist
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_resRiClbMin_C
    "minimum limit for Ri calibration error"
    VALUE
    0x8006E776
    Val_Ws16
    6553.500
    Resist
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_resRiClbRef_C
    "Rreference vaule for Ri calibration"
    VALUE
    0x8006E778
    Val_Ws16
    6553.500
    Resist
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_resRiMaxGrad_C
    "Maximum change of internal resistance for activation of heater coupling check"
    VALUE
    0x8006E7DE
    Val_Ws16
    6553.500
    Resist
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_RiDeb.tiHiLo_C
    "Debounce structure for Ri voltage check against the threshold for the detection of the OL at UN and VG / Time for a High to Low transition"
    VALUE
    0x8006E69C
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_RiDeb.tiLoHi_C
    "Debounce structure for Ri voltage check against the threshold for the detection of the OL at UN and VG / Time for a Low to High transition"
    VALUE
    0x8006E69E
    Kw_Ws16
    655350.0
    TimeDeb
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rLamRec_CUR
    "Curve for conversion from O2 concentration to reciprocal lambda value"
    CURVE
    0x8006E830
    Cur_Xs16Ws16
    65.53500
    lambdaRecVal
    -32.76800
    32.76700

    FORMAT "%8.5"
    EXTENDED_LIMITS -32.76800 32.76700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_rO2AdptLastLSU_mp
        O2
        12
        -0.3276800
        0.3276700

        FORMAT "%9.7"
        EXTENDED_LIMITS -0.3276800 0.3276700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2IsolChkMax_C
    "maximum of permitted O2 display at cold sensor during shunting detection"
    VALUE
    0x8006E7E0
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2IsolChkMin_C
    "minimum of permitted O2 display at cold sensor during shunting detection"
    VALUE
    0x8006E7E2
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2Lmbd1Thres_C
    "Minimum O2 ratio threshold for lambda=1 detection"
    VALUE
    0x8006E6A0
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2MaxVar_C
    "If calculated O2 ratio is within this tolerance width, steady state operation is detected, and O2 plausibility is enabled."
    VALUE
    0x8006EEE2
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2Min_C
    "If calculated O2 ratio is less than this threshold (rich mixture detected) then lambda=1 detection is not carried out"
    VALUE
    0x8006E6A2
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2NegDvtTst_C
    "Negative allowed deviation from calculated O2 concentration for O2 plausibility check when LSU service test diagnosis is active."
    VAL_BLK
    0x8006EEE4
    ValA_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2NegDvt_C
    "Negative allowed deviation from calculated O2 concentration for O2 plausibility check"
    VAL_BLK
    0x8006EEEA
    ValA_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2PosDvtTst_C
    "Positive allowed deviation from calculated O2 concentration for O2 plausibility check when LSU service test diagnosis is active."
    VAL_BLK
    0x8006EEF0
    ValA_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2PosDvt_C
    "Positive allowed deviation from calculated O2 concentration for O2 plausibility check"
    VAL_BLK
    0x8006EEF6
    ValA_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    
    NUMBER 3

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2SwtPresComp_C
    "O2 ratio threshold to decide which MAP should be used for pressure compensation, lean or rich."
    VALUE
    0x8006EFCA
    Val_Ws16
    0.6553500
    O2
    -0.3276800
    0.3276700

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_rO2Transf_CUR
    "Curve for conversion of O2 voltage to O2 ratio"
    CURVE
    0x8006E6F4
    Cur_Xs16Ws16
    0.6250000
    O2
    -0.3000000
    0.3250000

    FORMAT "%9.7"
    EXTENDED_LIMITS -0.3276800 0.3276700
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_uO2RawOfsCorLast_mp
        Volt
        15
        -1600.000
        4000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1DT1.T1_C
    "D structure for heater governor of the sensor before the catalyst / Reciprocal of time delay T1 ( 2^32 / T1; T1 in same quantisation as Dt)"
    VALUE
    0x8006E8CC
    Kw_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1DT1.Kd_C
    "D structure for heater governor of the sensor before the catalyst / Differential factor Kd = Td/T1"
    VALUE
    0x8006E8D0
    Kw_Ws32
    6553.59999847
    Kd_Temp_Kelv2Dcyc
    -3276.80000000
    3276.79999847

    FORMAT "%13.8"
    EXTENDED_LIMITS -3276.80000000 3276.79999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1I.Ki_C
    "I structure for heater governor of the sensor before the catalyst / Ki_C factor within the window"
    VALUE
    0x8006E8D4
    Kw_Ws32
    199999.999953
    Ki_Temp_Kelv2Dcyc
    -100000.000000
    99999.9999534

    FORMAT "%13.6"
    EXTENDED_LIMITS -100000.000000 99999.9999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1I.KiPos_C
    "I structure for heater governor of the sensor before the catalyst / Ki_C factor above the window"
    VALUE
    0x8006E8D8
    Kw_Ws32
    199999.999953
    Ki_Temp_Kelv2Dcyc
    -100000.000000
    99999.9999534

    FORMAT "%13.6"
    EXTENDED_LIMITS -100000.000000 99999.9999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1I.KiNeg_C
    "I structure for heater governor of the sensor before the catalyst / Ki_C factor below the window"
    VALUE
    0x8006E8DC
    Kw_Ws32
    199999.999953
    Ki_Temp_Kelv2Dcyc
    -100000.000000
    99999.9999534

    FORMAT "%13.6"
    EXTENDED_LIMITS -100000.000000 99999.9999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1I.WinPos_C
    "I structure for heater governor of the sensor before the catalyst / Upper border of the window"
    VALUE
    0x8006E8E0
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1I.WinNeg_C
    "I structure for heater governor of the sensor before the catalyst / Lower border of the window"
    VALUE
    0x8006E8E4
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1P.Kp_C
    "P structure heater governor of the sensor before the catalyst / Proportional factor Kp_C within window"
    VALUE
    0x8006E8E8
    Kw_Ws32
    13107.1999969
    Kp_Temp_Kelv2Dcyc
    -6553.60000000
    6553.59999695

    FORMAT "%13.8"
    EXTENDED_LIMITS -6553.60000000 6553.59999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1P.KpPos_C
    "P structure heater governor of the sensor before the catalyst / Proportional factor Kp_C above positive window border"
    VALUE
    0x8006E8EC
    Kw_Ws32
    13107.1999969
    Kp_Temp_Kelv2Dcyc
    -6553.60000000
    6553.59999695

    FORMAT "%13.8"
    EXTENDED_LIMITS -6553.60000000 6553.59999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1P.KpNeg_C
    "P structure heater governor of the sensor before the catalyst / Proportional factor Kp_C below negative window border"
    VALUE
    0x8006E8F0
    Kw_Ws32
    13107.1999969
    Kp_Temp_Kelv2Dcyc
    -6553.60000000
    6553.59999695

    FORMAT "%13.8"
    EXTENDED_LIMITS -6553.60000000 6553.59999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1P.WinPos_C
    "P structure heater governor of the sensor before the catalyst / Positive window border"
    VALUE
    0x8006E8F4
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens1P.WinNeg_C
    "P structure heater governor of the sensor before the catalyst / Negative window border"
    VALUE
    0x8006E8F8
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2DT1.T1_C
    "D structure for heater governor of the sensor after the catalyst / Reciprocal of time delay T1 ( 2^32 / T1; T1 in same quantisation as Dt)"
    VALUE
    0x8006E8FC
    Kw_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2DT1.Kd_C
    "D structure for heater governor of the sensor after the catalyst / Differential factor Kd = Td/T1"
    VALUE
    0x8006E900
    Kw_Ws32
    6553.59999847
    Kd_Temp_Kelv2Dcyc
    -3276.80000000
    3276.79999847

    FORMAT "%13.8"
    EXTENDED_LIMITS -3276.80000000 3276.79999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2I.Ki_C
    "I structure for heater governor of the sensor after the catalyst / Ki_C factor within the window"
    VALUE
    0x8006E904
    Kw_Ws32
    199999.999953
    Ki_Temp_Kelv2Dcyc
    -100000.000000
    99999.9999534

    FORMAT "%13.6"
    EXTENDED_LIMITS -100000.000000 99999.9999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2I.KiPos_C
    "I structure for heater governor of the sensor after the catalyst / Ki_C factor above the window"
    VALUE
    0x8006E908
    Kw_Ws32
    199999.999953
    Ki_Temp_Kelv2Dcyc
    -100000.000000
    99999.9999534

    FORMAT "%13.6"
    EXTENDED_LIMITS -100000.000000 99999.9999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2I.KiNeg_C
    "I structure for heater governor of the sensor after the catalyst / Ki_C factor below the window"
    VALUE
    0x8006E90C
    Kw_Ws32
    199999.999953
    Ki_Temp_Kelv2Dcyc
    -100000.000000
    99999.9999534

    FORMAT "%13.6"
    EXTENDED_LIMITS -100000.000000 99999.9999534
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2I.WinPos_C
    "I structure for heater governor of the sensor after the catalyst / Upper border of the window"
    VALUE
    0x8006E910
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2I.WinNeg_C
    "I structure for heater governor of the sensor after the catalyst / Lower border of the window"
    VALUE
    0x8006E914
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2P.Kp_C
    "P structure heater governor of the sensor after the catalyst / Proportional factor Kp_C within window"
    VALUE
    0x8006E918
    Kw_Ws32
    13107.1999969
    Kp_Temp_Kelv2Dcyc
    -6553.60000000
    6553.59999695

    FORMAT "%13.8"
    EXTENDED_LIMITS -6553.60000000 6553.59999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2P.KpPos_C
    "P structure heater governor of the sensor after the catalyst / Proportional factor Kp_C above positive window border"
    VALUE
    0x8006E91C
    Kw_Ws32
    13107.1999969
    Kp_Temp_Kelv2Dcyc
    -6553.60000000
    6553.59999695

    FORMAT "%13.8"
    EXTENDED_LIMITS -6553.60000000 6553.59999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2P.KpNeg_C
    "P structure heater governor of the sensor after the catalyst / Proportional factor Kp_C below negative window border"
    VALUE
    0x8006E920
    Kw_Ws32
    13107.1999969
    Kp_Temp_Kelv2Dcyc
    -6553.60000000
    6553.59999695

    FORMAT "%13.8"
    EXTENDED_LIMITS -6553.60000000 6553.59999695
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2P.WinPos_C
    "P structure heater governor of the sensor after the catalyst / Positive window border"
    VALUE
    0x8006E924
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_Sens2P.WinNeg_C
    "P structure heater governor of the sensor after the catalyst / Negative window border"
    VALUE
    0x8006E928
    Kw_Ws32
    429496729.500
    TempDiff_Kelv
    -214748364.800
    214748364.700

    FORMAT "%13.3"
    EXTENDED_LIMITS -214748364.800 214748364.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stChpClbActv_C
    "Activation flag for O2 and Ri calibration"
    VALUE
    0x8006E890
    Val_Wu8
    3.000
    OneToOne
    0.00
    3.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stHtDis_C
    "Application parameter to switch of heater depending on the engine battery conditions"
    VALUE
    0x8006E6E4
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stHtrPwrStgSel_C
    "Status word whether TLE6232(1)/BUK(0) is installed for powerstage."
    VALUE
    0x8006E6E5
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stMonActv_C
    "Activation flags for lambda sensor higher level diagnostics"
    VALUE
    0x8006EEFC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stMskEGROvrn_C
    ""
    VALUE
    0x8006EF00
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stO2Calc_C
    "Selection switch for enabling the fuel density correction, in case the injection quantity is in mm3"
    VALUE
    0x8006EF04
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stOpMClbEnaMsk_C
    ""
    VALUE
    0x8006E894
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stOpMLmbd1EnaMsk_C
    ""
    VALUE
    0x8006E6A4
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stOpMMonEnaMsk_C
    ""
    VALUE
    0x8006EF08
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stOpMO2SRCMinEnaMsk_C
    ""
    VALUE
    0x8006E734
    Val_Wu32
    4294967295.00
    OneToOne
    0.00
    4294967295.00

    FORMAT "%13.2"
    EXTENDED_LIMITS 0.00 4294967295.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stPmpCtlDisbl_C
    "Disable mask for pump current control dependent on engine conditions"
    VALUE
    0x8006EF2C
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stPortSel_CA
    "Calibratable port ID for sesnor interchangeability"
    VAL_BLK
    0x8006E6E6
    ValA_Wu8
    0.00
    OneToOne
    0.00
    0.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stPsDiaDisbl_C
    "Status word for deactivation of the heater powerstage diagnostic under special engine/battery conditions"
    VALUE
    0x8006E6E7
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stRefCurrHi_C
    "Application parameter to specify high reference pump current amount"
    VALUE
    0x8006E7D0
    Val_Wu8
    15.0000000000
    CurRefPump
    0.00
    15.0000000000

    FORMAT "%13.10"
    EXTENDED_LIMITS 0.00 15.0000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stRefCurrNrm_C
    "Application parameter to specify normal reference pump current amount"
    VALUE
    0x8006E7D1
    Val_Wu8
    15.0000000000
    CurRefPump
    0.00
    15.0000000000

    FORMAT "%13.10"
    EXTENDED_LIMITS 0.00 15.0000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stRefPmpDisbl_C
    "general disable conditions for the reference pump currents"
    VALUE
    0x8006EFE0
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stSelDynChkSig_C
    ""
    VALUE
    0x8006EF0C
    Val_Wu8
    4.00000000000
    LSUSelSig_COMPU_VERB
    0.00
    4.00000000000

    FORMAT "%13.11"
    EXTENDED_LIMITS 0.00 4.00000000000
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stSelOpPntOvrn_C
    ""
    VALUE
    0x8006EF0D
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stSelPlausChkSig_C
    "Flag to select the type of measured O2 ratio for plausibility check at different operating points"
    VALUE
    0x8006EF0E
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stSrvTstEna_C
    "Bit coded application to enable or disable different short LSU diagnosis functions when service test for LSU is active"
    VALUE
    0x8006E808
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_stWireDiaActv_C
    "Activation flags for diagnosis routines - shunting detection and heater coupling check"
    VALUE
    0x8006E7E4
    Val_Wu16
    65535.00
    OneToOne
    0.00
    65535.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 65535.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtAdap_C
    "Switch to select adaptation function"
    VALUE
    0x8006E862
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtChkDPFThmRgn_CA
    ""
    VAL_BLK
    0x8006EF0F
    ValA_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtCldSensDia_C
    "Status for enabling/disabling cold sensor diagnostics for SCB at IA/IP"
    VALUE
    0x8006E6A8
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtExhPresSel_C
    "Switch to add PFlt differential pressure to the modelled exhaust pressure during pressure compensation of oxygen signal"
    VALUE
    0x8006EFCC
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtO2Flt_C
    "switch to enable O2 ratio filtering"
    VALUE
    0x8006E738
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtPresCompAdapOn_C
    "Switch for activation adaptive pressure compensation ( 0 = off; 1 = on )"
    VALUE
    0x8006EFCD
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtSensPrs_C
    "Switch to indicate if LSU sensor is present/not present"
    VALUE
    0x8006E739
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtTempCompEna_C
    "Switch to turn on adaptation at lower temperature and temperature compensation of O2 signal"
    VALUE
    0x8006E863
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtTempCompNomEna_C
    ""
    VALUE
    0x8006E864
    Val_Wu8
    255.0
    OneToOne
    0.00
    255.0

    FORMAT "%5.1"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_swtWrPresCompAdapDfl_C
    "Switch to write default values to regression sums"
    VALUE
    0x8006EFCE
    Val_Wu8
    1.000
    OneToOne
    0.00
    1.000

    FORMAT "%5.3"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tAirAdapActv_C
    "Ambient temperature threshold below which adaption is activated"
    VALUE
    0x8006E866
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tExcMax_C
    "Maximum sensor temperature limit for heater control deviation error"
    VALUE
    0x8006E92C
    Val_Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tExcMin_C
    "Minimum sensor temperature limit for heater control deviation error"
    VALUE
    0x8006E92E
    Val_Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tHtCtlEna_C
    "Temperature threshold for PID heater governor activation"
    VALUE
    0x8006E930
    Val_Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_ti1stClb_C
    "Time from engine RUNNING state to first calibration of CJ125"
    VALUE
    0x8006E898
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiAdapFltIni_C
    "Fast filter time constant for adaption filter during first adaption"
    VALUE
    0x8006E868
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiAdapFlt_C
    "Slow filter time constant for adaption filter during successive adaption"
    VALUE
    0x8006E86C
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiClbEnaDly_C
    ""
    VALUE
    0x8006E89A
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiCldTstActv_C
    "Delay time after ECU start till which cold sensor test for SCB of IA/IP is enabled."
    VALUE
    0x8006E6AA
    Val_Ws16
    655.3500
    Time_s
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiClgLstRun_C
    "Time elapsed since last engine run"
    VALUE
    0x8006E7E8
    Val_Ws32
    21474836.4700
    Time_s
    0.00
    21474836.4700

    FORMAT "%13.4"
    EXTENDED_LIMITS -21474836.4800 21474836.4700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDelHtrTst_C
    "Time after ramp enable to SET bit 3 of LSU_stHtCtl"
    VALUE
    0x8006E932
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDelIniVal_C
    "Delay time for sampling of initial intake air temperature for start up heater duty cycle determination"
    VALUE
    0x8006E934
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDelO2Clb_C
    "Ddelay time for calibration after hardware was switched into O2 calibration mode"
    VALUE
    0x8006E73A
    Val_Wu16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDelO2Val_C
    "Delay time for normal O2 measuring after hardware was switched back to O2 measurement mode"
    VALUE
    0x8006E73C
    Val_Wu16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDelRiClb_C
    "Delay time for calibration after hardware was switched into Ri calibration mode"
    VALUE
    0x8006E77A
    Val_Wu16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDelRiVal_C
    "Delay time for normal Ri measuring after hardware was switched back to normal mode"
    VALUE
    0x8006E77C
    Val_Wu16
    1000.000
    Time_ms
    0.00
    1000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDPFThmRgnDly_C
    ""
    VALUE
    0x8006EF10
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiDvtFlt_C
    "Filter constant for measured O2 used in lambd=1 detection"
    VALUE
    0x8006E6AC
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiEngSpdDT1_C
    "DT1- parameter for engine speed gradient"
    VALUE
    0x8006EFD0
    Val_Ws32
    2.5404556453
    TimeDelay_s
    0.0099999937043
    2.5504556390

    FORMAT "%12.10"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiEvalFltIni_C
    "Fast filter time constant for evaluation filter during first adaption"
    VALUE
    0x8006E870
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiEvalFlt_C
    "Slow filter time constant for evaluation filter during successive adaption"
    VALUE
    0x8006E874
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiExhPresFlt_C
    "Filter time constant for filering the exhaust gas back pressure at the lambda sensor position, (required for monitoring O2 SRC Max error)"
    VALUE
    0x8006E740
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiHtCoupChk_C
    "Duration of heater switch-off in heater coupling check"
    VALUE
    0x8006E7EC
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiHtCoupFltTst_C
    "Filter time constant for smoothing O2 voltage ripple in heater coupling check for service test diagnosis of LSU"
    VALUE
    0x8006E7F0
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiHtCoupFlt_C
    "Filter time constant for smoothing O2 voltage ripple in heater coupling check"
    VALUE
    0x8006E7F4
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiHtCoupPerTst_C
    "Time of periodicity for activation of heater coupling check for short diagnosis of LSU"
    VALUE
    0x8006E7F8
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiHtCoupPer_C
    "Time of periodicity for activation of heater coupling check"
    VALUE
    0x8006E7FA
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiIsolChkErr_C
    "Maximum time until sensor LSU is cooled down."
    VALUE
    0x8006E7FC
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiIsolChkPer_C
    "Period of time for cyclic activation of pumping current in shunting detection"
    VALUE
    0x8006E7FE
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiIsolChkPmp_C
    "Pulse width for activation of pumping current in shunting detection"
    VALUE
    0x8006E800
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiLmbd1RgnDly_C
    "Delay after regeneration of SOx is started to disable lambda = 1 detection."
    VALUE
    0x8006E6B0
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiLmbd1RichMDly_C
    ""
    VALUE
    0x8006E6B2
    Val_Ws16
    655.3500
    Time_s
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiMaxDebVirtNernst_C
    "Measuring time for O2 voltages when a open load is detected at UN/VG."
    VALUE
    0x8006E6B4
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2CalcFltTst_C
    "Sensor position specific filter time constant for filtering calculated O2 concentration in case short diagnosis is active"
    VAL_BLK
    0x8006EF14
    ValA_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2CalcFlt_C
    "Sensor position specific filter time constant for filtering calculated O2 concentration"
    VAL_BLK
    0x8006EF18
    ValA_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2ClbPT1_C
    "PT1 time constant for filtering of O2 calibration value"
    VALUE
    0x8006E744
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2Clb_C
    "Actual O2 calibration time in CJ125"
    VALUE
    0x8006E748
    Val_Wu16
    100.0000
    Time_ms
    0.00
    100.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2EvalTst_C
    "Duration for O2 steady state detection during O2 plausibility check when short diagnosis for LSU is activated"
    VALUE
    0x8006EF1C
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2Eval_C
    "Duration for O2 steady state detection during O2 plausibility check"
    VALUE
    0x8006EF1E
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2PT1_C
    "PT1 time constant for filtering of O2 ratio"
    VALUE
    0x8006E74C
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiO2SRCMinDly_C
    "Delay after regeneration of NSC is started to disable O2 SRC Min error detection."
    VALUE
    0x8006E750
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiOpnLdTstActv_C
    "Time after bit 4 of heater control status is set for enabling open load test at UN/VG"
    VALUE
    0x8006E6B6
    Val_Ws16
    655.3500
    Time_s
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiPerClb_C
    "Periodicity of Ri and O2 calibration triggers"
    VALUE
    0x8006E89C
    Val_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiPExhGsDT1_C
    "DT1- parameter for exhaust gas pressure gradient"
    VALUE
    0x8006EFD4
    Val_Ws32
    2.5404556453
    TimeDelay_s
    0.0099999937043
    2.5504556390

    FORMAT "%12.10"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiPT1FltO2Raw_C
    "Applicable time constant for O2 voltage filtering"
    VALUE
    0x8006E764
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiPT1FltRiRaw_C
    "Applicable time constant for Ri voltage filtering"
    VALUE
    0x8006E768
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiRefPmpHi_C
    "duration of higher reference pump current"
    VALUE
    0x8006EFE2
    Val_Wu16
    655350.0
    Time_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiRefTransLo_C
    "Time required after the transition from High ref pump current to low ref pump current"
    VALUE
    0x8006EFE4
    Val_Wu16
    655350.0
    Time_ms
    0.00
    655350.0

    FORMAT "%8.1"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiRiClbPT1_C
    "PT1 time constant for filtering of Ri calibration value"
    VALUE
    0x8006E780
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiRiClb_C
    "Actual Ri calibration time"
    VALUE
    0x8006E784
    Val_Wu16
    150.0000
    Time_ms
    0.00
    150.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655350.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiRiMeasDisa_C
    "Time during which Ri measurement is disabled and O2 voltages are allowed to settle down, once a open load is detected at UN/VG."
    VALUE
    0x8006E6B8
    Val_Ws16
    655.3500
    Time_s
    -327.6800
    327.6700

    FORMAT "%8.4"
    EXTENDED_LIMITS -327.6800 327.6700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiRiPT1_C
    "PT1 time constant for filtering of Ri resistance value"
    VALUE
    0x8006E788
    Val_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiStbTemp_C
    "Delay time for confirming temperature stability before carrying out adaptation"
    VALUE
    0x8006E878
    Val_Ws16
    655350.0
    Time_ms
    -327680.0
    327670.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiSwt_CA
    "Maximum values for rise time O2 signal at transition from load to overrun during O2 dynamics check"
    VAL_BLK
    0x8006EF20
    ValA_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiUBattPT1_C
    ""
    VALUE
    0x8006E938
    Val_Ws32
    4294967.2940
    TimeDelay_ms
    0.0020000000009
    4294967.2960

    FORMAT "%12.4"
    EXTENDED_LIMITS 0.0020000000009 4294967.2960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiWait1_CA
    "Duration for steady state detection of dynamic check"
    VAL_BLK
    0x8006EF22
    ValA_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiWait2_CA
    "Maximum duration to reach overrun state during dynamics check"
    VAL_BLK
    0x8006EF24
    ValA_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiWait3_CA
    "Maximum duration to reach upper O2 threshold during dynamics check"
    VAL_BLK
    0x8006EF26
    ValA_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tiWait4_CA
    ""
    VAL_BLK
    0x8006EF28
    ValA_Wu16
    655.3500
    Time_s
    0.00
    655.3500

    FORMAT "%8.4"
    EXTENDED_LIMITS 0.00 655.3500
    
    NUMBER 1

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRiMaxTempComp_C
    "Maximum sensor temperature limit for O2 validity and carrying out adaptation"
    VALUE
    0x8006E93C
    Val_Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRiMinTempComp_C
    "Minimum sensor temperature limit for O2 validity and carrying out adaptation"
    VALUE
    0x8006E93E
    Val_Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRiSetPLo_C
    "Low setpoint temperature of LSU"
    VALUE
    0x8006E87A
    Val_Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRiSetPMaxDvt_C
    "Maximum allowable deviation in the sensor temperature for carrying out the adaptation"
    VALUE
    0x8006E87C
    Val_Ws16
    6553.500
    TempDiff_Kelv
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRiSetPStd_C
    "Standard setpoint temperature of LSU"
    VALUE
    0x8006E87E
    Val_Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRiSigQlHiLim_C
    ""
    VALUE
    0x8006E752
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRiSigQlLoLim_C
    ""
    VALUE
    0x8006E754
    Val_Ws16
    6553.500
    Temp_Cels
    -3549.940
    3003.560

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_tRi_CUR
    "Conversion curve for of resistance to tempertaure"
    CURVE
    0x8006E78C
    Cur_Xs16Ws16
    1200.000
    Temp_Cels
    99.96000
    1299.960

    FORMAT "%8.3"
    EXTENDED_LIMITS -3549.940 3003.560
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_resRi_mp
        Resist
        16
        0.00
        3000.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -3276.800 3276.700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uBattMaxHigh_C
    "Voltage above which the heater is switched off"
    VALUE
    0x8006E6E8
    Val_Ws16
    680360.0
    Volt_Batt
    -655360.0
    25000.00

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uBattMaxLow_C
    "Voltage below which the heater switch off is canceled"
    VALUE
    0x8006E6EA
    Val_Ws16
    680360.0
    Volt_Batt
    -655360.0
    25000.00

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uBattMin_C
    "Battery Minimum voltage for enebling most of the LSU diagnosis"
    VALUE
    0x8006E6BA
    Val_Ws16
    12500.00
    Volt_Batt
    -500.0000
    12000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uBattNominal_C
    "Nominal battery voltage = voltage witch lead to no pwm duty cycle correction"
    VALUE
    0x8006E6EC
    Val_Wu16
    16000.00
    Volt_Batt
    0.00
    16000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 1310700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uHtPerfBattMin_MAP
    ""
    MAP
    0x8006E940
    Map_Xs16Ys16Ws16
    1310700.
    Volt_Batt
    -655360.0
    655340.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -655360.0 655340.0
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        LSU_dmEGFldHtCtl_mp
        AirMassPerTime
        25
        -3276.800
        3276.700

        FORMAT "%8.3"
        EXTENDED_LIMITS -3276.800 3276.700
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

    /begin AXIS_DESCR

        STD_AXIS
        LSU_tEGFldHtCtl_mp
        Temp_Cels
        25
        -3549.940
        3003.560

        FORMAT "%8.3"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uMinClb_C
    "Minimum voltage to enable the Ri and O2 calibration"
    VALUE
    0x8006E89E
    Val_Wu16
    16000.00
    Volt_Batt
    0.00
    16000.00

    FORMAT "%8.2"
    EXTENDED_LIMITS 0.00 1310700.
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2ClbDvtMax_C
    "Max limiting voltage value for O2 calibration"
    VALUE
    0x8006E756
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2ClbDvtMin_C
    "Min limiting voltage value for O2 calibration"
    VALUE
    0x8006E758
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2ClbMax_C
    "Upper threshold for O2 calibration error"
    VALUE
    0x8006E75A
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2ClbMin_C
    "Lower threshold for O2 calibration error"
    VALUE
    0x8006E75C
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2MaxGrad_C
    "Mmaximum change of U_O2 for activation of heater coupling check"
    VALUE
    0x8006E802
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2MaxRippel_C
    "Maximum allowed rippel of U_O2 in heater coupling check"
    VALUE
    0x8006E804
    Val_Ws16
    13107.00
    Volt
    -6553.600
    6553.400

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2Max_C
    "Upper SRC limit (not 1.5V subtracted) for O2 voltage with normal sensitivity"
    VALUE
    0x8006E75E
    Val_Ws16
    5000.000
    Volt
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2Min_C
    "Lower SRC limit (not 1.5V subtracted) for O2 voltage with normal sensitivity"
    VALUE
    0x8006E760
    Val_Ws16
    5000.000
    Volt
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2OfsCorSqMax_C
    "Predicted maximum square input of LSU voltage"
    VALUE
    0x8006EFD8
    Val_Ws32
    4294967295.00
    Volt_Sq
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2OfsCor_C
    "Offset of LSU voltage considered while adaptive pressure compensation"
    VALUE
    0x8006EFDC
    Val_Ws16
    6553.500
    Volt_FnReso1
    -3276.800
    3276.700

    FORMAT "%8.3"
    EXTENDED_LIMITS -3276.800 3276.700
    READ_ONLY

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2OpnLdNernstMax_C
    "Maximum O2 raw voltage threshold for open circuit error of Nernst pin (UN)"
    VALUE
    0x8006E6BC
    Val_Ws16
    5000.000
    Volt
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2OpnLdNernstMin_C
    "Minimum O2 raw voltage threshold for open circuit error of Nernst pin (UN)"
    VALUE
    0x8006E6BE
    Val_Ws16
    7000.000
    Volt
    -2000.000
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2OpnLdVirtGndMax_C
    "Maximum O2 raw voltage threshold for open circuit error of virtual ground (VG) pin"
    VALUE
    0x8006E6C0
    Val_Ws16
    5100.000
    Volt
    -100.0000
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2OpnLdVirtGndMin_C
    "Minimum O2 raw voltage threshold for open circuit error of virtual ground (VG) pin"
    VALUE
    0x8006E6C2
    Val_Ws16
    5500.000
    Volt
    -500.0000
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uO2Ref_C
    "Voltage which equals 0% O2 ratio (value 1.5V)"
    VALUE
    0x8006E762
    Val_Ws16
    5000.000
    Volt
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uRiOfs_C
    "Circuit offset voltage in CJ125 for Ri = 0"
    VALUE
    0x8006E7CE
    Val_Ws16
    5000.000
    Volt
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_uRiOpnLdTstMax_C
    "Maximum Ri voltage threshold value for open load detection at UN/VG"
    VALUE
    0x8006E6C4
    Val_Ws16
    5200.000
    Volt
    0.00
    5200.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -6553.600 6553.400
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    LSU_volMinFl_C
    "Minimum volume of fuel in the tank for enabling O2 plausibility check"
    VALUE
    0x8006EF2A
    Val_Ws16
    300.0000
    Fl_Vol_q0p05
    0.00
    300.0000

    FORMAT "%8.4"
    EXTENDED_LIMITS -1638.400 1638.350
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    medc_datasetid
    "Text with the dataset identification"
    ASCII
    0x8006EFE6
    ValA_Wu8
    255.0
    defaultAscii
    0.00
    255.0
    NUMBER 99
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_CrntCtlDT1.T1_C
    "Class for DT1 current governor parameter / Reciprocal of time delay T1 ( 2^32 / T1; T1 in same quantisation as Dt)"
    VALUE
    0x8006F09C
    Kw_Ws32
    4294.9672940
    TimeDelay_s
    0.000002000000001
    4294.9672960

    FORMAT "%12.7"
    EXTENDED_LIMITS 0.000002000000001 4294.9672960
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_CrntCtlDT1.Kd_C
    "Class for DT1 current governor parameter / Differential factor Kd = Td/T1"
    VALUE
    0x8006F0A0
    Kw_Ws32
    65535.9999847
    Kd
    -32768.0000000
    32767.9999847

    FORMAT "%13.7"
    EXTENDED_LIMITS -32768.0000000 32767.9999847
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_CrntCtlI.Ki_C
    "Class for I element parameter / Ki_C factor within the window"
    VALUE
    0x8006F180
    Kw_Ws32
    244.140624943
    Ki_curr2fact
    -122.070312500
    122.070312443

    FORMAT "%13.9"
    EXTENDED_LIMITS -122.070312500 122.070312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_CrntCtlI.KiPos_C
    "Class for I element parameter / Ki_C factor above the window"
    VALUE
    0x8006F184
    Kw_Ws32
    244.140624943
    Ki_curr2fact
    -122.070312500
    122.070312443

    FORMAT "%13.9"
    EXTENDED_LIMITS -122.070312500 122.070312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_CrntCtlI.KiNeg_C
    "Class for I element parameter / Ki_C factor below the window"
    VALUE
    0x8006F188
    Kw_Ws32
    244.140624943
    Ki_curr2fact
    -122.070312500
    122.070312443

    FORMAT "%13.9"
    EXTENDED_LIMITS -122.070312500 122.070312443
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_CrntCtlI.WinPos_C
    "Class for I element parameter / Upper border of the window"
    VALUE
    0x8006F18C
    Kw_Ws32
    4294967295.00
    Curr
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_CrntCtlI.WinNeg_C
    "Class for I element parameter / Lower border of the window"
    VALUE
    0x8006F190
    Kw_Ws32
    4294967295.00
    Curr
    -2147483648.00
    2147483647.00

    FORMAT "%13.2"
    EXTENDED_LIMITS -2147483648.00 2147483647.00
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_ctRot_C
    "Maximum number of function calls of the rotation"
    VALUE
    0x8006F160
    Val_Wu8
    10.00
    OneToOne
    0.00
    10.00

    FORMAT "%5.2"
    EXTENDED_LIMITS 0.00 255.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_dvolSet_C
    "Remote control value of the flow quantity through the metering unit"
    VALUE
    0x800713A8
    Val_Ws16
    150000.0
    Qp_mm3_sec
    0.00
    150000.0

    FORMAT "%8.1"
    EXTENDED_LIMITS -327680.0 327670.0
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_facCrntCtlInit_CUR
    "Initialization factor for current governor I component as system temperature function"
    CURVE
    0x8006F194
    Cur_Xs16Ws16
    2.000000
    Fact
    0.00
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        FuelT_tFlSys
        Temp_Cels
        6
        -50.14000
        149.8600

        FORMAT "%8.4"
        EXTENDED_LIMITS -3549.940 3003.560
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_facCrntCtlMax_C
    "Maximum I component"
    VALUE
    0x8006F1AE
    Val_Ws16
    1.000000
    Fact
    1.000000
    2.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_facCrntCtlMin_C
    "Minimum I component"
    VALUE
    0x8006F1B0
    Val_Ws16
    0.5000000
    Fact
    0.5000000
    1.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS -4.000000 3.999878
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_facRefActrTst_C
    "Detection threshold for MeUn Actr test"
    VALUE
    0x8006F05C
    Val_Wu16
    3.000000
    Fact1
    0.00
    3.000000

    FORMAT "%8.6"
    EXTENDED_LIMITS 0.00 511.9922
    

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iCnvFlowRate_CUR
    "Curve for converting volume flow to current"
    CURVE
    0x8006F1B2
    Cur_Xs16Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        MeUn_dvolSet
        Qp_mm3_sec
        10
        -10000.00
        50000.00

        FORMAT "%8.2"
        EXTENDED_LIMITS -327680.0 327670.0
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iLin_CUR
    "Analog input, linearisation curve"
    CURVE
    0x8006F0A4
    Cur_Xs16Ws16
    5000.000
    Curr
    0.00
    5000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    

        /* AsapCFm - KWP2000 */

    /begin AXIS_DESCR

        STD_AXIS
        MeUn_uRaw_mp
        Volt
        2
        0.00
        5200.000

        FORMAT "%8.3"
        EXTENDED_LIMITS -6553.600 6553.400
        DEPOSIT ABSOLUTE

    /end AXIS_DESCR

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iMaxActrTst_CA
    "Upper limit for MeUn current"
    VAL_BLK
    0x8006F05E
    ValA_Ws16
    2000.000
    Curr
    0.00
    2000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iMinActrTst_CA
    "Lower limit for MeUn current"
    VAL_BLK
    0x8006F066
    ValA_Ws16
    2000.000
    Curr
    0.00
    2000.000

    FORMAT "%8.3"
    EXTENDED_LIMITS -32768.00 32767.00
    
    NUMBER 4

        /* AsapCFm - KWP2000 */

/end CHARACTERISTIC

/begin CHARACTERISTIC

    MeUn_iSetMaxActrTst_C
