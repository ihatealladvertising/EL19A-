    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b1c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[2]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[2] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[3]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[3] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[4]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[4] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b28 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[5]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[5] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[6]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[6] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b30 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[7]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[7] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b34 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[8]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[8] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b38 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dist_buf_NVM[9]
		"Buffer of the 20 last mileages associated to an activation or shut off"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_cru_dist_buf[9] 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd0004b3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[0]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[0] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[10]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[10] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[11]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[11] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b73 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[12]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[12] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[13]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[13] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[14]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[14] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[15]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[15] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b77 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[16]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[16] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[17]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[17] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b79 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[18]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[18] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[19]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[19] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b7b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[1]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[1] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[2]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[2] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[3]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[3] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b6b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[4]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[4] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[5]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[5] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[6]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[6] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[7]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[7] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b6f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[8]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[8] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pccruspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pccruspt_data.c' */
/begin MEASUREMENT
		PcCruSpt_RVLV_NVM.Sxx_cru_dsb_buf_NVM[9]
		"Buffer of the 20 last CC activations or deactivations root cause"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_cru_dsb_buf[9] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0004b71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcaplou_xxxm3x_data.c' */
/begin MEASUREMENT
		PedalError
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER PedalError 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ef1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcaplou_xxxm3x_data.c' */
/begin MEASUREMENT
		PowerTrainSetPoint
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1023.
    DISPLAY_IDENTIFIER PowerTrainSetPoint 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001884 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctqeou_xxxm3x_data.c' */
/begin MEASUREMENT
		RawEngineTorque_WithoutTMReq
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER RawEngineTorque_WithoutTMReq 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000188a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pcaplou_xxxm3x_data.c' */
/begin MEASUREMENT
		RawSensor
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1023.
    DISPLAY_IDENTIFIER RawSensor 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001886 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		RearDefrostEngaged
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		1.
    DISPLAY_IDENTIFIER RearDefrostEngaged 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002443 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		RearGearEngaged
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER RearGearEngaged 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f1d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txp50ou_xxxm3x_data.c' */
/begin MEASUREMENT
		RequestedSpeedDisplayRequest
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER RequestedSpeedDisplayRequest 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000216e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_pctqeou_xxxm3x_data.c' */
/begin MEASUREMENT
		RequestedTorqueAfterProc
		"Transmitted CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		4095.
    DISPLAY_IDENTIFIER RequestedTorqueAfterProc 
    FORMAT "%4.0" 
    ECU_ADDRESS 0xd000188c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		SLockRequestControl
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER SLockRequestControl 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000b2a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SLockValueControl
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		31.
    DISPLAY_IDENTIFIER SLockValueControl 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0002444 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a4f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a51 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a53 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SWA_CANHS_RNr_01[7]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SWA_CANHS_RNr_01_7_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Sbx_pfo_emtv_flow_meca
		"Blocked emtv during full closing request (OBD failure) OBD pending failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_pfo_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002859 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Sbx_pfo_emtv_reg_blk
		"Blocked EMTV during regulation OBD pending failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_pfo_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000285a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Sbx_pfo_emtv_reg_blk_open
		"Blocked emtv during full closing request OBD pending failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_pfo_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000285b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Sbx_pfo_it_reg_blk_clos
		"Blocked IT during full closing request OBD pending failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_pfo_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itdiagx_xxxxxd_data.c' */
/begin MEASUREMENT
		Sbx_pfo_it_reg_blk_open
		"Blocked IT during full opening request OBD pending failure"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Sbx_pfo_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_data.c' */
/begin MEASUREMENT
		SmIsrCtl_NVM.Vxx_is_ad_tq_NVM
		"Adaptive correction"
		SWORD
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		1
		100
		-1024.
		1023.96875
    DISPLAY_IDENTIFIER Vxx_is_ad_tq 
    FORMAT "%11.5" 
    ECU_ADDRESS 0xd0007738 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		SmIsrSpt_NVM.Vbx_acs_acel_is_ena_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acs_acel_is_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000123f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		SmIsrSpt_NVM.Vxx_acs_acel_is_NVM
		""
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Vxx_acs_acel_is 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000123c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		SmIsrSpt_NVM.Vxx_el_csm_ctr_NVM
		""
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_el_csm_ctr 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000123e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_data.c' */
/begin MEASUREMENT
		SmStaSpv_NVM.Vbx_clu_stal_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_clu_stal 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_data.c' */
/begin MEASUREMENT
		SmStaSpv_NVM.Vbx_frst_sta_done_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_frst_sta_done 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_data.c' */
/begin MEASUREMENT
		SmStaSpv_NVM.Vbx_mem_swlk_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_mem_swlk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029dd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smstaspv.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smstaspv_data.c' */
/begin MEASUREMENT
		SmStaSpv_NVM.Vbx_swlk_stal_NVM
		""
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_swlk_stal 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		SoftwareLockRequest[0]
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockRequest[0] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		SoftwareLockRequest[1]
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockRequest[1] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		SoftwareLockRequest[2]
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockRequest[2] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		SoftwareLockRequest[3]
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockRequest[3] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		SoftwareLockRequest[4]
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockRequest[4] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfslkmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfslkmng_lockxv4_xxxxxx_data.c' */
/begin MEASUREMENT
		SoftwareLockRequest[5]
		"Transmitted CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockRequest[5] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000b2a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SoftwareLockValue[0]
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockValue_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002445 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SoftwareLockValue[1]
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockValue_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002446 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SoftwareLockValue[2]
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockValue_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002447 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SoftwareLockValue[3]
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SoftwareLockValue_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002448 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SportivityCriteria
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER SportivityCriteria 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001f1e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		StartButtonPushed
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER StartButtonPushed 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0002449 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		StarterStatus
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER StarterStatus 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f1f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		StartingMode_BCM_R
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER StartingMode_BCM_R 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f20 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		SteeringWheelAngle
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER SteeringWheelAngle 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000189a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[0]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[0] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000217c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[100]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[100] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[101]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[101] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[102]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[102] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[103]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[103] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[104]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[104] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[105]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[105] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[106]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[106] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[107]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[107] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[108]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[108] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[109]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[109] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021e9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[10]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[10] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002186 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[110]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[110] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[111]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[111] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021eb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[112]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[112] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[113]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[113] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[114]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[114] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[115]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[115] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[116]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[116] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[117]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[117] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[118]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[118] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[119]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[119] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[11]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[11] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002187 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[120]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[120] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[121]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[121] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[122]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[122] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[123]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[123] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[124]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[124] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[125]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[125] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021f9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[126]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[126] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[127]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[127] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021fb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[128]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[128] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[129]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[129] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021fd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[12]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[12] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002188 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[130]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[130] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[131]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[131] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ff 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[132]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[132] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002200 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[133]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[133] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002201 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[134]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[134] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002202 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[135]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[135] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002203 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[136]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[136] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002204 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[137]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[137] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002205 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[138]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[138] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002206 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[139]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[139] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002207 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[13]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[13] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002189 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[140]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[140] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002208 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[141]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[141] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002209 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[142]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[142] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000220a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[143]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[143] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000220b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[144]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[144] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000220c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[145]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[145] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000220d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[146]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[146] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000220e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[147]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[147] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000220f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[148]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[148] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002210 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[149]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[149] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002211 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[14]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[14] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000218a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[150]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[150] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002212 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[151]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[151] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002213 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[152]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[152] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002214 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[153]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[153] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002215 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[154]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[154] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002216 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[155]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[155] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002217 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[156]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[156] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002218 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[157]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[157] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002219 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[158]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[158] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000221a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[159]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[159] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000221b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[15]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[15] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000218b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[160]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[160] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000221c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[161]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[161] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000221d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[162]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[162] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000221e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[163]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[163] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000221f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[164]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[164] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002220 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[165]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[165] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002221 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[166]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[166] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002222 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[167]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[167] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002223 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[168]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[168] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002224 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[169]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[169] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002225 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[16]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[16] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000218c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[170]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[170] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002226 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[171]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[171] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002227 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[172]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[172] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002228 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[173]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[173] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002229 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[174]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[174] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000222a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[175]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[175] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000222b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[176]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[176] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000222c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[177]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[177] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000222d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[178]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[178] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000222e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[179]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[179] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000222f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[17]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[17] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000218d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[180]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[180] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002230 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[181]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[181] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002231 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[182]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[182] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002232 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[183]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[183] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002233 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[184]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[184] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002234 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[185]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[185] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002235 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[186]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[186] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002236 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[187]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[187] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002237 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[188]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[188] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002238 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[189]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[189] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002239 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[18]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[18] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000218e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[190]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[190] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000223a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[191]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[191] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000223b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[192]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[192] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000223c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[193]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[193] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000223d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[194]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[194] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000223e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[195]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[195] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000223f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[196]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[196] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002240 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[197]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[197] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002241 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[198]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[198] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002242 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[199]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[199] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002243 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[19]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[19] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000218f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[1]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[1] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000217d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[200]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[200] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002244 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[201]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[201] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002245 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[202]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[202] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002246 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[203]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[203] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002247 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[204]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[204] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002248 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[205]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[205] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002249 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[206]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[206] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000224a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[207]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[207] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000224b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[208]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[208] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000224c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[209]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[209] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000224d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[20]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[20] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002190 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[210]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[210] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000224e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[211]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[211] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000224f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[212]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[212] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002250 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[213]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[213] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002251 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[214]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[214] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002252 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[215]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[215] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002253 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[216]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[216] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002254 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[217]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[217] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002255 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[218]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[218] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002256 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[219]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[219] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002257 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[21]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[21] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002191 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[220]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[220] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002258 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[221]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[221] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002259 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[222]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[222] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000225a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[223]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[223] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000225b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[224]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[224] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000225c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[225]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[225] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000225d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[226]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[226] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000225e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[227]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[227] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000225f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[228]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[228] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002260 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[229]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[229] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002261 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[22]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[22] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002192 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[230]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[230] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002262 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[231]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[231] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002263 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[232]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[232] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002264 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[233]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[233] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002265 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[234]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[234] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002266 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[235]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[235] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002267 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[236]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[236] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002268 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[237]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[237] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002269 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[238]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[238] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000226a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[239]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[239] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000226b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[23]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[23] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002193 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[240]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[240] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000226c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[241]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[241] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000226d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[242]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[242] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000226e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[243]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[243] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000226f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[244]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[244] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002270 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[245]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[245] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002271 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[246]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[246] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002272 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[247]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[247] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002273 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[248]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[248] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002274 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[249]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[249] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002275 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[24]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[24] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002194 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[250]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[250] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002276 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[251]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[251] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002277 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[252]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[252] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002278 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[253]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[253] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002279 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[254]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[254] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000227a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[255]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[255] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000227b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[25]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[25] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002195 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[26]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[26] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002196 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[27]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[27] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002197 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[28]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[28] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002198 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[29]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[29] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002199 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[2]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[2] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000217e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[30]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[30] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000219a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[31]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[31] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000219b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[32]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[32] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000219c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[33]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[33] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000219d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[34]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[34] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000219e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[35]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[35] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000219f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[36]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[36] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[37]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[37] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[38]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[38] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[39]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[39] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[3]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[3] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000217f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[40]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[40] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[41]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[41] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[42]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[42] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[43]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[43] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[44]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[44] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[45]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[45] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021a9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[46]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[46] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[47]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[47] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ab 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[48]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[48] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[49]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[49] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[4]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[4] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002180 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[50]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[50] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[51]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[51] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[52]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[52] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[53]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[53] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[54]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[54] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[55]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[55] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[56]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[56] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[57]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[57] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[58]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[58] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[59]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[59] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[5]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[5] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002181 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[60]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[60] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[61]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[61] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021b9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[62]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[62] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[63]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[63] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021bb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[64]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[64] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[65]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[65] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[66]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[66] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[67]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[67] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[68]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[68] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[69]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[69] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[6]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[6] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002182 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[70]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[70] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[71]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[71] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[72]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[72] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[73]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[73] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[74]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[74] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[75]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[75] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[76]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[76] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[77]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[77] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[78]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[78] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[79]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[79] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[7]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[7] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002183 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[80]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[80] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[81]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[81] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[82]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[82] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[83]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[83] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021cf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[84]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[84] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[85]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[85] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[86]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[86] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[87]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[87] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[88]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[88] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[89]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[89] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[8]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[8] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002184 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[90]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[90] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[91]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[91] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[92]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[92] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[93]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[93] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021d9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[94]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[94] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[95]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[95] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021db 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[96]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[96] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[97]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[97] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021dd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[98]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[98] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[99]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[99] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00021df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Stx_esd[9]
		"Extended Snapshot Data table"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_esd[9] 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002185 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000736c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0007377 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007370 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007364 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000736e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007366 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007369 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007372 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007368 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000736d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000736a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007362 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007374 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000736b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007378 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007376 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[0].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[0].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007367 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007384 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000738f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007388 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000737c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007386 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000737e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007381 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000738a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007380 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007385 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007382 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000737a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000738c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007383 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007390 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000738e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[1].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[1].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000737f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000739c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00073a7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007394 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000739e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007396 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007399 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00073a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007398 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000739d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000739a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007392 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00073a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000739b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[2].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[2].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007397 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00073b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00073bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00073ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073b1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00073ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073b5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00073bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073b3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[3].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[3].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073af 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00073cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00073d7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00073c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00073d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00073d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[4].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[4].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00073e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd00073ef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00073de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073e1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd00073ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073e5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd00073ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073e3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[5].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[5].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073df 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00073fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0007407 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007400 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd00073fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd00073f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073f9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007402 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073fd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd00073f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007404 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd00073fb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007408 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007406 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[6].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[6].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd00073f7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007414 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000741f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007418 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000740c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007416 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000740e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007411 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000741a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007410 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007415 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007412 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000740a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000741c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007413 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007420 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000741e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[7].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[7].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000740f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000742c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0007437 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007430 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007424 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000742e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd0007426 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007429 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0007432 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007428 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000742d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000742a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007422 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd0007434 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd000742b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007438 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007436 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[8].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[8].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007427 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vbx_rtn_clos_o2_phs
		"Stored richness regulation condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vbx_rtn_clos_o2_phs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007444 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_dgdftmng_priority
		"Local frame priority"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		6.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_dgdftmng_priority 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd000744f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_ind_xxx
		"static index"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_ind_xxx 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007448 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_obd_fail_code
		"DTC that caused required freeze frame data storage"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_obd_fail_code 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000743c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_clr_dist
		"Stored distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0007446 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_eal
		"Stored calculated load value for the scantool."
		UBYTE
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_eal 
    FORMAT "%12.8" 
    ECU_ADDRESS 0xd000743e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_frm_tco
		"Stored engine coolant temperature."
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_frm_tco 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007441 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_maf
		"Stored Mass air flow"
		UWORD
		BoztEEa_wAtegrd_ysgmAca_g__000a
		1
		100
		0.
		655.35
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_maf 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd000744a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_map
		"Stored Manifold pressure value measurement"
		UBYTE
		nbaqdya_zjyCbvb_Enxyxob_k_A_1oa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_map 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007440 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_mat
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_mat 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0007445 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_mv_ad_fac
		"Stored mean effective gain applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_mv_ad_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007442 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_n01
		"Stored engine speed"
		UWORD
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		1
		100
		0.
		16383.75
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_n01 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd000743a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_rail_prs
		"Stored Rail pressure measured"
		UWORD
		inDioEb_CahrmFd_hBqncrc_k___o0a
		1
		100
		0.
		655350.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_rail_prs 
    FORMAT "%6.0" 
    ECU_ADDRESS 0xd000744c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_rich_loop_ti_fac
		"Stored multiplicative factor from richness closed loop applied on injected fuel mass quantity"
		UBYTE
		tkesiuc_dAjrjBa_kDhegDb_f__188a
		1
		100
		-100.
		99.21875
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_rich_loop_ti_fac 
    FORMAT "%10.5" 
    ECU_ADDRESS 0xd0007443 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_rvac
		"Stored raw Tank differential pressure value for Scantool."
		SWORD
		sAupbbd_ECffvEc_Evfzxob_PC__ooa
		1
		100
		-8192.
		8191.75
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_rvac 
    FORMAT "%8.2" 
    ECU_ADDRESS 0xd0007450 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_tia
		"Stored intake air temperature"
		UBYTE
		wwwvcEd_jBlyuwc_jBjharc_qC_0ooa
		1
		100
		-40.
		215.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_tia 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000744e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Stx_frm_pool[9].Vxx_rtn_vs
		"Stored filtered vehicule speed."
		UBYTE
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Stx_frm_pool[9].Vxx_rtn_vs 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000743f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_clr_dist
		"Distance travelled since last clear"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_clr_dist 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_clr_wup
		"Warm-up cycles counter since last clear"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Sxx_clr_wup 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd000227c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_dyn_ctr
		"Failure structure index of the next diagnostic instance to be stored (number of stored failures)"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		10.
    DISPLAY_IDENTIFIER Sxx_dyn_ctr 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000227d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_max_ind
		"Number of defined failures in the static memory"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_max_ind 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_mil_on_km
		"Distance travelled while MIL is activated"
		UWORD
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Sxx_mil_on_km 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd0006b78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_owe_st3
		"State of the third scheduler"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		20.
    DISPLAY_IDENTIFIER Sxx_owe_st3 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000253b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_owpdlrx_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_owe_st4
		"State of the fourth scheduler"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		20.
    DISPLAY_IDENTIFIER Sxx_owe_st4 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd000253c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_obdfram_xxxxxd_data.c' */
/begin MEASUREMENT
		Sxx_sel_frm
		"Selected Legislative Freeze frame from the table of potential stored freeze frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		9.
    DISPLAY_IDENTIFIER Sxx_sel_frm 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0002285 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_tmp_dist_1
		"Temporary distance used to calculate distance traveled while MIL is illuminated"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_1 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failmgt_xxxxxx_data.c' */
/begin MEASUREMENT
		Sxx_tmp_dist_2
		"Temporary distance used to calculate distance traveled since last clear"
		ULONG
		Fwoswra_yrtFdDa_iwnyxwb_kC__ooa
		1
		100
		0.
		16777215.
    DISPLAY_IDENTIFIER Sxx_tmp_dist_2 
    FORMAT "%8.0" 
    ECU_ADDRESS 0xd00050c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a59 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_01[7]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_01_7_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a5d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a5f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a61 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[5]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_5_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a63 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[6]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_6_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_AT_CANHS_RNr_02[7]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_AT_CANHS_RNr_02_7_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_01[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_01_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_01[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_01_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001ae9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_01[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_01_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_01[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_01_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aeb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_01[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_01_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_01[5]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_01_5_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aed 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_01[6]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_01_6_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_02[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_02_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001aef 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_02[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_02_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_02[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_02_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_02[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_02_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_02[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_02_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_RNr_02[5]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_RNr_02_5_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_R_01[0]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_R_01_0_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_R_01[1]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_R_01_1_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_R_01[2]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_R_01_2_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_R_01[3]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_R_01_3_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_txfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TORQUE_ECM_CANHS_R_01[4]
		"Transmitted CAN frame"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER TORQUE_ECM_CANHS_R_01_4_ 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001af9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_03.Vbx_tac_xx_req
		"Indicates if the I/O control test of FAN1 and its relay is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_03_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b3d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_03.Vsx_tac_xx_cdn
		"FAN1 and its relay intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_03_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b3c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_04.Vbx_tac_xx_req
		"Indicates if the I/O control test of FAN2 and its relay is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_04_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b45 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_04.Vsx_tac_xx_cdn
		"FAN2 and its relay intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_04_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b44 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_05.Vbx_tac_xx_req
		"Indicates if the I/O control test of electronic water pump for turbocharger cooling is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_05_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b4d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_05.Vsx_tac_xx_cdn
		"Electronic water pump for turbocharger cooling intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_05_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b4c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_11.Vbx_tac_xx_req
		"Indicates if the I/O control test of glow plug and its relay is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_11_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_11.Vsx_tac_xx_cdn
		"Glow plug and its relay intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_11_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_12.Vbx_tac_xx_req
		"Indicates if the I/O control test of EGR flap is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_12_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b5d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_12.Vsx_tac_xx_cdn
		"EGR flap intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_12_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b5c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_13.Vbx_tac_xx_req
		"Indicates if the I/O control test of diesel intake air throttle is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_13_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_13.Vsx_tac_xx_cdn
		"Diesel intake air throttle intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_13_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b64 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_14.Vbx_tac_xx_req
		"Indicates if the I/O control test of EGR cooling bypass solenoid is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_14_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b6d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_14.Vsx_tac_xx_cdn
		"EGR cooling bypass solenoid intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_14_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b6c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_17.Vbx_tac_xx_req
		"Indicates if the I/O control test of 5th injector diesel dosing valve and its gavage pump is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_17_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_17.Vsx_tac_xx_cdn
		"PTC (body heater) and its relay intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_17_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b74 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_18.Vbx_tac_xx_req
		"Indicates if the I/O control test of 5th injector is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_18_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b7d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_18.Vsx_tac_xx_cdn
		"5th injector intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_18_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b7c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_22.Vbx_tac_xx_req
		"Indicates if the I/O control test of flow actuator (VCV) is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_22_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b85 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_22.Vsx_tac_xx_cdn
		"Flow actuator (VCV) intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_22_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b84 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_23.Vbx_tac_xx_req
		"Indicates if the I/O control test of rail pressure regulator (PCV) is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_23_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b87 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_23.Vsx_tac_xx_cdn
		"Rail pressure regulator (PCV) intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_23_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b86 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_24.Vbx_tac_xx_req
		"Indicates if the I/O control test of 02 upper sensor (heater) is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_24_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b89 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_24.Vsx_tac_xx_cdn
		"Oxygen upper sensor heater intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_24_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b88 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_25.Vbx_tac_xx_req
		"Indicates if the I/O control test of 02 lower sensor (heater) is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_25_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b8b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_25.Vsx_tac_xx_cdn
		"Oxygen lower sensor heater intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_25_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b8a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_26.Vbx_tac_xx_req
		"Indicates if the I/O control test of diesel turbocharger command valve is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_26_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b8d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_26.Vsx_tac_xx_cdn
		"Diesel turbocharger command valve intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_26_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b8c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_29.Vbx_tac_xx_req
		"Indicates if the I/O control test of ignition coil 1 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_29_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b95 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_29.Vsx_tac_xx_cdn
		"Ignition coil 1 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_29_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b94 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_30.Vbx_tac_xx_req
		"Indicates if the I/O control test of ignition coil 2 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_30_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b97 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_30.Vsx_tac_xx_cdn
		"Ignition coil 2 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_30_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b96 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_31.Vbx_tac_xx_req
		"Indicates if the I/O control test of ignition coil 3 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_31_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b99 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_31.Vsx_tac_xx_cdn
		"Ignition coil 3 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_31_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b98 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_32.Vbx_tac_xx_req
		"Indicates if the I/O control test of ignition coil 4 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_32_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b9b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_32.Vsx_tac_xx_cdn
		"Ignition coil 4 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_32_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b9a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_35.Vbx_tac_xx_req
		"Indicates if the I/O control test of fuel injector 1 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_35_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b9d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_35.Vsx_tac_xx_cdn
		"Fuel injector 1 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_35_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b9c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_36.Vbx_tac_xx_req
		"Indicates if the I/O control test of fuel injector 2 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_36_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b9f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_36.Vsx_tac_xx_cdn
		"Fuel injector 2 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_36_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b9e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_37.Vbx_tac_xx_req
		"Indicates if the I/O control test of fuel injector 3 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_37_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ba1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_37.Vsx_tac_xx_cdn
		"Fuel injector 3 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_37_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ba0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_38.Vbx_tac_xx_req
		"Indicates if the I/O control test of fuel injector 4 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_38_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ba3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_38.Vsx_tac_xx_cdn
		"Fuel injector 4 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_38_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ba2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_41.Vbx_tac_xx_req
		"Indicates if the I/O control test of thermoplunger relay 1 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_41_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ba5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_41.Vsx_tac_xx_cdn
		"Thermoplunger relay 1 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_41_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ba4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_42.Vbx_tac_xx_req
		"Indicates if the I/O control test of thermoplunger relay 2 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_42_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bad 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_42.Vsx_tac_xx_cdn
		"Thermoplunger relay 2 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_42_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_43.Vbx_tac_xx_req
		"Indicates if the I/O control test of thermoplunger relay 3 is in porgress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_tac_43_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bb5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_43.Vsx_tac_xx_cdn
		"Thermoplunger relay 3 intermediary status"
		UBYTE
		DpjnsAb_Ehtwufc_xFpuivb_B3xi_1_
		1
		100
		0.
		12.
    DISPLAY_IDENTIFIER Vsx_tac_43_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bb4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_03.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of FAN1 and its relay"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_03_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b42 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_03.Vxx_tac_xx_subval
		"Substitution value for a test of FAN1 and its relay"
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_tac_03_subval 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b40 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_03.Vxx_tmp_dly_xx
		"Signal generator timer for FAN1 and its relay"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_03 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b3e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_04.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of FAN2 and its relay"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_04_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b4a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_04.Vxx_tac_xx_subval
		"Substitution value for a test of FAN2 and its relay"
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_tac_04_subval 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b48 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_04.Vxx_tmp_dly_xx
		"Signal generator timer for FAN2 and its relay"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_04 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b46 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_05.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of electronic water pump for turbocharger cooling"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_05_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b52 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_05.Vxx_tac_xx_subval
		"Substitution value for a test of electronic water pump for turbocharger cooling"
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_tac_05_subval 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b50 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_05.Vxx_tmp_dly_xx
		"Signal generator timer for electronic water pump for turbocharger cooling"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_05 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b4e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_11.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of glow plug and its relay"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_11_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b5a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_11.Vxx_tac_xx_subval
		"Substitution value for a test of glow plug and its relay"
		UWORD
		xytAqxd_qAFatsd_yuAczca_f_Ra5oa
		1
		100
		0.
		100.
    DISPLAY_IDENTIFIER Vxx_tac_11_subval 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001b58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_11.Vxx_tmp_dly_xx
		"Signal generator timer for glow plug and its relay"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_11 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b56 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_12.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of EGR flap"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_12_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b62 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_12.Vxx_tac_xx_subval
		"Substitution value for a test of EGR flap"
		UWORD
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_tac_12_subval 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001b60 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_12.Vxx_tmp_dly_xx
		"Signal generator timer for EGR flap"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_12 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_13.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of diesel intake air throttle"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_13_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_13.Vxx_tac_xx_subval
		"Substitution value for a test of diesel intake air throttle"
		UWORD
		ioDywdb_Admtpyb_jtsmfwc_fA_0a60
		1
		100
		-100.
		100.
    DISPLAY_IDENTIFIER Vxx_tac_13_subval 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001b68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_13.Vxx_tmp_dly_xx
		"Signal generator timer for diesel intake air throttle"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_13 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_14.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of EGR cooling bypass solenoid"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_14_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b72 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_14.Vxx_tac_xx_subval
		"Substitution value for a test of EGR cooling bypass solenoid"
		UWORD
		ufpgAoa_gxrCuda_mmabCpc_fA_038a
		1
		100
		-200.
		200.
    DISPLAY_IDENTIFIER Vxx_tac_14_subval 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001b70 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_14.Vxx_tmp_dly_xx
		"Signal generator timer for EGR cooling bypass solenoid"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_14 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b6e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_17.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of 5th injector diesel dosing valve and its gavage pump"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_17_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b7a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_17.Vxx_tac_xx_subval
		"Substitution value for a test of 5th injector diesel dosing valve and its gavage pump"
		UWORD
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER Vxx_tac_17_subval 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b78 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_17.Vxx_tmp_dly_xx
		"Signal generator timer for 5th injector diesel dosing valve and its gavage pump"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_17 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b76 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_18.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of 5th injector"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_18_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b82 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_18.Vxx_tac_xx_subval
		"Substitution value for a test of 5th injector"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_tac_18_subval 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001b80 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_18.Vxx_tmp_dly_xx
		"Signal generator timer for 5th injector"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_18 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b7e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_26.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of diesel turbocharger command valve"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_26_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001b92 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_26.Vxx_tac_xx_subval
		"Substitution value for a test of diesel turbocharger command valve"
		UWORD
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		1
		100
		0.
		200.
    DISPLAY_IDENTIFIER Vxx_tac_26_subval 
    FORMAT "%6.2" 
    ECU_ADDRESS 0xd0001b90 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_26.Vxx_tmp_dly_xx
		"Signal generator timer for diesel turbocharger command valve"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_26 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001b8e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_41.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of thermoplunger relay 1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_41_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001baa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_41.Vxx_tac_xx_subval
		"Substitution value for a test of thermoplunger relay 1"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_tac_41_subval 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001ba8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_41.Vxx_tmp_dly_xx
		"Signal generator timer for thermoplunger relay 1"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_41 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001ba6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_42.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of thermoplunger relay 1"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_42_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bb2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_42.Vxx_tac_xx_subval
		"Substitution value for a test of thermoplunger relay 1"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_tac_42_subval 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001bb0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_42.Vxx_tmp_dly_xx
		"Signal generator timer for thermoplunger relay 1"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_42 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_43.Vxx_tac_xx_nc
		"Current number of cycles done for the I/O control of thermoplunger relay 3"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER Vxx_tac_43_nc 
    FORMAT "%3.0" 
    ECU_ADDRESS 0xd0001bba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_43.Vxx_tac_xx_subval
		"Substitution value for a test of thermoplunger relay 3"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		7.
    DISPLAY_IDENTIFIER Vxx_tac_43_subval 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001bb8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdgtmon.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdgtmon_tacmngx_xxxxxx_data.c' */
/begin MEASUREMENT
		Tac_data_set_rsa_43.Vxx_tmp_dly_xx
		"Signal generator timer for thermoplunger relay 3"
		UWORD
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		1
		100
		0.
		65.535
    DISPLAY_IDENTIFIER Vxx_tmp_dly_43 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001bb6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TorqueConverterState
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		3.
    DISPLAY_IDENTIFIER TorqueConverterState 
    FORMAT "%1.0" 
    ECU_ADDRESS 0xd0001f21 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TransmRangeEngaged_Current
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER TransmRangeEngaged_Current 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001f22 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TransmRangeEngaged_Target
		"Received CAN parameter"
		UBYTE
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		15.
    DISPLAY_IDENTIFIER TransmRangeEngaged_Target 
    FORMAT "%2.0" 
    ECU_ADDRESS 0xd0001f23 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_rxfrmxx_xxxm3x_data.c' */
/begin MEASUREMENT
		TransversalAcceleration
		"Received CAN parameter"
		UWORD
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		1
		100
		0.
		65535.
    DISPLAY_IDENTIFIER TransversalAcceleration 
    FORMAT "%5.0" 
    ECU_ADDRESS 0xd000189c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		USM_CANHS_RNr_01[0]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER USM_CANHS_RNr_01_0_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a66 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		USM_CANHS_RNr_01[1]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER USM_CANHS_RNr_01_1_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a67 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		USM_CANHS_RNr_01[2]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER USM_CANHS_RNr_01_2_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a68 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		USM_CANHS_RNr_01[3]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER USM_CANHS_RNr_01_3_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a69 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		USM_CANHS_RNr_01[4]
		"Received CAN frame"
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    DISPLAY_IDENTIFIER USM_CANHS_RNr_01_4_ 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0001a6a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_abs_pws_typ_bc
		"Indicates the ABS power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_abs_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026bd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcibki.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcibki_absxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_abs_reg
		"ABS in regulation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_abs_reg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b5b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_clu_dsb
		"Air conditioning compressor clutching interdiction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_clu_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000262a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_clu_ena
		"AC compressor clutching order"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_clu_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000262d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acclucs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_clu_req
		"Air conditioning compressor clutching request sent from AC ECU to USM (M3 architecture)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_clu_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b71 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_dclu_dsb
		"Air conditioning compressor declutching interdiction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_dclu_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000262b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_compxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_dsb
		"Immediate AC compressor inhibition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000262c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_dsb_req
		"Air conditioning deactivation request before coordination"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_dsb_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002de7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_eng_dsb
		"Air conditioning compressor inhibition request for engine needs"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_eng_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002de3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_eng_frz
		"Air conditioning compressor freezing request for engine needs"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_eng_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002de4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_ext_pres
		"Air conditioning ECU detection. Equal to 0 if cold loop is present"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_ext_pres 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d2c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_mdf1_req
		"Fan 1 activation request from cold loop or air conditioning ECU"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_mdf1_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028fd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_mdf1_req_ext
		"Fan 1 activation request from air conditioning ECU"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_mdf1_req_ext 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002812 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_mdf1_req_int
		"Fan 1 activation request from cold loop"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_mdf1_req_int 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a01 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_mdfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_mdf2_req
		"Fan 2 activation request from cold loop or air conditioning ECU"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_mdf2_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_mdf2_req_ext
		"Fan 2 activation request from air conditioning ECU"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_mdf2_req_ext 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002813 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_acfanxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_mdf2_req_int
		"Fan 2 activation request from cold loop"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_mdf2_req_int 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a02 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_acprssr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_pres
		"Air conditioning option detection with security on configuration detection."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_pres 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000280d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_ac_pws_typ_bc
		"Indicates the AC power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_req
		"Filtered air conditioning compressor activation request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002814 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'vfacomng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'vfacomng_noacvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ac_secu_dsb
		"Combination of all the vehicle inhibitions"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ac_secu_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a04 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_acc_pws_typ_bc
		"Indicates the ACC power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acc_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026bf 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_is_ac_dsb
		"Air conditioning deactivation request for minimum idle speed at compressor clutching"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_is_ac_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002de8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_100_rat
		"Accel pedal depressed beyond 100% ratio"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_100_rat 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_fil_sens_v1
		"Accelerator pedal sensor track 1 evolution condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_fil_sens_v1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxsr_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_fil_sens_v2
		"Accelerator pedal sensor track 1 evolution condition"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_fil_sens_v2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b58 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedinxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_kd
		"accel pedal depressed beyond mechanical hard point (if no mechanical KD, flag remains inactive)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_kd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_act
		"Accelerator pedal safety strategy activated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000296b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_dft_act
		"Activation of the accelerator pedal limp home strategy"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_dft_act 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000296c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_dft_prev
		"Pedal limp home downgraded mode at t-1"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_dft_prev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000296d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_i_rst
		"Conditions to reset integral term of pedal limp home regulators"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_i_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000296e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_min_cdn
		"Conditions to apply the minimum available engine torque in pedal limp home"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_min_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000296f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_ditcfxx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_min_spc_cdn
		"Specific conditions to apply the minimum available engine torque in pedal limp home"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_min_spc_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b75 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_n_i_frz
		"Conditions to freeze the integral term of the engine speed regulator in pedal limp home"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_n_i_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002970 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_n_tqe_h
		"The maximum torque allowed by the engine speed regulator in pedal limp home is reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_n_tqe_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002971 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_n_tqe_l
		"The minimum torque allowed by the engine speed regulator in pedal limp home is reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_n_tqe_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002972 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_reg_swi
		"(1) vehicle speed regulator activated. (0) engine speed regulator activated in pedal limp home."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_reg_swi 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002973 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_sp_cdn
		"Conditions to initialize the engine and vehicle speed setpoints to their current value"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_sp_cdn 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002974 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_vs_i_frz
		"Conditions to freeze the integral term of vehicle speed regulator"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_vs_i_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002975 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_vs_p_rst
		"Conditions to reset proportionnal term of vehicle speed pedal limp home regulator"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_vs_p_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002976 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_vs_tqe_h
		"The maximum torque allowed by the vehicle speed regulator in pedal limp home is reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_vs_tqe_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002977 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedlhxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_lih_vs_tqe_l
		"The minimum torque allowed by the vehicle speed regulator in pedal limp home is reached"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_lih_vs_tqe_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002978 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_secu_cdn_1
		"Condition 1 for activation of pedal safety case (used for the exit of emergency mode too)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_secu_cdn_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d0d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_secu_cdn_2
		"Condition 2 for activation of pedal safety case (not used for the exit of emergency mode too)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_secu_cdn_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d0e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_sftpdxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_secu_det
		"Detection of the conditions accelerator pedal safety case (before breaking)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_secu_det 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d0f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acel_pdl_sens1_ok
		"accelerator pedal sensor track 1 without default"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acel_pdl_sens1_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_acsiscs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acs_acel_is_req
		"Accelerated idle speed request for commercial vehicle accessories"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acs_acel_is_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002eea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_acs_frz
		"Accessories freezing request before coordination"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_acs_frz 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002de9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_csfsttx_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_act_dgtc_spd_req_lght
		"Boolean indicating reinitialisation in garage"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_act_dgtc_spd_req_lght 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002e5e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_ack
		"AT frame acknowledgment. This value is set to 1 if there is no torque request"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_ack 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c3 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_clck_fail
		"the AT frame clock value is not coherent with the last AT frame clock"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_clck_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c5 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_cmd
		"Validation of AT protocol conditions"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_cmd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_dft
		"Protocol error detected (to activate slew rate)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_dft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c7 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_gear_mod_ok
		"Boolean indicating that the AGB requests are authorized"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_gear_mod_ok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_agbxxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_is_acel_req
		"Idle speed setpoint acceleration by AT is requested"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_is_acel_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d24 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_atissxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_is_clc_ena
		"Activation (1) or deactivation (0) of the calculation of the AGB idle speed setpoints."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_is_clc_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_mdf1_req
		"Fan 1 activation request from AGB"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_mdf1_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002815 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'invfiaci.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'invfiaci_mngtxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_mdf2_req
		"Fan 2 activation request from AGB"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_mdf2_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002816 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'cmmuxser.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'cmmuxser_mngtxxx_xxxm3x_data.c' */
/begin MEASUREMENT
		Vbx_agb_pws_typ_bc
		"Indicates the AGB power supply class"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_pws_typ_bc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00026c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_int_rst
		"Reset of AGB torque integretar diagnostic"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_int_rst 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_lim_dft
		"When this flag is set to 1, Agb torque limitation will be set to a default calibration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_lim_dft 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027c9 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_req
		"Agb torque request in progress"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_atsipxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_req_full_ctl
		"Requested AGB torque intervention of full control type (corresponding to shift in progress in M2S)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_req_full_ctl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b53 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_req_full_ctl_vld
		"Validated AGB torque intervention of full control type (corresponding to shift in progress in M2S)"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_req_full_ctl_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027cb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_atsipxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_req_h_lim
		"Requested AGB torque intervention of upper limitation type"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_req_h_lim 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b54 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_req_h_lim_vld
		"Validated AGB torque intervention of upper limitation type"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_req_h_lim_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_atsipxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_req_l_lim
		"Requested AGB torque intervention of lower limitation type"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_req_l_lim 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b55 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_sdftaxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_agb_tq_req_l_lim_vld
		"Validated AGB torque intervention of lower limitation type"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_agb_tq_req_l_lim_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027cd 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'asmafctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'asmafctl_airslop_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_air_slop_on
		"Air system slop on"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_air_slop_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002a57 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_airb_on
		"Boolean indicating the reception of airbag crash signal"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_airb_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00028f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_acel_decl_stt
		"Acceleration (1) or deceleration (0) vehicle state"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_acel_decl_stt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002993 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_cor_fast_cor_off
		"The fast anti-jerk correction is not active."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_cor_fast_cor_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002610 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_cor_fast_cor_on
		"The fast anti-jerk correction is active."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_cor_fast_cor_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002611 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_cor_stt_cut
		"Boolean variable deactivating (1) the AJCOR function"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_cor_stt_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002612 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_cut_cdn_on
		"Boolean to enable the observation of driver demand condtions to enable the boost of the curative anti-jerk function."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_cut_cdn_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002999 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_fast_cor_on
		"Boolean to activate the boost of the curative anti-jerk function."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_fast_cor_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002994 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_modu_loss_fil_cut
		"Boolean variable to detect engine torque losses filtering"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_modu_loss_fil_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002980 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_modu_stt_cut
		"Boolean variable deactivating (1) AJMOD function"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_modu_stt_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002981 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_modu_tkof_ena
		"Boolean to activate parameters modulation during takeoff phase"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_modu_tkof_ena 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002982 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_no_drag
		"Boolean variable activating the drag error correction"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_no_drag 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002995 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_pdl_cdn_on
		"Boolean to activate the boost of the curative anti-jerk function based on the driver pedal observation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_pdl_cdn_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000299a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_decl_off
		"Boolean variable to detect crossing slack torque low threshold during vehicle deceleration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_decl_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000299b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_decl_on
		"Boolean variable to detect crossing slack torque high threshold during vehicle deceleration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_decl_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000299c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_on
		"Boolean variable activating the slack effect"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002996 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_on_prev
		"Previous value of the boolean variable activating the slack effect"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_on_prev 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000299d 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_open_on
		"Boolean variable activating the slack effect with an open driveline"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_open_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000299e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_tqe_decl_out
		"Boolean variable detecting the end of the slack effect correction during vehicle deceleration"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_tqe_decl_out 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002997 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_tqe_off
		"Boolean variable to detect crossing of the slack torque deactivation threshold"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_tqe_off 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000299f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_slk_tqe_on
		"Boolean variable to detect crossing of the slack torque activation threshold"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_slk_tqe_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_spv_stt_cut
		"Preventive and curative anti-jerk functions are deactivated"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_spv_stt_cut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002998 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ajs_tq_cdn_on
		"Boolean to enable the boost of the curative anti-jerk function based on the driver torque observation."
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ajs_tq_cdn_on 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00029a1 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_alt_dsb_req
		"Alternator deactivation request before coordination"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_alt_dsb_req 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002dea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_alt_eng_dsb
		"Alternator deactivation request after coordination"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_alt_eng_dsb 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002deb 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_alt_pow_trs
		"Alternator power transitional detection"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_alt_pow_trs 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002d2b 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_amp_chr_cnd
		"Conditions for amp chr diag activation"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_amp_chr_cnd 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000279e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_amp_chr_in_vld
		"Amp chr diagnosis input validity"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_amp_chr_in_vld 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000279f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_ampxxsr_xxxxxd_data.c' */
/begin MEASUREMENT
		Vbx_amp_chr_prs_cond
		"Intake pressure condition for AMP CHR diag enabling"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_amp_chr_prs_cond 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00027a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ant_gear_coup_cut_ct_1
		"First gear ratio is detected"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ant_gear_coup_cut_ct_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002625 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_clbdgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_ant_gear_shf
		"Rising shift identification"
		UBYTE
		utCpcna_olpdfvb_iFvAkza_nC___01
		1
		100
		0.
		1.
    BIT_MASK 0x1 
    DISPLAY_IDENTIFIER Vbx_ant_gear_shf 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0002b65 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin MEASUREMENT
		Vbx_apmp_down_shf
		"Vbx_apmp_down_shf"
		UBYTE
		VA_Bool_ON_OFF
		2
		100
		0
		1
    BIT_MASK 0x1 
    ECU_ADDRESS 0xd000294f 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
