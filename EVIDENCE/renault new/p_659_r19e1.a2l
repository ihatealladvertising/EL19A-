    AXIS_PTS_Y        4 SWORD INDEX_INCR DIRECT
    FNC_VALUES        5 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wr32

    FNC_VALUES        1 FLOAT32_IEEE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Ws32

    FNC_VALUES        1 SLONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu32

    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT ValA_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wr32

    FNC_VALUES        1 FLOAT32_IEEE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Ws16

    FNC_VALUES        1 SWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Ws32

    FNC_VALUES        1 SLONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Ws8

    FNC_VALUES        1 SBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu16

    FNC_VALUES        1 UWORD COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu32

    FNC_VALUES        1 ULONG COLUMN_DIR DIRECT

/end RECORD_LAYOUT

/begin RECORD_LAYOUT Val_Wu8

    FNC_VALUES        1 UBYTE COLUMN_DIR DIRECT

/end RECORD_LAYOUT



/******************************************************************************
 *
 * Insertion of the Customer entries (Begin)
 *
 */
/* RSA::SAXHandler : Converted from 'insmissr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'insmissr_accluxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ac_acel_is
		"Breakpoint table for engine idle speed need for AC"
		0x800588d4
		Vxx_tair_ext
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_mcissxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ac_forb_is_n
		"Idle speed breakpoints used to avoid critical engine speed requested by AC"
		0x8005aed2
		Vxx_ac_acel_is_sp
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ac_pow
		"Air conditioning power breakpoints"
		0x8006b326
		Vxx_no_cor_raw_ac_pow
		RSA_RecordLayout_Axis_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		9
		0.
		655350.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_clmxxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ac_pow_cor_n
		"Air conditioning power breakpoints"
		0x8006b312
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		9
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_acel_pdl_fmt
		"Pedal ratio breakpoints for pedal progressivity maps"
		0x80059ce4
		Vxx_acel_pdl_rat
		RSA_RecordLayout_Axis_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		17
		0.
		1.
    FORMAT "%7.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_acel_pdl_fmt_fac_driv
		"Driving style breakpoints for map giving transition factor between 2 progressivity maps"
		0x80059cde
		Vxx_driv_spt_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ecqiCpc_DaDmwla_yczccca_n_Ra5oa
		5
		0.
		1.
    FORMAT "%9.7" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_acel_pdl_fmt_fac_vs
		"Vehicle speed breakpoints for map giving transition factor between 2 progressivity maps"
		0x80059cca
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		9
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_acel_pdl_fmt_tkof_fac_driv
		"take off assistance factor breakpoints for take off map giving transition factor between 2 progressivity maps"
		0x80059cc4
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		5
		0.
		1.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_pedfmxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_acel_pdl_fmt_tkof_fac_vs
		"Vehicle speed breakpoints for take off map giving transition factor between 2 progressivity maps"
		0x80059cb8
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		5
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inpciapi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciapi_pedxxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_acel_pdl_v_max_dif
		"Pedal breakpoint for the consistency diagnosis"
		0x800587ca
		Vxx_acel_pdl_fil_sens_v1
		RSA_RecordLayout_Axis_UWORD
		1
		vemczAb_reFdrlb_hCftnsa_n__a30a
		9
		0.
		1.
    FORMAT "%9.7" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_adv_amp_cor_sta_n
		"Engine speed breakpoints for starting set point tables"
		0x8006aeb6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_adv_amp_cor_sta_tco
		"Coolant temperature breakpoints for starting set point tables"
		0x8006aea8
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_agb_csm_tq_is_n_sp_dif
		"Breakpoint on the difference between nominal engine speed setpoint and the real setpoint"
		0x8005875e
		Vxx_is_n_sp_dif
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		5
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_agb_tq_dif_n_is_n_sp
		"Breakpoint on the difference between the engine speed and the engine setpoint"
		0x8005874a
		Vxx_agb_tq_dif_n_is_n_sp
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		9
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inpciagb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inpciagb_attqxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_agb_tq_vs
		"Breakpoint of Vehicle speed, to disable the coupler torque"
		0x80058736
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		9
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_aux_tql
		"Breakpoints calibration for torque losses due to accessories, for Anti-Jerk Strategy"
		0x8005a9c8
		Vxx_ajs_aux_tql
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_cor_driv_tq_fac
		"Breakpoint calibration of normalized driver torque factor in AJCOR function"
		0x800410c0
		Vxx_ajs_spv_driv_tq_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		11
		0.
		1.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_cor_n
		"Breakpoint calibration of engine speed in AJCOR function"
		0x800410ac
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		9
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_cor_n_diff
		"Breakpoint calibration of difference between engine speed and idle speed setpoint in AJCOR function"
		0x8004109a
		Vxx_ajs_cor_n_diff
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_cor_tco
		"Breakpoint calibration of engine coolant temperature in AJCOR function"
		0x8004108c
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_drag_tq_fac
		"Breakpoint calibration of normalized driver torque factor for drag error correction."
		0x8005a6ea
		Vxx_ajs_spv_driv_tq_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		7
		0.
		1.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_driv_tq_drv
		"Breakpoint calibration of derivated driver torque"
		0x8005a9b8
		Vxx_ajs_driv_tq_drv
		RSA_RecordLayout_Axis_UWORD
		10000
		skzzggb_gryEsta_lpfamqd_n__420a
		7
		-5000.
		5000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smcajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smcajctl_ajcorxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_dt_tq_rat
		"a_sm_caj_ctl_ajcorxx_xxx_xx_x_a/Breakpoint calibration of driveline torque ratio"
		0x8004107a
		Vxx_ajs_dt_tq_rat
		RSA_RecordLayout_Axis_UWORD
		210
		vtyvFka_akFtnud_rnCproc_n__1a0a
		8
		-10.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_gear_rat
		"Breakpoint calibration of vehicle_speed / rotary_engine_speed ratio"
		0x8005a9a6
		Vxx_ajs_gear_rat_n
		RSA_RecordLayout_Axis_UWORD
		210
		vtyvFka_akFtnud_rnCproc_n__1a0a
		8
		-10.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_modu_n
		"Breakpoint calibration of engine speed in AJMOD function"
		0x8005a6da
		Vxx_ajs_modu_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		7
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_modu_tkof_spt_fac
		"Breakpoint calibration of sportivity factor during takeoff phase"
		0x8005a6d4
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		5
		0.
		1.
    FORMAT "%9.7" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_slk_tq_fac
		"Breakpoint calibration of normalized driver torque factor for slack effect strategy (open driveline)."
		0x8005a99e
		Vxx_ajs_spv_driv_tq_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		7
		0.
		1.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_spv_drag_tq_fac
		"Breakpoint calibration of normalized driver torque factor for drag error correction."
		0x8005a996
		Vxx_ajs_spv_driv_tq_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		7
		0.
		1.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_spv_n
		"Breakpoint calibration of engine speed in AJSPV function"
		0x8005a986
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		7
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajspvxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_spv_tq_fac
		"Breakpoint calibration of normalized driver torque factor"
		0x8005a97e
		Vxx_ajs_spv_driv_tq_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		7
		0.
		1.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_spcpaxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_tco
		"9 engine coolant temperature breakpoints for AJS"
		0x800409ea
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcpajctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcpajctl_ajmodxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ajs_tq_fac
		"Breakpoint calibration of normalized driver torque factor"
		0x8005a6cc
		Vxx_ajs_spv_driv_tq_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		yEDvFfd_baDakdd_ycrdhoa_n_Ra0oa
		7
		0.
		1.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_alt_n_fil_fac
		"Engine speed breakpoints to filter alternator torque and power"
		0x80058a64
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_alt_pow
		"Alternator power breakpoints"
		0x80058a50
		Vxx_no_cor_raw_alt_pow
		RSA_RecordLayout_Axis_UWORD
		655350
		euujibb_FsnwgBc_lyegbrc_W_R01oa
		9
		0.
		655350.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'intqiacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'intqiacs_paltxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_alt_pow_cor_n
		"Engine speed breakpoints for alternator power correction"
		0x80058a3c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		9
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_comb_efy_sta
		"Atmospheric pressure breapoints for the combustion efficiency correction during start"
		0x8004329e
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		5
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_ex_prs_sp_cor_pr
		"Breakpoints y for atmospheric pressure correction of exhaust pressure setpoint in pft regeneration mode"
		0x80060b9a
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		10
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_ex_prs_sp_cor_rij
		"Breakpoints y for atmospheric pressure correction of exhaust pressure setpoint in regular injection mode"
		0x80061480
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		10
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_ex_prs_sp_tkof_pr
		"Breakpoints y for atmospheric pressure correction of exhaust pressure setpoint for take off assistance in pft regeneration mode"
		0x80060b88
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_ex_prs_sp_tkof_rij
		"Breakpoints y for atmospheric pressure correction of exhaust pressure setpoint for take off assistance in regular injection mode"
		0x8006146e
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_fms_adv_amp_fac_pr
		"Atmospheric pressure breakpoint of atmospheric pressure factor for main advance set point"
		0x8006add0
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_fms_adv_amp_tco_fac_rij
		"Atmospheric pressure breakpoint of atmospheric pressure factor for main advance set point"
		0x80050fa8
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_fms_fp1_amp_fac_rij
		"Atmospheric pressure breakpoint of amp factor for quantity of pre injection 1 during rij"
		0x8004a982
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_fms_fp2_amp_fac_rij
		"Atmospheric pressure breakpoint of amp factor for quantity of pre injection 2 during rij"
		0x8004b418
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_fms_tlp_fac_pr
		""
		0x8004f37c
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_fms_tp1_amp_fac_rij
		"Atmospheric pressure breakpoint of amp factor for separation of pre injection 1 during rij"
		0x8005222e
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_fms_tp2_amp_fac_rij
		"Atmospheric pressure breakpoint of amp factor for separation of pre injection 2 during rij"
		0x800533fc
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_pft_fms_cor
		"Programmable atmospheric pressure breakpoints for basic injected fuel mass flow settings correction."
		0x80045854
		Vxx_amp_reg
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_pft_utp_sp_cor
		"Programmable atmospheric pressure breakpoints for TBF setpoint correction."
		0x80045d00
		Vxx_amp_reg
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_rps_amp_fac_pr
		"Atmospheric pressure breakpoint of amp rail pressure factor during pr"
		0x8004db98
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_rps_amp_tco_fac_rij
		"Atmospheric pressure breakpoint of atmospheric pressure factor for rail pressure set point"
		0x8004ea56
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatieaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatieaf_egafxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_amp_sot_esti
		"Programmable atmospheric pressure breakpoints"
		0x80057de0
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_cf_conf_thpl
		""
		0x800590c2
		Vxx_thpl_lvl_cf
		RSA_RecordLayout_Axis_UBYTE
		15
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		16
		0.
		15.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inpcidls.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inpcidls_dlsttxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_coup
		"Breakpoint calibration of transmission coupler states"
		0x8005883d
		Vxx_ant_coup
		RSA_RecordLayout_Axis_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		3
		0.
		255.
    FORMAT "%3.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pccructl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pccructl_servoxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_cru_sl_vs
		"Speed breakpoints"
		0x80040194
		Vxx_vs
		RSA_RecordLayout_Axis_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		17
		0.
		255.
    FORMAT "%3.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_csm_sum_sta_drv_esti
		"Programmable breakpoints table for Ctp_pft_csm_ms_esti map"
		0x8004692e
		Vxx_csm_sum_sta_drv_ms
		RSA_RecordLayout_Axis_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		6
		0.
		65535.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fscurxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_cur_spd
		"Ctb_cur_spd"
		0x80059270
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		VA_F_0v25_p0_3
		8
		0
		16383.75
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxsr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_damp_map_dif
		"manifold pressure breakpoint to dampening the effect of adaptation"
		0x800577d6
		Vxx_mapc_hpf_map
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		14
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_doc1_cal_cpy_gaz
		"BKPT: Calorific capacity of the gas"
		0x80058238
		Vxx_doc1_gaz_temp_mem
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		10
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_doc1_cal_cpy_tbn
		"Break point of calorific capacity of the material"
		0x80058232
		Vxx_doc1_temp_esti_dly
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		2
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_doc1_dyn_visc_gaz
		"BKPT: Dynamic viscosity of gas"
		0x8005821c
		Vxx_tbt_conv
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		10
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_doc1_ext_cnvt_cur
		"BKPT: Externe convection curve"
		0x80058208
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		9
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_doc1_itl_cnvt_cur
		"BKPT: Nusselt Internal convection curve"
		0x800581f2
		Vxx_doc1_itl_cnvt_cur
		RSA_RecordLayout_Axis_UWORD
		6553.5
		ykmzBoa_nqupBma_Ffvbarc_m_R0ooa
		10
		0.
		6553.5
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_doc1_tbn_vol_th_loss
		"BKPT: Turbine Volumetric thermal loss"
		0x800581de
		Vxx_doc1_dif_prs_cpr
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		9
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tdoc1md_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_doc1_th_trsm_gaz
		"BKPT: Thermal transmission of gas"
		0x800581c8
		Vxx_tbt_conv
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		10
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fslawxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_down_shf_pdl
		"Ctb_down_shf_pdl"
		0x800593b6
		Vxx_free_shf_pdl
		RSA_RecordLayout_Axis_UWORD
		100
		VA_F_0v125_p0_6
		11
		0
		100
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_dp_fms_adv_dp_map_fac_rij
		"Delta mass air pressure breakpoint of delta mass air pressure factor for main advance during rij"
		0x80050f96
		Vxx_vnt_reg_spg_err
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		8
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_dp_fms_adv_dp_rps_fac_pr
		"Delta rail pressure breakpoint ofdelta rail pressure factor for main advance during pr"
		0x8006adbe
		Vxx_rps_dp_rail_prs
		RSA_RecordLayout_Axis_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		8
		-2000.
		2000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_dp_fms_adv_dp_rps_fac_rij
		"Delta rail pressure breakpoint of delta rail pressure factor for main advance during npu"
		0x80050f84
		Vxx_rps_dp_rail_prs
		RSA_RecordLayout_Axis_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		8
		-2000.
		2000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_driv_sp_grd_ref_vs
		"Vehicle speed breakpoints for driver activity reference value (vehicle speed dependent tuning factor"
		0x80059204
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		5
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_driv_sp_mv_fil_fac_pwt_sp
		"Powertrain setpoint breakpoints for filter time constant in driver setpoint mean value calculation"
		0x800591fe
		Vxx_driv_pwt_sp
		RSA_RecordLayout_Axis_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		2
		0.
		1.
    FORMAT "%7.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_driv_sp_mv_fil_fac_vs
		"Vehicle speed breakpoints for filter time constant in driver setpoint mean value calculation"
		0x800591f8
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		2
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_driv_spt_fac_driv_sp_grd_mv
		"Driver activity breakpoints for driving style map"
		0x800591f2
		Vxx_driv_sp_grd_mv
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		5
		0.
		1.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_driv_spt_fac_driv_sp_mv
		"Driver setpoint mean value breakpoints for driving style map"
		0x800591ec
		Vxx_driv_sp_mv
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		5
		0.
		1.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_driv_tqe_map_n
		"Engine speed breakpoints for engine torque setpoint map"
		0x80059bfa
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		20
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_driv_tqe_map_pwt_sp
		"Powertrain setpoint breakpoints for engine torque setpoint map"
		0x80059bd6
		Vxx_driv_pwt_sp
		RSA_RecordLayout_Axis_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		17
		0.
		1.
    FORMAT "%7.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_spgpitc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_dt1_exp
		""
		0x8004349c
		Vxx_dt1_exp
		RSA_RecordLayout_Axis_UWORD
		9
		kybEEsb_fcjzqub_saFowBd_n_ao66a
		16
		0.
		9.
    FORMAT "%5.4" 
    READ_ONLY 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_dt_tq_rat
		"Breakpoint calibration of driveline torque ratio"
		0x8005b1ea
		Vxx_dt_tq_rat
		RSA_RecordLayout_Axis_UWORD
		210
		vtyvFka_akFtnud_rnCproc_n__1a0a
		8
		-10.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_dtp_pft_utp_var_sp
		"Programmble CSF downstream temperature breakpoints for CSF up temp variable set point"
		0x80045cee
		Vxx_pft_dtp_in
		RSA_RecordLayout_Axis_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_efi_ff_pwm
		"Programmable mass flow bkpts map for the cycling opening percentage of the fuel injector in exhaust"
		0x80058ef4
		Vxx_pft_efi_efv_ff_clc
		RSA_RecordLayout_Axis_UWORD
		655.35
		cdvfnAa_yxaetBd_njakqtd_gnA_00a
		8
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_efi_ff_pwm_ff
		"Programmable mass flow bkpts map for the cycling opening percentage of the fuel injector in exhaust."
		0x80058ee2
		Vxx_pft_efi_pwm_prct_ind_cor
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		8
		0.
		200.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_efi_fuel_prs_n
		"Programmable engine speed bkpts map for estimating exhaust line pressure"
		0x80058ed0
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_efi_mv_vb
		"Breakpoints for voltage battery correction table"
		0x80058ebc
		Vxx_mv_vb
		RSA_RecordLayout_Axis_UWORD
		25000
		hBgaFxb_zbgejFb_ewnyxac_mC__ooa
		9
		0.
		25000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_efi_purg_msf_egaf
		"Programmable exhaust gas air flow bkpts map for purge mass fraction interpolation"
		0x80058ff2
		Vxx_pft_egaf
		RSA_RecordLayout_Axis_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		8
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_efy_rgn
		"Programmable CSF efficiency breakpoints map"
		0x80045ce0
		Vxx_pft_efy_prct_reg
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		6
		0.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_patxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_egaf_cor_pat
		"Exhaust gas flow breakpoint table for catalist pressure drop calculation"
		0x80057d82
		Vxx_pft_egaf_cor
		RSA_RecordLayout_Axis_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		10
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_egaf_fms_efi_max_pr
		"Programmable breakpoints of exhaust gas flow for maximum exhaust fuel injection mass flow"
		0x80044c34
		Vxx_pft_egaf
		RSA_RecordLayout_Axis_UWORD
		2000
		movAqed_DtteCgd_cloonha_Bh__10a
		8
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrspt_elissxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_el_csm_n_sp_ofs
		"breackpoint table used for the calculation of the electric balance idle speed setpoint offset"
		0x8005ae5a
		SmIsrSpt_NVM.Vxx_el_csm_ctr_NVM
		RSA_RecordLayout_Axis_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		9
		0.
		255.
    FORMAT "%3.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_emtv_psn_ofs_disp_last_1
		"X breakpoint for curve of offset dispersion between two offset learning"
		0x80058b5e
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evdiagx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_emtv_psn_ofs_disp_last_2
		"X breakpoint for curve of offset dispersion between two offset learning for OBD purpose"
		0x80058b4c
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouasoegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoegr_evmonxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_emtv_pwl_act
		"Breakpoint table used with the cartography Ctp_emtv_pwl_act."
		0x80058bc0
		Vxx_emtv_t_pwl
		RSA_RecordLayout_Axis_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		16
		0.
		65.535
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiegr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiegr_evpossr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_emtv_sens_cor
		"Breakpoint table used with the cartography Ctp_it_sens_cor."
		0x80056fae
		Vxx_emtv_psn_chr
		RSA_RecordLayout_Axis_UWORD
		100
		xxtlvyb_AzqAaga_xjrbcpc_fn__0a0
		4
		0.
		100.
    FORMAT "%8.4" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_protcxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_eng_amp
		"atmopsheric pressure breakpoint of full load torque limitation"
		0x8005ba76
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_maxtqri_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_eng_amp_2
		"atmospheric pressure breakpoint of full load torque limitation."
		0x8005b89e
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		11
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_cor_ena_off_thd_rij
		"Breakpoint of Ctp_ex_prs_lim_cor_ena_off_thd_rij"
		0x8006144c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_cor_ena_on_thd_rij
		"Breakpoint of Ctp_ex_prs_lim_cor_ena_on_thd_rij"
		0x8006142a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_prs_cor_ena_off_thd_pr
		"Breakpoint of Ctp_ex_prs_lim_cor_ena_off_thd_pr"
		0x80060b66
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_prs_cor_ena_on_thd_pr
		"Breakpoint of Ctp_ex_prs_lim_cor_ena_on_thd_pr"
		0x80060b44
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_prs_sp_pft_cor_pr
		"Breakpoint of exhaust pressure setpoint correction due to particulate filter loading in pft regeneration mode"
		0x80060b2e
		Vxx_pft_dp
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		10
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_prs_sp_pft_cor_rij
		"Breakpoint of exhaust pressure setpoint correction due to particulate filter loading in regular injection mode"
		0x80061414
		Vxx_pft_dp
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		10
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_prs_sp_tkof_gear
		"Breakpoints of gear type definition in order to enable specific take off exhaust pressure setpoint"
		0x8006140a
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%4.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ex_prs_thd_h
		"Breakpoint of  exh_lim activation threshold table  depending on exhaust pressure setpoint"
		0x80043b1e
		Vxx_ex_prs_lim_sp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		10
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_fast_driv_spt_fac_pdl
		"Pedal difference breakpoints for fast driving style factor"
		0x800591e0
		Vxx_acel_pdl_dif
		RSA_RecordLayout_Axis_UWORD
		1
		Fyedevd_rnBqacd_ulakuub_roA_00a
		5
		0.
		1.
    FORMAT "%7.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcdrs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcdrs_drstyxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_fast_driv_spt_fac_vs
		"Vehicle speed breakpoints for fast driving style factor"
		0x800591d4
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		5
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_fast_off_pdl_grd
		"Ctb_fast_off_pdl_grd"
		0x80059342
		Vxx_pdl_grd
		RSA_RecordLayout_Axis_UWORD
		4000
		VA_F_0v125_m2000_5
		5
		-2000
		2000
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'vfcrkmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'vfcrkmng_mngtxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_fct_tco_crkm
		"Equally distributed breakpoints for Ctp_fct_tco_dly"
		0x8005cf06
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_adv_amp_fac_sta
		"Breakpoints of atmospheric pressure for starting set point tables"
		0x8006ae9a
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_amp_fac_pr
		"Programmable amospheric pressure breakpoints for global injection factor during pft regeneration"
		0x80044c22
		Vxx_amp_reg
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_faf_amp_fac_rij
		"Atmospheric pressure breakpoint of amp quantity of after injection factor during regular injection"
		0x80068c2c
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_faf_tco_fac_rij
		"Coolant temperature breakpoint of tco quantity of after injection factor during regular injection"
		0x80068c1a
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_faf_tia_fac_rij
		"Intake air temperature breakpoint of tia quantity of after injection factor during regular injection"
		0x80068c08
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp1_amp_fac_pr
		"Atmospheric pressure breakpoint of amp quantity of pre injection 1 factor during pft regeneration"
		0x8004bdf8
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp1_amp_fac_sta
		"Breakpoints of atmospheric pressure for pilote 1 quantity correction factor in starting mode"
		0x80068d1a
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp1_tco_fac_pr
		"Coolant temperature breakpoint of tco quantity of pre injection 1 factor during pft regeneration"
		0x8004bde6
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp1_tco_fac_rij
		"Coolant temperature breakpoint of tco factor interpolation for quantity of preinjection 1 during rij"
		0x8004a970
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp1_tia_fac_pr
		"Intake air temperature breakpoint of tia quantity of pre injection 1 factor during pft regeneration"
		0x8004bdd4
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp2_amp_fac_pr
		"Atmospheric pressure breakpoint of amp quantity of pre injection 2 factor during pft regeneration"
		0x8004c594
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp2_amp_fac_sta
		"Breakpoints of atmospheric pressure for pilote 2 quantity correction factor in starting mode"
		0x80068dfc
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp2_tco_fac_pr
		"Coolant temperature breakpoint of tco quantity of pre injection 2 factor during pft regeneration"
		0x8004c582
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp2_tco_fac_rij
		"Coolant temperature breakpoint of tco factor interpolation for quantity of preinjection 2 during rij"
		0x8004b406
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fp2_tia_fac_pr
		"Intake air temperature breakpoint of tia quantity of pre injection 2 factor during pft regeneration"
		0x8004c570
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fpo_amp_fac_pr
		"Atmospheric pressure breakpoint of amp quantity of post injection factor during pft regeneration"
		0x8004d1d4
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fpo_tco_fac_pr
		"Coolant temperature breakpoint of tco quantity of post injection factor during pft regeneration"
		0x8004d1c2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_fpo_tia_fac_pr
		"Intake air temperature breakpoint of tia quantity of post injection factor during pft regeneration"
		0x8004d1b0
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_ms_dp_fac_pr
		"Programmable CSF equivalent load breakpoints for global injection factor during pft regeneration"
		0x80044c10
		Vxx_pft_ms_dp_reg
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		8
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_taf_amp_fac_rij
		"Atmospheric pressure breakpoint of amp separation of after injection factor during regular injection"
		0x80069dd8
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_taf_tco_fac_rij
		"Coolant temperature breakpoint of tco separation of after injection factor during regular injection"
		0x80069dc6
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_taf_tia_fac_rij
		"Intake air temperature breakpoint of tia separation of after injection factor during regular injecti"
		0x80069db4
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tia_fac_pr
		"Programmable intake air temperature breakpoints for global injection factor during pft regeneration"
		0x80044bfe
		Vxx_tia_reg
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tp1_amp_fac_pr
		"Atmospheric pressure breakpoint of amp separation of pre injection 1 factor during pft regeneration"
		0x80053ed0
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tp1_tco_fac_pr
		"Coolant temperature breakpoint of tco separation of pre injection 1 factor during pft regeneration"
		0x80053ebe
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tp1_tco_fac_rij
		"Coolant temperature breakpoint of tco factor interpolation for separation of preinjection 1 during r"
		0x8005221c
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tp1_tia_fac_pr
		"Intake air temperature breakpoint of tia separation of pre injection 1 factor during pft regeneratio"
		0x80053eac
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tp2_amp_fac_pr
		"Atmospheric pressure breakpoint of amp separation of pre injection 2 factor during pft regeneration"
		0x800549a8
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tp2_tco_fac_pr
		"Coolant temperature breakpoint of tco separation of pre injection 2 factor during pft regeneration"
		0x80054996
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tp2_tia_fac_pr
		"Intake air temperature breakpoint of tia separation of pre injection 2 factor during pft regeneratio"
		0x80054984
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tpo_amp_fac_pr
		""
		0x8005523c
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tpo_tco_fac_pr
		""
		0x8005522a
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fms_tpo_tia_fac_pr
		""
		0x80055218
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fuel_rps_sp_fac_lim
		"Fuel temperature breakpoint of factor of rail pressure setpoint decrease by fuel temperature"
		0x80069184
		Vxx_fuel_temp
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fuel_rps_sp_lim_abs
		"Fuel temperature breakpoint of rail pressure setpoint limitation absolute"
		0x80069172
		Vxx_fuel_temp
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fwe_tco
		"Programmable engine coolant temperature bkpts map for fuel wear estimation"
		0x80058fe0
		Vxx_tco_clc
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_purgexx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fwe_tt
		"Measured temperature before turbine bkpts map for fuel wear estimation"
		0x80058fce
		Vxx_tt_clc
		RSA_RecordLayout_Axis_UWORD
		1200
		vwfEuxd_nycakvb_dhzaarc_qC_00oa
		8
		0.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_fzy_gear_typ
		"Breakpoints of gear type definition for fuzzification rules"
		0x8005f07c
		Vxx_gear_fzy
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_gear
		"Gearbox ratio breakpoint"
		0x8004319c
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%4.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_gear_fs
		"Ctb_gear_fs"
		0x800597ce
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UBYTE
		5
		VA_F_1_p1_1
		6
		1
		6
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_inj_cut_n
		"Breakpoint calibration of engine speed"
		0x8005b1da
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		7
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_inj_dist
		"Table of injector distance breakpoints for msot contribution"
		0x80046614
		Vxx_inj_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		4
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_inj_dist_min_rgn
		"Programmable injectors distance breakpoints."
		0x80046c9e
		Vxx_inj_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		6
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_inj_dist_wait_cdn
		"Programmable injectors mileage breakpoints map for waiting condition computation"
		0x80046d58
		Vxx_inj_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		6
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idactxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_is_in_ofs_drv
		"Breakpoint calibration of thresholds of entry to ISR"
		0x8005aaf2
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		16383
		ErwgDnb_wudaCDa_gAzibEd_rsA_o90
		6
		-8192.
		8191.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_is_n_d_dif
		"Static error breakpoints for idle speed regulator (case derivate)"
		0x8005aa4c
		Vxx_dif_n_sp
		RSA_RecordLayout_Axis_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		8
		-8192.
		8191.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_idctrxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_is_n_dif
		"Static error breakpoints for idle speed regulator"
		0x8005ab12
		Vxx_dif_n_sp
		RSA_RecordLayout_Axis_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		8
		-8192.
		8191.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_intxxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_is_n_i_dif
		"Static error breakpoints for idle speed regulator"
		0x8005ac9c
		Vxx_dif_n_sp
		RSA_RecordLayout_Axis_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		8
		-8192.
		8191.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_propxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_is_n_p_dif
		"Static error breakpoints for idle speed regulator (case proportional)"
		0x8005ad8e
		Vxx_dif_n_sp
		RSA_RecordLayout_Axis_UWORD
		16383.75
		cvxuqsa_qeEanfd_gyuanCd_rCRa38a
		8
		-8192.
		8191.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'smisrctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'smisrctl_dervxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_is_tco
		"Coolant temperature breakpoints for ISR set point tables"
		0x8005aa38
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_it_frst_ofs_act
		"Breakpoint table for the unique offset strategy."
		0x80058d5c
		Vxx_it_t_frst_ofs
		RSA_RecordLayout_Axis_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		16
		0.
		65.535
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_it_pwl_act
		"Breakpoint table used with the cartography Ctp_it_pwl_act."
		0x80058d3a
		Vxx_it_t_pwl_act
		RSA_RecordLayout_Axis_UWORD
		65.535
		nCcfksc_mngycBb_hCDnnsa_s__a00a
		16
		0.
		65.535
    FORMAT "%6.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiti.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiti_itpossr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_it_sens_cor
		"Breakpoint table used with the cartography Ctp_it_sens_cor."
		0x80057d08
		Vxx_it_chr_psn
		RSA_RecordLayout_Axis_UWORD
		100
		wmkbkad_wwidqld_lsCArsa_f__a40a
		4
		0.
		100.
    FORMAT "%12.8" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouasoito.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouasoito_itmonxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_it_sp_cor
		"Breakpoint table for the unique offset strategy"
		0x80058d18
		Vxx_it_psn_sp_3
		RSA_RecordLayout_Axis_UWORD
		200
		zDFkafa_eltfmfd_fbpbxpb_fA_0a8a
		16
		-100.
		100.
    FORMAT "%9.4" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsfofxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_law
		"Ctb_law"
		0x8005930f
		Vsx_law_sel
		RSA_RecordLayout_Axis_UBYTE
		4
		VA_F_1_p1_2
		5
		1
		5
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_loop_dev_fms_dg_add_cor
		"Programmable TBF loop deviation breakpoints for loop deviation derivative gain correction"
		0x80045842
		Vxx_pft_utp_reg_loop_dev
		RSA_RecordLayout_Axis_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		8
		-1200.
		1200.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_loop_dev_fms_ig_add_cor
		"Programmable TBF loop deviation breakpoints for loop deviation integral gain correction"
		0x80045830
		Vxx_pft_utp_reg_loop_dev
		RSA_RecordLayout_Axis_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		8
		-1200.
		1200.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_loop_dev_fms_pg_add_cor
		"Programmable TBF loop deviation breakpoints for loop deviation proportionnal gain correction"
		0x8004581e
		Vxx_pft_utp_reg_loop_dev
		RSA_RecordLayout_Axis_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		8
		-1200.
		1200.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'incbiueg.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'incbiueg_upscsxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_maf_dyn_hpf_fac
		"Dynamic mass air flow breakpoint for the filter time constant of the upstream proportional richness"
		0x8005839c
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		11
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_maf_efi_maf_err_fac_pr
		""
		0x80044bf0
		Vxx_fms_efi_maf_err_fil
		RSA_RecordLayout_Axis_UWORD
		6000
		tClffab_hirDflc_mxtqjrd_mtA_o00
		6
		-3000.
		3000.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_maf_flp_maf_err_fac_pr
		"Programmable mass air flow breakpoints for factor of maximum late post injection during pft regeneration"
		0x80044be2
		Vxx_fms_flp_maf_err_fil
		RSA_RecordLayout_Axis_UWORD
		6000
		tClffab_hirDflc_mxtqjrd_mtA_o00
		6
		-3000.
		3000.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_maf_pft_utp_sp_max
		"Programmable mass air flow breakpoints for TBF maximum setpoint value."
		0x80045cce
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		8
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_map_fail_amp
		"Ambiant pressure bkp for Map fail value correction calculation"
		0x80057776
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_map_fail_fim_tot
		"Total injected quantity bkp for MAP fail value calculation"
		0x80057764
		Vxx_fms_fim_tot
		RSA_RecordLayout_Axis_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		8
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_mapxxcs_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_map_fail_n
		"Engine speed bkp for  MAP fail value calculation"
		0x80057752
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_max_rams_tqe_3
		"Breakpoints for the safety vehicle speed limitation converted in torque limitation level 3 (strong)"
		0x8004323c
		Vxx_vs
		RSA_RecordLayout_Axis_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		12
		0.
		255.
    FORMAT "%3.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_max_rams_tqi_1
		"Breakpoints for the safety torque limitation level 1 (low)"
		0x80043222
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_tqramsx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_max_rams_tqi_2
		"Breakpoints for the safety torque limitation level 2 (mean)"
		0x80043208
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drtqexx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_min_driv_tqe_pwt_sp
		"Powertrain setpoint breakpoints for minimum driver engine torque factor"
		0x80059bb2
		Vxx_driv_pwt_sp
		RSA_RecordLayout_Axis_UWORD
		1
		qjFFggb_gqcrfFb_ycrdhkb_n_Ra0oa
		17
		0.
		1.
    FORMAT "%7.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrvdit.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrvdit_drarbxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_min_max_forc_vs
		"Vehicle speed  breakpoints for mi/max force tables"
		0x8004026e
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		9
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_mintqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_min_tqe_n
		"engine speed breakpoint for minimum torque"
		0x8005b1c4
		Vxx_n_dif_tq
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ms_dp_amp
		"Breakpoint table of atmospheric pressure"
		0x80058056
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ms_dp_dp
		"Breakpoint table of differential pressure"
		0x80058034
		Vxx_pft_ms_dp_dp_fil
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		16
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_msdpxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ms_dp_egaf
		"Breakpoint table of volumic exhaust flow"
		0x80058012
		Vxx_pft_ms_dp_egaf_cor
		RSA_RecordLayout_Axis_UWORD
		2000
		movAqed_DtteCgd_cloonha_Bh__10a
		16
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ms_fms_adv_ms_dp_fac_pr
		"Partilculate filter soot mass breakpoint of soot mass factor for main advance during pr"
		0x8006adac
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		8
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ms_pft_utp_var_sp
		"Programmable soot mass left breakpoints for CSF up temp variable setpoint"
		0x80045cbc
		Vxx_pft_ms_in
		RSA_RecordLayout_Axis_UWORD
		655.35
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		8
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ms_sta_asd_var_utp_sp
		"Programmable soot mass breakpoints for CSF up temp variable set point in ASD regeneration mode"
		0x80045caa
		Vxx_pft_ms_sta_asd
		RSA_RecordLayout_Axis_UWORD
		100
		CoFbbtd_Dqqnhod_ysddhoa_g_Ra0oa
		8
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_n
		"20 programmable engine speed breakpoints map"
		0x80058948
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		20
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'insmisyn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'insmisyn_speedxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_n2
		"9 programmable engine speed breakpoints table"
		0x80058934
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		9
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_n4
		"Engine speed  breakpoints for oil temperature computing"
		0x800585dc
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_n_alt
		"Engine speed breakpoints for alternator cartographies"
		0x8005ceae
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcopo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcopo_fsapgxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_n_apmp
		"Ctb_n_apmp"
		0x80059246
		Vxx_n_gear
		RSA_RecordLayout_Axis_UWORD
		16383.75
		VA_F_0v25_p0_7
		17
		0
		16383.75
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_amp_cor_pr
		"Breakpoints x for atmospheric pressure correction of exhaust pressure setpoint in pft regeneration mode"
		0x80060b0c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_amp_cor_rij
		"Breakpoints x for atmospheric pressure correction of exhaust pressure setpoint in regular injection mode"
		0x800613e8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_amp_tkof_pr
		"Breakpoints x for atmospheric pressure correction of exhaust pressure setpoint for take off assistance in rpft regeneration mode"
		0x80060af6
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_amp_tkof_rij
		"Breakpoints x for atmospheric pressure correction of exhaust pressure setpoint for take off assistance in regular injection mode"
		0x800613d2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_bas_pr
		"X breakpoint of basic exhaust pressure setpoint in pft regeneration mode"
		0x80060ad4
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_bas_rij
		"X breakpoint of basic exhaust pressure setpoint in regular injection mode"
		0x800613b0
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_max_pr
		"Breakpoint of exhaust pressure max limitation in pft regeneration mode"
		0x80060abe
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_max_rij
		"Breakpoint of exhaust pressure max limitation in regular injection mode"
		0x8006139a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_pft_cor_pr
		"X breakpoint of exhaust pressure set point correction in pft regeneration mode"
		0x80060a9c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_pft_cor_rij
		"X breakpoint of exhaust pressure set point correction in regular injection mode"
		0x80061378
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_tia_cor_pr
		"Breakpoints x for air temperature correction of exhaust pressure setpoint in pft regeneration mode"
		0x80060a7a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_tia_cor_rij
		"Breakpoints x for air temperature correction of exhaust pressure setpoint in regular injection mode"
		0x80061356
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_tia_tkof_pr
		"Breakpoints x for air temperature correction of exhaust pressure setpoint for take off assistance in pft regeneration mode"
		0x80060a64
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_ex_prs_sp_tia_tkof_rij
		"Breakpoints x for air temperature correction of exhaust pressure setpoint for take off assistance in regular injection mode"
		0x80061340
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_0p_rij
		"Engine speed breakpoint of main advance without pre-injection"
		0x80050f72
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_1p_rij
		"Engine speed breakpoint of main advance with 1 pre-injection"
		0x80050f50
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_2p_rij
		"Engine speed breakpoint of main advance with 2 pre-injections"
		0x80050f2e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction for main advance during pr"
		0x8006ad92
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_amp_tco_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction for main advance"
		0x80050f14
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_aut_eng_cor_rij
		"Engine speed breakpoint of autonomous engine correction for main advance during rij"
		0x80050efa
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_dp_map_cor_rij
		"Engine speed breakpoint of delta mass air pressure factor for main advance during rij"
		0x80050ee0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_dp_rps_cor_pr
		"Engine speed breakpoint of delta rail pressure correction for main advance during pr"
		0x8006ad78
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_dp_rps_cor_rij
		"Engine speed breakpoint of delta rail pressure factor for main advance during rij"
		0x80050ec6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_gear_rij
		"Engine speed breakpoint of main advance with specific gearbox ratio."
		0x80050ea4
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_max_pr
		"Engine speed breakpoint of maximun for main advance during pr"
		0x8006ad62
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_max_rij
		"Engine speed breakpoint of maximun for main advance"
		0x80050e8e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_min_pr
		"Engine speed breakpoint of minimum for main advance during pr"
		0x8006ad4c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_min_rij
		"Engine speed breakpoint of minimum for main advance"
		0x80050e78
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_ms_dp_cor_pr
		"Engine speed breakpoint of soot mass correction for main advance during pr"
		0x8006ad32
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction for main advance during pr"
		0x8006ad18
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_tia_cor_pr
		"Engine speed breakpoint of atmospheric temperature correction for main advance during pr"
		0x8006acfe
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_adv_tia_tco_cor_rij
		"Engine speed breakpoint of atmospheric temperature correction for main advance"
		0x80050e5e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_amp_cor_pr
		"Programmable engine speed breakpoints for atmospheric pressure correction for global fuel injection during pft rgn"
		0x80044bc8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_adv_0p_pr
		"Engine speed breakpoint of base main advance without pre-injection during pr"
		0x8006acec
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_adv_1p_pr
		"Engine speed breakpoint base main advance with 1 pre-injection during pr"
		0x8006acca
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_adv_2p_pr
		"Engine speed breakpoint base main advance with 2 pre-injections during pr"
		0x8006aca8
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_fp1_2p_pr
		"Engine speed breakpoint of basic quantity of pre-injection 1 with 2 pre-injection during pft rgn"
		0x8004bdb2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_fp1_pr
		"Engine speed breakpoint of basic quantity of pre-injection 1 during pft regeneration"
		0x8004bd90
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_fp2_pr
		"Engine speed breakpoint of basic quantity of pre-injection 2 during pft regeneration"
		0x8004c54e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_fpo_pr
		"Engine speed breakpoint of basic quantity of post injection during pft regeneration"
		0x8004d18e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_tlp_pr
		"Engine speed breakpoint of basic angle of late post injection during pft regeneration"
		0x8004f35a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_tp1_2p_pr
		"Engine speed breakpoint of basic separation of pre-injection 1 with 2 pre-injection during pft rgn"
		0x80053e8a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_tp1_pr
		"Engine speed breakpoint of basic separation of pre-injection 1 during pft regeneration"
		0x80053e68
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_tp2_2p_pr
		"Engine speed breakpoint of basic separation of pre-injection 2 with 2 pre-injection during pft rgn"
		0x80054962
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_tp2_pr
		"Engine speed breakpoint of basic separation of pre-injection 2 during pft regeneration"
		0x80054940
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_bas_tpo_pr
		"Engine speed breakpoint of basic angle of post injection during pft regeneration"
		0x800551f6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_dyn_phi_ofs_nxt_cyl
		"n-breakpoints for map maximum variation of angle of first injection on next cylinder."
		0x8006924a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_efi_maf_err_fac_pr
		"Programmable breakpoints of exhaust gas flow for maximum exhaust fuel injection mass flow"
		0x80044bba
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_efi_max_pr
		"Programmable engine speed breakpoints for maximum quantity of exhaust fuel injection during pft rgn"
		0x80044b98
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_efi_min_pr
		"Programmable engine speed breakpoints for minimum quantity of exhaust fuel injection during pft rgn"
		0x80044b82
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_faf_amp_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction during regular injection"
		0x80068bee
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_faf_max_rij
		"Engine speed breakpoint of maximum quantity of after injection during regular injection"
		0x80068bd8
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_faf_rij
		"Engine speed breakpoint of quantity of after injection for cold coolant temperature during rij"
		0x80068bb6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_faf_tia_cor_rij
		"Engine speed breakpoint of intake air temperature correction during regular injection"
		0x80068b9c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_flp2_wish_h
		"Engine speed breakpoint for hugh level of activation of split late post injection"
		0x800498a2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_flp_maf_err_fac_pr
		"Programmable engine breakpoint for factor for maximum quantity of late post injection during pft rgn"
		0x80044b74
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_flp_max_pr
		"Engine speed breakpoint of maximum quantity of late post injection during pft regeneration"
		0x80044b52
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_flp_min_pr
		"Programmable engine speed breakpoints for minimum quantity of late post injection during pft rgn"
		0x80044b3c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_2p_rij
		"Engine speed breakpoint of quantity of pre injection 1 for cold tco with 2 pre injection during rij"
		0x8004a94e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction of pre injection 1 during pft rgn"
		0x8004bd76
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_amp_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction during regular injection"
		0x8004a934
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_amp_cor_sta
		"Engine speed breakpoints for starting set point correction table"
		0x80068d0c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_max_pr
		"Engine speed breakpoint of maximum quantity of pre-injection 1 during pft regeneration"
		0x8004bd60
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_max_rij
		"Engine speed breakpoint of maximum quantity of pre-injection 1 during regular injection"
		0x8004a91e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_rij
		"Engine speed breakpoint of quantity of pre injection 1 during rij"
		0x8004a8fc
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction of pre injection 1 during pft rgn"
		0x8004bd46
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_tia_cor_pr
		"Engine speed breakpoint of intake air temperature correction of pre injection 1 during pft rgn"
		0x8004bd2c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp1_tia_cor_rij
		"Engine speed breakpoint of intake air temperature correction during regular injection"
		0x8004a8e2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction of pre injection 2 during pft rgn"
		0x8004c534
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_amp_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction during rij"
		0x8004b3ec
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_amp_cor_sta
		"Engine speed breakpoints for starting set point correction table"
		0x80068dee
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_max_pr
		"Engine speed breakpoint of maximum quantity of pre-injection 2 during pft regeneration"
		0x8004c51e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_max_rij
		"Engine speed breakpoint of maximum quantity of pre-injection 2 during regular injection"
		0x8004b3d6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_rij
		"Engine speed breakpoint of quantity of pre-injection 2 during rij"
		0x8004b3b4
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction of pre injection 2 during pft rgn"
		0x8004c504
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_tia_cor_pr
		"Engine speed breakpoint of intake air temperature correction of pre injection 2 during pft rgn"
		0x8004c4ea
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fp2_tia_cor_rij
		"Engine speed breakpoint of intake air temperature correction during regular injection"
		0x8004b39a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fpo_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction during pft regeneration"
		0x8004d174
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fpo_max_pr
		"Engine speed breakpoint of maximum quantity of post injection during pft regeneration"
		0x8004d15e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fpo_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction during pft regeneration"
		0x8004d144
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_fpo_tia_cor_pr
		"Engine speed breakpoint of intake air temperature correction during pft regeneration"
		0x8004d12a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_ms_dp_cor_pr
		"Programmable engine speed breakpoints for CSF equivalent load correction of global injection during pft rgn"
		0x80044b22
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_pinj_cut_1
		"Engine speed breakpoint of the pre injection cut one"
		0x8004ca38
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_pinj_cut_2
		"Engine speed breakpoint of the pre injection cut two"
		0x8004ca26
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_pinj_cut_3
		"Engine speed breakpoint of the pre injection cut three"
		0x8004ca14
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_pinj_cut_4
		"Engine speed breakpoint of the pre injection cut four"
		0x8004ca02
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_pinj_cut_5
		"Engine speed breakpoint of the pre injection cut five"
		0x8004c9f0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_taf_amp_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction during regular injection"
		0x80069d9a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_taf_max_rij
		"Engine speed breakpoint of maximum separation of after injection during regular injection"
		0x80069d84
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_taf_min_rij
		"Engine speed breakpoint of minimum separation of after injection during regular injection"
		0x80069d6e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_taf_rij
		"Engine speed breakpoint of separation of after injection during rij"
		0x80069d4c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_taf_tia_cor_rij
		"Engine speed breakpoint of intake air temperature correction during regular injection"
		0x80069d32
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tia_cor_pr
		"Programmable engine speed breakpoints for intake air temperature correction of global injection during pft rgn"
		0x80044b08
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tlp_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction for late post injection during pft rgn"
		0x8004f340
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tlp_max_pr
		"Engine speed breakpoint of maximum angle of late post injection during pft regeneration"
		0x8004f32a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tlp_min_pr
		"Engine speed breakpoint of minimum angle of late post injection during pft regeneration"
		0x8004f314
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tlp_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction for late post injection during pft rgn"
		0x8004f2fa
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tlp_tia_cor_pr
		"Engine speed breakpoint of intake air temperature correction for late post injection during pft rgn"
		0x8004f2e0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_2p_rij
		"Engine speed breakpoint of separation of pre-injection 1 with 2 pre-injection during rij"
		0x800521fa
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction of pre injection 1 during pft rgn"
		0x80053e4e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_amp_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction during regular injection"
		0x800521e0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_max_pr
		"Engine speed breakpoint of maximum separation of pre-injection 1 during pft regeneration"
		0x80053e38
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_max_rij
		"Engine speed breakpoint of maximum separation of pre-injection 1 during regular injection"
		0x800521ca
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_min_pr
		"Engine speed breakpoint of minimum separation of pre-injection 1 during pft regeneration"
		0x80053e22
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_min_rij
		"Engine speed breakpoint of minimum separation of pre-injection 1 during regular injection"
		0x800521b4
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_rij
		"Engine speed breakpoint of separation of pre-injection 1 during rij"
		0x80052192
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction of pre injection 1 during pft rgn"
		0x80053e08
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_tia_cor_pr
		"Engine speed breakpoint of intake air temperature correction of pre injection 1 during pft rgn"
		0x80053dee
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp1_tia_cor_rij
		"Engine speed breakpoint of intake air temperature correction during regular injection"
		0x80052178
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_2p_rij
		"Engine speed breakpoint of separation of pre-injection 2 for cold tco with 2 pre-injection during rij"
		0x800533da
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction of pre injection 2 during pft rgn"
		0x80054926
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_amp_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction during rij"
		0x800533c0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_max_pr
		"Engine speed breakpoint of maximum separation of pre-injection 2 during pft regeneration"
		0x80054910
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_max_rij
		"Engine speed breakpoint of maximum separation of pre-injection 2 during regular injection"
		0x800533aa
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_min_pr
		"Engine speed breakpoint of minimum separation of pre-injection 2 during pft regeneration"
		0x800548fa
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_min_rij
		"Engine speed breakpoint of minimum separation of pre-injection 2 during regular injection"
		0x80053394
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_rij
		"Engine speed breakpoint of separation of pre-injection 2 for cold coolant temperature during rij"
		0x80053372
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction of pre injection 2 during pft rgn"
		0x800548e0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_tia_cor_pr
		"Engine speed breakpoint of intake air temperature correction of pre injection 2 during pft rgn"
		0x800548c6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tp2_tia_cor_rij
		"Engine speed breakpoint of intake air temperature correction during regular injection"
		0x80053358
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tpo_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction during pft regeneration"
		0x800551dc
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tpo_max_pr
		"Engine speed breakpoint of maximum angle of post injection during pft regeneration"
		0x800551c6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tpo_min_pr
		"Engine speed breakpoint of minimum angle of post injection during pft regeneration"
		0x800551b0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tpo_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction during pft regeneration"
		0x80055196
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_tpo_tia_cor_pr
		"Engine speed breakpoint of intake air temperature correction during pft regeneration"
		0x8005517c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimsck_lpostsc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_fms_wish_tlp2
		"Engine speed breakpoint for Late post injection 2 desired timing separation"
		0x80069238
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_lpos_efi_exo_fac
		"Programmable engine speed breakpoints for phisical fuel flow exotherm adaptation from late post injection to exhaust fuel injection"
		0x80044ae6
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiaf.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiaf_mafxxsr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_maf_cor
		"Engine speed breakpoint for the pulsation correction"
		0x80057674
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		18
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_fms_cor
		"Programmable engine speed breakpoints for basic injected fuel mass flow settings correction."
		0x8004580c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_fms_dg
		"Programmable engine speed breakpoints for derivative gain of injected fuel mass flow control"
		0x800457fa
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_fms_ig
		"Programmable engine speed breakpoints for integral gain of of injected fuel mass flow control"
		0x800457e8
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_fms_pg
		"Programmable engine speed breakpoints for proportional gain of injected fuel mass flow control"
		0x800457d6
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_inj_fms_bas
		"Programmable engine speed breakpoints for the late post injection mass fraction basic settings"
		0x800457b4
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_neg_dev
		"Programmable engine speed breakpoints for negative deviation of TBF regulaion"
		0x80044d84
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregdgn_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_pos_dev
		"Programmable engine speed breakpoints for positive deviation of temperature regulation"
		0x80044d72
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_utp_bas
		"Programmable engine speed breakpoints for the value of CSF up temp with base setting"
		0x800457a2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_utp_bas_ftc
		"Programmable engine speed breakpoints for the value of filter time for CSF up temp with base setting"
		0x80045790
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_utp_inj_fms_fac
		"Programmable engine speed breakpoints for the CSF up temp / injected fuel mass flow gain"
		0x8004577e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspv_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_utp_reg_on_stt
		"Programmable engine speed breakpoints for CSF up temp regulation activation state"
		0x800458e2
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_utp_reg_ovs
		"Programmable engine speed breakpoints for CSF up temp regulator overshoot"
		0x80045c98
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_utp_sp
		"Programmable engine speed breakpoints for CSF up temp regulator setpoint"
		0x80045c86
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_pft_utp_sp_max
		"Programmable engine speed breakpoints for the maximum value of CSF up temp setpoint"
		0x80045c74
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_0p_pr
		"Engine speed breakpoint of base rail pressure without pre-injection during pr"
		0x8004db86
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_0p_rij
		"Engine speed breakpoint of rail pressure for medium coolant temperatrure without pre-injection"
		0x8004ea44
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_1p_pr
		"Engine speed breakpoint base rail pressure with 1 pre-injection during pr"
		0x8004db64
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_1p_rij
		"Engine speed breakpoint of rail pressure for medium coolant temperatrure with 1 pre-injection"
		0x8004ea22
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_amp_cor_pr
		"Engine speed breakpoint of atmospheric pressure correction for rail pressure during pr"
		0x8004db4a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_amp_tco_cor_rij
		"Engine speed breakpoint of atmospheric pressure correction for rail pressure"
		0x8004ea08
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_grd_prs_inc_prs
		""
		0x80069150
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_max_pr
		"Engine speed breakpoint of maximum rail pressure set point during pr"
		0x8004db34
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_max_rij
		"Engine speed breakpoint of maximun for rail pressure"
		0x8004e9f2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_min_pr
		"Engine speed breakpoint of minimum for rail pressure during pr"
		0x8004db1e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_min_rij
		"Engine speed breakpoint of minimum for rail pressure"
		0x8004e9dc
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_sp_amp_cor_sta
		"Engine speed breakpoints for starting set point correction table"
		0x80068eea
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_sp_dec
		"Engine speed breakpoint of rail pressure setpoint decrease by fuel temperature"
		0x8006913e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_sp_lim_abs
		"Engine speed breakpoint of rail pressure setpoint limitation absolute"
		0x8006912c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_tco_cor_pr
		"Engine speed breakpoint of coolant temperature correction for rail pressure during pr"
		0x8004db04
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_tia_cor_pr
		"Engine speed breakpoint of atmospheric temperature correction for rail pressure during pr"
		0x8004daea
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_rps_tia_tco_cor_rij
		"Engine speed breakpoint of atmospheric temperature correction for rail pressure"
		0x8004e9c2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_spg_sp_max_fac
		"Breakpoints x for setpoint limitation factor depending on intake air temperature"
		0x80043a96
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_fms_adv_sta_n
		"Engine speed breakpoints for starting set point tables"
		0x8006ae8c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainsta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_fms_adv_sta_tco
		"Coolant temperature breakpoints for starting set point tables"
		0x8006ae7e
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_fms_fp1_sta_n
		"Engine speed breakpoints for starting set point tables"
		0x80068cfe
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_fms_fp1_sta_tco
		"Coolant temperature breakpoints for starting set point tables"
		0x80068cf0
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_fms_fp2_sta_n
		"Engine speed breakpoints for starting set point tables"
		0x80068de0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_fms_fp2_sta_tco
		"Coolant temperature breakpoints for starting set point tables"
		0x80068dd2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_rps_sp_sta_n
		"Engine speed breakpoints for starting set point tables"
		0x80068edc
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_rps_sp_sta_tco
		"Coolant temperature breakpoints for starting set point tables"
		0x80068ece
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_tsp_tp1_sta_n
		"Engine speed breakpoints for starting set point tables"
		0x8006af98
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_tsp_tp1_sta_tco
		"Coolant temperature breakpoints for starting set point tables"
		0x8006af8a
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_tsp_tp2_sta_n
		"Engine speed breakpoints for starting set point tables for pre injection 2 separation"
		0x8006b07a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tco_tsp_tp2_sta_tco
		"Coolant temperature breakpoints for starting set point tables for pre injection 2 separation"
		0x8006b06c
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tsp_tp1_amp_cor_sta
		"Engine speed breakpoints for starting set point tables corrections"
		0x8006af7c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tsp_tp2_amp_cor_sta
		"Engine speed breakpoints for starting set point tables corrections for pre injection 2 separation"
		0x8006b05e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		6
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tt_bas
		"Programmable engine speed breakpoints for the ttr measure with engine basic settings"
		0x8004576c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tt_bas_ftc
		"Programmable engine speed breakpoints for the ttr measure filtering constants"
		0x8004575a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_tt_pft_utp_fac
		"Programmable engine speed breakpoints for factor to convert ttr difference to an equivalent CSF up temp difference"
		0x80045748
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstctl_rcocxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_n_vnt_emtv_psn_thd
		"Breakpoints x of emtv position threshold to force i part initialisation"
		0x8005f06a
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ocd_dly_fct_egaf
		"Programmable exhaust gas air flow breakpoints for inert DOC model delay caculation"
		0x80043c50
		Vxx_pft_sys_egaf
		RSA_RecordLayout_Axis_UWORD
		0.65535
		RB_CONV_AtCatDgn_Kg_s_00001
		9
		0.
		0.65535
    DISPLAY_IDENTIFIER Ctb_ocd_dly_fct_egaf 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ocd_n_mv
		"Programmable engine speed breakpoints for post injection calibration"
		0x80043c3e
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		RB_CONV_AtCatDgn_rpm
		8
		0.
		16383.75
    DISPLAY_IDENTIFIER Ctb_ocd_n_mv 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ocd_t_fct_egaf
		"Programmable exhaust gas air flow breakpoints for time constant calculation in filtering of pre catalyst exhaust gas temperature"
		0x80043c26
		Vxx_pft_sys_egaf
		RSA_RecordLayout_Axis_UWORD
		0.65535
		RB_CONV_AtCatDgn_Kg_s_00001
		11
		0.
		0.65535
    DISPLAY_IDENTIFIER Ctb_ocd_t_fct_egaf 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atcatdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atcatdgn_catdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_ocd_tqi_sp
		"Programmable torque breakpoints for post injection calibration"
		0x80043c14
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		RB_CONV_AtCatDgn_32_Nm_0
		8
		0.
		2047.96875
    DISPLAY_IDENTIFIER Ctb_ocd_tqi_sp 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_oil_dil_max_oil_eva
		"Ctp_dil_max_eva_kin_fac_cor breakpoints"
		0x8005547a
		ClLubWea_NVM.Vxx_pft_oil_dil_max_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		RB_CONV_100_65535_Prc
		12
		0.0
		100.0
    DISPLAY_IDENTIFIER Ctb_oil_dil_max_oil_eva 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ovh_n
		"engine speed breakpoints map for over heating"
		0x8005b93c
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		5
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ovh_tco
		"Coolant temperature breakpoints map for over heating"
		0x8005b92e
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ovh_toil
		"Oil temperature breakpoints map for over heating"
		0x8005b920
		Vxx_toil
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ovh_up_it_temp
		"Manifold air temperature breakpoints map for over heating"
		0x8005b912
		Vxx_up_it_temp
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_ovhtqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ovh_vs
		"Vehicle speed breakpoints map for over heating"
		0x8005b90c
		Vxx_vs
		RSA_RecordLayout_Axis_UBYTE
		255
		FfBqnda_Bdvwydd_aAwtuCb_khA_10a
		5
		0.
		255.
    FORMAT "%3.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_owe_oil_dil
		"Ctp_owe_dil _breakpoints"
		0x8006b166
		Vxx_oil_dil
		RSA_RecordLayout_Axis_UWORD
		100
		RB_CONV_100_65535_Prc
		8
		0.0
		100.0
    DISPLAY_IDENTIFIER Ctb_owe_oil_dil 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_owe_toil
		"Ctp_owe_toil breakpoints"
		0x8006b154
		Vxx_toil
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_owe_toil 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_owe_toil_fac
		"Ctp_owe_toil_fac  breakpoints"
		0x8006b142
		Vxx_owe_toil_tco
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_owe_toil_fac 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_owe_toil_off
		"Cmp_owe_toil_prev_crkg  X breakpoints"
		0x8006b130
		ClLubWea_NVM.Vxx_owe_toil_eng_off_prev_NVM
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_owe_toil_off 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oxixxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_owe_toil_sta
		"Cmp_owe_toil_prev_crkg  Y breakpoints"
		0x8006b11e
		Vxx_owe_toil_sta
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_owe_toil_sta 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftafs.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftafs_asdcsfx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_asd_n_is_prct
		"Programmable time spent in idle speed ratio breakpoints"
		0x80045d17
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UBYTE
		100
		RB_CONV_100_255_Prc
		8
		0.0
		100.0
    DISPLAY_IDENTIFIER Ctb_pft_asd_n_is_prct 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_cal_cpy_ehr_itl_temp
		"Programmable temperatures breakpoints map for interpolation of pft ehr gaz calorific capacity"
		0x80046b42
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		8
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_delta_temp_fil
		"Programmable breakpoints table of temperatures for soot mass estimation factor map"
		0x8004691e
		Vxx_pft_delta_temp_fil
		RSA_RecordLayout_Axis_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_efy
		"Programmable filter efficiency breakpoints for CSF diagnosis"
		0x80045f58
		Vxx_pft_efy_prct
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		9
		0.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_efy_lkg
		"Programmable filter efficiency breakpoints for CSF diagnosis in overload particulate filter"
		0x80046600
		Vxx_pft_efy_prct
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		9
		0.
		200.
    FORMAT "%4.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_egaf_fil
		"Programmable air flow breakpoints for diagnosis interpolation (no visualization)"
		0x80045f4a
		Vxx_pft_diag_egaf_fil
		RSA_RecordLayout_Axis_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		6
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_egaf_fil2
		"Programmable air flow breakpoints for diagnosis interpolation (no visualization)"
		0x80045f34
		Vxx_pft_diag_egaf_fil
		RSA_RecordLayout_Axis_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		10
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_egaf_fil2_lkg
		"Programmable air flow breakpoints for diagnosis interpolation (no visualization)"
		0x800465ea
		Vxx_pft_diag_egaf_fil_lkg
		RSA_RecordLayout_Axis_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		10
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_csfdiag_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_egaf_fil3
		"Programmable exhaust gas flow class breakpoints for diagnosis interpolation"
		0x80045f28
		Vxx_pft_diag_egaf_fil3
		RSA_RecordLayout_Axis_UBYTE
		255
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		10
		0.
		255.
    FORMAT "%3.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_gear
		"Programmable engaged gear breakpoints for diagnosis enabling."
		0x80046404
		Vxx_gear
		RSA_RecordLayout_Axis_UBYTE
		7
		rCyphhc_iqjnskc_Fqnyhwb_n_R0ooa
		8
		-1.
		6.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_obdmalf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_diag_n
		"Programmable engine speed breakpoints for diagnosis enabling."
		0x800463e2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_dil_rat
		"Programmable oil dilution rate breakpoint"
		0x80046c8c
		Vxx_oil_dil
		RSA_RecordLayout_Axis_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		8
		0.
		100.
    FORMAT "%12.8" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_dist_load_min
		"Programmable oil dilution breakpoint"
		0x80046c7e
		Vxx_oil_dil
		RSA_RecordLayout_Axis_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		6
		0.
		100.
    FORMAT "%12.8" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_dist_ms_new_pft_ofs
		"Breakpoint of Driven distance since new soot filter low resolution"
		0x800468ac
		Vxx_pft_vh_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		8
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_efi_itl_cp
		"Breakpoints for material calorific capacity"
		0x80058312
		Vxx_efi_itl_ar_temp
		RSA_RecordLayout_Axis_UWORD
		1240
		dFjxvqb_bnBujga_oeusmlb_K__an3a
		6
		233.
		1473.
    FORMAT "%4.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_efi_prs_pwm_cor
		"Programmable efi fuel relative pressure breakpoints map for efi injector cycling opening percentage"
		0x80058eaa
		Vxx_pft_efi_fuel_rel_prs
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_efy_ms_comb
		"Programmable breakpoints csf efficiency map for soot mass interpolation"
		0x80068020
		Vxx_pft_efy_prct_comb
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		6
		0.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_efy_ms_stop
		"Programmable breakpoints map for soot mass stop interpolation"
		0x80068012
		Vxx_pft_efy_prct_comb
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		6
		0.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_efy_rgn
		"a_at_pft_mng_chgtend/Programmable CSF efficiency breakpoints map"
		0x800470da
		Vxx_pft_efy_prct_thd
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		6
		0.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouatoefi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouatoefi_command_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_egaf
		"Programmable exhaust gas air flow breakpoints map for samping time"
		0x80058e98
		Vxx_pft_egaf
		RSA_RecordLayout_Axis_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		8
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftdgn.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftdgn_sttclog_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_egaf_ind_lkg
		"Programmable exhaust gas flow class breakpoints for diagnosis interpolation"
		0x800465de
		Vxx_pft_egaf_ind_lkg
		RSA_RecordLayout_Axis_UBYTE
		10
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		10
		0.
		10.
    FORMAT "%2.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_egaf_mv_zon
		"Programmable breakpoints table of exhaust gaz air flow"
		0x8004689a
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		2000
		ppmBusd_Dwihbha_vDEsrCc_mhA_10a
		8
		0.
		2000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_egaf_tt_efi_int
		"Programmable indicated breakpoints map for thermal convection calculus."
		0x800582fc
		Vxx_pft_egaf_tt_efi_int
		RSA_RecordLayout_Axis_UWORD
		6553.5
		ykmzBoa_nqupBma_Ffvbarc_m_R0ooa
		10
		0.
		6553.5
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_ehr_clc_dtp_dly1
		"Programmable breakpoints table of soot combustion speed."
		0x80046b04
		Vxx_pft_ehr_clc_dtp1_dly
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		30
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_ehr_clc_dtp_dly2
		"Programmable breakpoints table of soot combustion speed."
		0x80046ac6
		Vxx_pft_ehr_clc_dtp2_dly
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		30
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_ehr_clc_dtp_dly3
		"Programmable breakpoints table of soot combustion speed."
		0x80046a88
		Vxx_pft_ehr_clc_dtp3_dly
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		30
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_eng_sp
		"Programmable breakpoints of engine operating point"
		0x80046c78
		Vsx_pft_eng_sp
		RSA_RecordLayout_Axis_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		4
		0.
		3.
    FORMAT "%1.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atspvarb.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvarb_combreq_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_eng_sp_agb_req
		"Programmable breakpoint of engine operating point for automatic gearbox request"
		0x8004714a
		Vsx_pft_eng_sp
		RSA_RecordLayout_Axis_UBYTE
		3
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		4
		0.
		3.
    FORMAT "%1.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_mdlcb1d_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_ext_cnvt_fac_vs
		"Programmable speed breakpoints map for interpolation of external convection coefficient"
		0x80046a76
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		8
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_inj_dist_rgn
		"Programmable injectors distance breakpoints."
		0x800470cc
		Vxx_inj_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		6
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_max_rgn_t_csm
		"Programmable breakpoints map for max regeneration time interpolation with injected fuel"
		0x80068004
		Vxx_csm_sum_sta_drv_fil_rgn
		RSA_RecordLayout_Axis_UWORD
		65535
		jnmsFhb_uzcgAAb_akuvuka_msA_10a
		6
		0.
		65535.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_max_rgn_t_vs
		"Programmable breakpoints map for max timing interpolation with vehicule speed"
		0x80067ff6
		Vxx_pft_vs_fil
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		6
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgnreqx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_min_rgn_df_val_t
		"Programmable breakpoints map for max timing interpolation with vehicle speed"
		0x80067fe8
		Vxx_pft_vs_fil
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		6
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_ms_test
		"Programmable breakpoints map of mass soot"
		0x8004688e
		Vtx_pft_ms_test[0]
		RSA_RecordLayout_Axis_UWORD
		510
		arAgssb_cAzswia_pjzaDlc_gA_020a
		5
		-255.
		255.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_n_oil_1
		"programmable engine speed breakpoints map for oil dilution interpolation"
		0x80055458
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		RB_CONV_rpm
		16
		0
		16383.75
    DISPLAY_IDENTIFIER Ctb_pft_n_oil_1 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_n_oil_3
		"Ctp_pft_n_tqi_sp_oil_eva breakpoints"
		0x80055438
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		RB_CONV_rpm
		15
		0
		16383.75
    DISPLAY_IDENTIFIER Ctb_pft_n_oil_3 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_n_oil_csm
		"Programmable engine speed breakpoints map for engine oil consumption interpolation"
		0x800584f0
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_n_oil_flp_bas
		"Cmp_pft_flp_pr_bas_oil_dil  X breakpoints"
		0x80055416
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		RB_CONV_rpm
		16
		0
		16383.75
    DISPLAY_IDENTIFIER Ctb_pft_n_oil_flp_bas 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_n_oil_rij_bas
		"Cmp_pft_n_tqi_sp_oil_rij  X breakpoints"
		0x800553fa
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		RB_CONV_rpm
		13
		0
		16383.75
    DISPLAY_IDENTIFIER Ctb_pft_n_oil_rij_bas 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_chgxxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_nr_driv_cdn
		"Programmable breakpoints map for mass soot estimator parameters maps."
		0x8004688a
		Vxx_pft_nr_driv_cdn
		RSA_RecordLayout_Axis_UBYTE
		1
		pyyBnbb_Ayghjkd_Fqnyxwb_n_R0ooa
		2
		0.
		1.
    FORMAT "%3.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_o2_fac_sot_esti
		"Programmable breakpoints table of O2 concentration for combustion speed interpolation"
		0x80046914
		Vxx_pft_o2_fac_sot_esti
		RSA_RecordLayout_Axis_UWORD
		200
		gBspFma_crfhuEa_yctdhoa_f_Ra0oa
		4
		0.
		200.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_oil_dil_dist_rgn_cold
		"Programmable oil dilution breakpoint"
		0x800470ba
		Vxx_oil_dil
		RSA_RecordLayout_Axis_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		8
		0.
		100.
    FORMAT "%12.8" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_oil_dil_dist_rgn_hot
		"Programmable oil dilution breakpoint in hot conditions"
		0x800470a8
		Vxx_oil_dil
		RSA_RecordLayout_Axis_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		8
		0.
		100.
    FORMAT "%12.8" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_oil_dil_dist_rgn_med
		"Programmable oil dilution breakpoint in medium conditions"
		0x80047096
		Vxx_oil_dil
		RSA_RecordLayout_Axis_UWORD
		100
		Edjqxvd_mqsonha_pgCaqfb_f__6o0a
		8
		0.
		100.
    FORMAT "%12.8" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmdl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmdl_combxxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_temp_fac_sot_esti
		"Programmable breakpoints table of temperatures for interpolation of combustion speed"
		0x80046906
		Vxx_pft_temp_fac_sot_esti
		RSA_RecordLayout_Axis_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_catheat_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_cata_hot
		"Programmable manifold air temperature breakpoints map"
		0x80067f10
		Vxx_tia_cata
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chktmpx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_chk_temp
		"Programmable breakpoints map for intake air temperature"
		0x80067f72
		Vxx_tia_temp
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_cold_cdn
		"Programmable air temperature breakpoints map (cold conditions)"
		0x8006816e
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_forc_rgn
		""
		0x80068162
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_hot_cdn
		"Programmable air temperature breakpoints map ( hot conditions)"
		0x80068156
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atspvexc.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atspvexc_engpopx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_med_cdn
		"Programmable air temperature breakpoints map ( medium rgn conditions)"
		0x8006814a
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_mv_dist_min
		"Programmable breakpoints of inlet air temperature"
		0x80046c6a
		Vxx_pft_tia_mv_lh
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_mv_dist_thd
		"Programmable breakpoint of air temperature average value for distance threshold."
		0x80047084
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_mv_err_ctr
		"Programmable breakpoints for Intake air temperature average value used in maximum error counter."
		0x80047072
		Vxx_pft_tia_mv_thd
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_thdchgt_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_mv_ms_rgn_cor
		"Programmable breakpoint of air temperature average value for soot mass correction."
		0x80047060
		Vxx_pft_tia_mv_thd
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_sttoutx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tia_wait_cdn
		"Breakpoint of mean value air temperature for threshold to get into waiting mode"
		0x80046d4a
		Vxx_pft_tia_mv_out
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tqi_oil_csm
		"Programmable torque set point breakpoints map for engine oil consumption interpolation"
		0x800584de
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		8
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tqi_sp_flp_bas
		"Cmp_pft_flp_pr_bas_oil_dil  Y breakpoints"
		0x800553d8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		RB_CONV_Nm
		16
		0.0
		2047.96875
    DISPLAY_IDENTIFIER Ctb_pft_tqi_sp_flp_bas 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tqi_sp_oil_1
		"programmable torque breakpoints map for oil dilution interpolation"
		0x800553b6
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		RB_CONV_Nm
		16
		0.0
		2047.96875
    DISPLAY_IDENTIFIER Ctb_pft_tqi_sp_oil_1 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tqi_sp_rij_bas
		"Cmp_pft_n_tqi_sp_oil_rij  Y breakpoints"
		0x8005539e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		RB_CONV_Nm
		11
		0.0
		2047.96875
    DISPLAY_IDENTIFIER Ctb_pft_tqi_sp_rij_bas 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tt_efi_int
		"Programmable indicated exhaust fuel injector temperature breakpoints for internal dynamic viscosity calculus."
		0x800582e6
		Vxx_tt_k
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		10
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatitbo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatitbo_tefiarx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_tt_efi_int_sph
		"Programmable indicated exhaust fuel injector temperature for thermal conductivity calculus."
		0x800582d0
		Vxx_tt_k
		RSA_RecordLayout_Axis_UWORD
		1240
		yBrdDAa_dujFjAd_eiepCwc_K__1n0a
		10
		233.
		1473.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_utp_inj_fms_wup_slop
		"Programmable engine breakpoint for factor for maximum quantity of exhaust fuel injection during pft rgn"
		0x80044ad4
		Vxx_pft_utp_reg
		RSA_RecordLayout_Axis_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasipbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasipbt_patxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_utp_pat
		"CSF upstream temperature breakpoint table for catalyst pressure drop calculation"
		0x80057d76
		Vxx_pft_utp
		RSA_RecordLayout_Axis_UWORD
		1240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		5
		-40.
		1200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_chgtend_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_vh_dist_dist_min
		"Programmable vehicle distance breakpoints."
		0x80046c5c
		Vxx_vh_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		6
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_oilcsmx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_vh_dist_oil_csm
		"Programmable vehicle distance breakpoints"
		0x800584d0
		Vxx_vh_dist_l_res
		RSA_RecordLayout_Axis_UWORD
		1048560
		kDgkitc_uFBiyid_xcsinbd_k__6na0
		6
		0.
		1048560.
    FORMAT "%7.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_pft_vnt_err_reg
		"Programmable governor error for boost air pressure breakpoints"
		0x80044ac2
		Vxx_vnt_reg_spg_err
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		8
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimlos.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimlos_ptqxxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_ptq_dp_form_fac
		"Difference pressure axis for form factor map."
		0x800415f2
		Vxx_dp_fil
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		10
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_mngtxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_rbst_el_csm_dsb_amp
		"Atmospheric pressure breakpoints in engine robustness strategy"
		0x8005ce9a
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		9
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_rps_sp_amp_fac_sta
		"Breakpoints of atmospheric pressure correction for rail pressure setpoint during starting mode"
		0x80068ec0
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inatipfi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inatipfi_rupxxsr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_sens_rup_acc
		"Upstream pressure breakpoints to take into account the nominal sensor accuracy"
		0x800580dc
		Vxx_raw_sens_pft_rel_up_prs_cor
		RSA_RecordLayout_Axis_UWORD
		20000
		BhendBa_Bnmgqnd_blgaFzd_hCRa10a
		10
		-10000.
		10000.
    FORMAT "%6.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_cor_n_1
		"Engine speed breakpoint for richness correction depending on coolant temperature"
		0x8004317a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_cor_n_2
		"Engine speed breakpoint for richness correction depending on rail pressure error"
		0x80043158
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_cor_rail_prs
		"Rail pressure breakpoint for richness correction"
		0x80043136
		Vxx_rps_rail_prs_dif
		RSA_RecordLayout_Axis_UWORD
		4000
		AhCDoja_prbvulb_dammzgc_b__0a0a
		16
		-2000.
		2000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_cor_tco
		"Coolant temperature breakpoint for richness correction"
		0x80043114
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_fac_amp
		"Atmospheric pressure breakpoint for richness correction"
		0x80043106
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_fac_vs
		"Vehicle speed breakpoint for richness correction"
		0x800430f0
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		10
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkppxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_maf_pp
		"Maf breakpoint for richness limitation in pp mode"
		0x80041fba
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_maf_pr
		"Maf breakpoint for richness limitation in pft_rgn operation"
		0x800422bc
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_maf_rij_1
		"Maf breakpoint for richness limitation in RIJ mode depending on gear"
		0x800430ce
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_maf_rij_2
		"Maf breakpoint for richness limitation in RIJ mode depending on gear"
		0x800430ac
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_maf_rij_3
		"Maf breakpoint for richness limitation in RIJ mode depending on gear"
		0x8004308a
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_maf_rij_amp
		"Maf breakpoint for richness latmospheric pressure correction"
		0x80043068
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		16
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkppxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_n_pp
		"Engine speed breakpoint for richness limitation in pp mode"
		0x80041f98
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_n_pr
		"Engine speed breakpoint for richness limitation in pft_rgn operation"
		0x8004229a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_n_rij_1
		"Engine speed breakpoint for richness limitation in RIJ mode depending on gear"
		0x80043046
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_n_rij_2
		"Engine speed breakpoint for richness limitation in RIJ mode depending on gear"
		0x80043024
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_n_rij_3
		"Engine speed breakpoint for richness limitation in RIJ mode depending on gear"
		0x80043002
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_rich_lim_n_rij_amp
		"Engine speed breakpoint for richness atmospheric pressure correction"
		0x80042fe0
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_tkof_ass_fac_pr
		"Breakpoints of takeoff factor for richness offset factor in PR mode"
		0x80042290
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		8
		0.
		1.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_tkof_ass_fac_rij
		"Breakpoints of takeoff factor for richness offset factor for takeoff in RIJ mode"
		0x80042fd7
		Vxx_tkof_ass_fac
		RSA_RecordLayout_Axis_UBYTE
		1
		ltluECa_kDentwc_ulilrCa_roA_50a
		8
		0.
		1.
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UBYTE' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_tkof_pft_load_rij
		"Average positive soot load speed breakpoint for richness offset for takeoff in RIJ combustion mode"
		0x80042fce
		Vxx_pft_mv_pos_sot_load_spd
		RSA_RecordLayout_Axis_UBYTE
		0.348
		tqfnykb_zrjpzpb_cvihkvb_gC_o00a
		8
		0.002
		0.35
    FORMAT "%5.3" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_tkof_rich_maf_pr
		"Maf breakpoint for richness offset for takeoff in PR mode"
		0x8004227e
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		8
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_tkof_rich_maf_rij
		"Maf breakpoint for richness offset for takeoff in RIJ mode"
		0x80042fbc
		Vxx_maf_dyn
		RSA_RecordLayout_Axis_UWORD
		5000
		jkAkzAa_urBxnEd_ptjsFeb_mt__10a
		8
		0.
		5000.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_tkof_rich_n_pr
		"Engine speed breakpoint for richness offset for takeoff in PR mode"
		0x8004226c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmxt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmxt_smkrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_smk_tkof_rich_n_rij
		"Engine speed breakpoint for richness offset for takeoff in RIJ mode"
		0x80042faa
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_spg_fail_amp
		"Ambient pressure bkp for SPG fail value calculation"
		0x800578aa
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_spg_fail_fim_tot
		"Total injection quantity bkp for SPG fail value calculation"
		0x80057898
		Vxx_fms_fim_tot
		RSA_RecordLayout_Axis_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		8
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiap.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiap_spgxxcs_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_spg_fail_n
		"Engine speed bkp for SPG fail value calculation"
		0x80057886
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqlimmnt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqlimmnt_statqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_sta_n
		"Engine speed breakpoints for starting set point tables"
		0x8004191e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_sta_tco
		"Coolant temperature breakpoints for starting set point tables"
		0x8005841e
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_t_asd_var_utp_sp
		"Programmable time breakpoints for CSF up temp variable set point in ASD regeneration mode"
		0x80045c62
		Vxx_pft_asd_rgn_var_utp_ctr
		RSA_RecordLayout_Axis_UWORD
		6553.5
		isbAByd_airlCCb_devbarc_s_R0ooa
		8
		0.
		6553.5
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_t_fms_adv_aut_eng_fac_rij
		"Time breakpoint of autonomous engine factor for main advance during rij"
		0x80050e4c
		Vxx_fms_adv_aut_eng_t
		RSA_RecordLayout_Axis_UWORD
		655.35
		EfhAhyd_imFhDDa_ysgdhoa_s_Ra0oa
		8
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_act_amp_n_rij
		"Engine speed breakpoints for the regulation activation correction f(atmo pressure) in RIJ mode"
		0x800497c2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_act_amp_rij
		"Atmospheric pressure breakpoints for release governor in rij mode"
		0x800497b0
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_act_amp_tqi_rij
		"Torque breakpoints for the regulation activation correction f(atmo pressure) in RIJ mode"
		0x8004979e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_act_n_pr
		"Engine speed breakpoints for the regulation activation in PR mode"
		0x80048bd2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_act_n_rij
		"Engine speed breakpoints for the regulation activation in regular combustion mode"
		0x80049784
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_act_tqi_pr
		"Inner torque breakpoints for the regulation activation in PR mode"
		0x80048bb8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_act_tqi_rij
		"Inner torque breakpoints for the regulation activation in regular combustion mode"
		0x8004976a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_adv_cor_amp_pr
		"Atmospheric pressure breakpoints for the environmental corrections of advance in PR mode"
		0x80048ba6
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_adv_cor_bas_n_pr
		"Engine speed breakpoints for the advance correction in PR mode"
		0x80048b84
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_adv_cor_bas_tqi_pr
		"Inner torque breakpoints for the advance correction in PR mode"
		0x80048b62
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_adv_cor_n_pr
		"Engine speed breakpoints for the environmental corrections of advance in PR mode"
		0x80048b50
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_adv_cor_tia_pr
		"Air temperature breakpoints for the environmental corrections of advance in PR mode"
		0x80048b3e
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_adv_cor_tqi_pr
		"Torque breakpoints for the environmental corrections of advance in PR mode"
		0x80048b2c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_amp
		"Atmospheric pressure breakpoints"
		0x80049758
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_dg_fac_err_pr
		"Loop temperature deviation breakpoints of D part factor correction in PR mode"
		0x80048b12
		Vxx_tbt_err_ulim_dif_pr
		RSA_RecordLayout_Axis_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		12
		-1200.
		1200.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_dg_fac_err_rij
		"Loop temperature deviation breakpoints of D part factor correction in RIJ mode"
		0x8004973e
		Vxx_tbt_err_ulim_dif_rij
		RSA_RecordLayout_Axis_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		12
		-1200.
		1200.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_dg_fac_n
		"Engine speed breakpoints for D gain in rij and pp mode"
		0x80049724
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fim_main_cor_n_pr
		"Engine speed breakpoints for the fuel main quantity correction in PR mode"
		0x80048af8
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fim_main_cor_n_rij
		"Engine speed breakpoints for the fuel main quantity correction in RIJ mode"
		0x8004970a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fim_main_cor_tqi_pr
		"Inner torque breakpoints for the fuel main quantity correction in PR mode"
		0x80048ade
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fim_main_cor_tqi_rij
		"Inner torque breakpoints for the fuel main quantity correction in regular combustion mode"
		0x800496f0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fpo_cor_amp_pr
		"Atmospheric pressure breakpoints for the environmental corrections of fuel post in PR mode"
		0x80048acc
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fpo_cor_bas_n_pr
		"Engine speed breakpoints for the fuel post quantity correction in PR mode"
		0x80048ab2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fpo_cor_bas_tqi_pr
		"Inner torque breakpoints for the fuel post quantity correction in PR mode"
		0x80048a98
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fpo_cor_n_pr
		"Engine speed breakpoints for the environmental corrections of fuel post in PR mode"
		0x80048a86
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fpo_cor_tia_pr
		"Air temperature breakpoints for the environmental corrections of fuel post in PR mode"
		0x80048a74
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_fpo_cor_tqi_pr
		"Torque breakpoints for the environmental corrections of fuel post in PR mode"
		0x80048a62
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_ig_fac_err
		"Loop temperature deviation breakpoints of I part factor correction"
		0x80048a48
		Vxx_tbt_err_ulim
		RSA_RecordLayout_Axis_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		12
		-1200.
		1200.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_max_tqi_cor_n_pr
		"Engine speed breakpoints for the max inner torque correction in PR mode"
		0x80048a2e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_max_tqi_cor_n_rij
		"Engine speed breakpoints for the max inner torque correction in RIJ mode"
		0x800496d6
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_max_tqi_cor_tqi_pr
		"Inner torque breakpoints for the max inner torque correction in PR mode"
		0x80048a1c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_max_tqi_cor_tqi_rij
		"Inner torque breakpoints for the max inner torque correction in RIJ mode"
		0x800496c4
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_pg_fac_err
		"Loop temperature deviation breakpoints of P part factor correction"
		0x80048a02
		Vxx_tbt_err_ulim
		RSA_RecordLayout_Axis_UWORD
		2400
		dFBFEab_bkAlFtb_ewgpawa_q__110a
		12
		-1200.
		1200.
    FORMAT "%7.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_pid_fac_n
		"Engine speed breakpoints for PID gain"
		0x800489e8
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_pid_fac_tqi
		"Inner torque breakpoints for PID gain"
		0x800489ce
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_amp_n_pr
		"Engine speed breakpoints for temp target correction f(atmo pressure) in PR mode"
		0x800489bc
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_amp_pr
		"Atmospheric pressure breakpoints"
		0x800489aa
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		8
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_amp_tqi_pr
		"Inner torque breakpoints for tbt target correction f(atmo pressure) in PR mode"
		0x80048998
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_min_max_n
		"Engine breakpoints for the maximal and minimal tbt setpoint"
		0x800496b2
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_min_max_n_pr
		"Engine breakpoints for the maximal and minimal temperature before turbine setpoint in PR mode"
		0x80048986
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_ms
		"Soot mass breakpoints for correction curve of tbt setpoint"
		0x800496a0
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		8
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_ms_amp_n_rij
		"Engine speed breakpoints for tbt setpoint correction f(soot mass, atmo pressure) in RIJ mode"
		0x8004968e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_ms_amp_tqi_rij
		"Torque breakpoints for tbt setpoint correction f(soot mass, atmo pressure) in RIJ mode"
		0x8004967c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_ms_n_pr
		"Engine speed breakpoints for the tbt setpoint correction f(soot mass) in PR mode"
		0x80048974
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_ms_pr
		"Soot mass breakpoints for tbt setpoint in PR mode"
		0x80048962
		InAtiPfi_NVM.Vxx_pft_ms_dp_NVM
		RSA_RecordLayout_Axis_UWORD
		100
		xmigjyd_xBwpCvc_lfvbarc_g_R0ooa
		8
		0.
		100.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_ms_tqi_pr
		"Torque breakpoints for the tbt setpoint correction f(soot mass) in PR mode"
		0x80048950
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_n_pr
		"Engine speed breakpoints for the target temperature in PR mode"
		0x8004892e
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_n_rij
		"Engine speed breakpoints for the tbt setpoint in RIJ mode"
		0x8004965a
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tia_n_pr
		"Engine speed breakpoints for temp target correction f(intake air temperature) in PR mode"
		0x8004891c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tia_n_rij
		"Engine speed breakpoints for tbt setpoint correction f(intake air temperature) in RIJ mode"
		0x80049648
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tia_pr
		"Air temperature breakpoints for tbt setpoint in PR mode"
		0x8004890a
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tia_rij
		"Air temperature breakpoints for tbt setpoint in RIJ mode"
		0x80049636
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tia_tqi_pr
		"Inner torque breakpoints for tbt target correction f(air temperature) in PR mode"
		0x800488f8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tia_tqi_rij
		"Inner torque breakpoints for tbt tbt setpoint correction f(air temperature) in RIJ mode"
		0x80049624
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tqi_pr
		"Inner torque breakpoints for the target temperature in PR mode"
		0x800488d6
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbcortbt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbcortbt_tbtrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tbt_sp_tqi_rij
		"Inner torque breakpoints for the tbt setpoint in RIJ mode"
		0x80049602
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tco
		"16 engine coolant temperature breakpoints"
		0x800583fc
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclicoi.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclicoi_tcoxxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tco2
		"Engine coolant temperature breakpoints"
		0x800583e8
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_cor
		"X-breakpoints for coolant correction table"
		0x80057cd8
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		10
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqsetftr.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetftr_drcutxx_axxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tco_cut
		"Engine coolant temperature breakpoints for injection cut"
		0x80043340
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		9
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxmd_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tco_dif
		"Table of Delta between water temp. and  reference  water temp. in running conditions (near 92 °c)"
		0x800585b8
		Vxx_tco_dif
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		17
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_adv_amp_tco_fac_rij
		"Coolant temperature breakpoint of atmospheric pressure factor for main advance set point"
		0x80050e44
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_adv_aut_eng_fac_rij
		"Coolant temperature breakpoint of autonomous engine factor for main advance during rij"
		0x80050e32
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_adv_tco_fac_pr
		"Coolant temperature breakpoint of coolant temperature factor"
		0x8006ac96
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_adv_tco_fac_rij
		"Coolant temperature breakpoint of coolant temperature factor"
		0x80050e20
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_adv_tia_tco_fac_rij
		"Coolant temperature breakpoint of atmospheric temperature factor for main advance set point"
		0x80050e18
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_faf_amp_fac_rij
		"Coolant temperature breakpoint of atmopheric pressure factor during regular injection"
		0x80068b94
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_faf_tia_fac_rij
		"Coolant temperature breakpoint of intake air temperature factor during regular injection"
		0x80068b8c
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_fp1_amp_cor_sta
		"Coolant temperature breakpoints for starting set point correction table"
		0x80068ce2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_fp1_amp_fac_rij
		"Coolant temperature breakpoint of amp factor for quantity of pre injection 1 during rij"
		0x8004a8da
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_fp1_tia_fac_rij
		"Coolant temperature breakpoint of tia factor for quantity of pre injection 1 during rij"
		0x8004a8d2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_fp2_amp_cor_sta
		"Coolant temperature breakpoints for starting set point correction table"
		0x80068dc4
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_fp2_amp_fac_rij
		"Coolant temperature breakpoint of amp factor for quantity of pre injection 2 during rij"
		0x8004b392
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_fp2_tia_fac_rij
		"Coolant temperature breakpoint of tia factor for quantity of pre injection 2 during rij"
		0x8004b38a
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_pinj_cut
		"Coolant temperature breakpoint for pre injection cut off"
		0x8004c9de
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_taf_amp_fac_rij
		"Coolant temperature breakpoint of atmopheric pressure factor during regular injection"
		0x80069d2a
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_taf_tia_fac_rij
		"Coolant temperature breakpoint of intake air temperature factor during regular injection"
		0x80069d22
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_tlp_fac_pr
		""
		0x8004f2ce
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_tp1_amp_fac_rij
		"Coolant temperature breakpoint of amp factor for separation of pre injection 1 during rij"
		0x80052170
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_tp1_tia_fac_rij
		"Coolant temperature breakpoint of tia factor for separation of pre injection 1 during rij"
		0x80052168
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_tp2_amp_fac_rij
		"Coolant temperature breakpoint of amp factor for separation of pre injection 2 during rij"
		0x80053350
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_tp2_tco_fac_rij
		"Coolant temperature breakpoint of tco factor interpolation for separation of preinjection 2 during r"
		0x8005333e
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_fms_tp2_tia_fac_rij
		"Coolant temperature breakpoint of tia factor for separation of pre injection 2 during rij"
		0x80053336
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_oil_1
		"Ctp_pft_tco_oil_dil_cor breakpoints"
		0x8005538c
		Vxx_oil_dil_tco
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_tco_oil_1 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_oil_rij
		"Ctp_pft_tco_oil_dil_cor_rij breakpoints"
		0x8005537a
		Vxx_oil_dil_tco
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_tco_oil_rij 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_rgn
		"Programmable coolant temperature breakpoints map"
		0x800680d4
		Vxx_tco_ena
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_rgn_ena
		"Programmable coolant temperature breakpoints map"
		0x800680c6
		Vxx_tco_ena
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_rps_amp_tco_fac_rij
		"Coolant temperature breakpoint of atmospheric pressure factor for rail pressure set point"
		0x8004e9ba
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsstax_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_rps_sp_amp_cor_sta
		"Coolant temperature breakpoints for starting set point correction table"
		0x80068eb2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_rps_tco_fac_pr
		"Coolant temperature breakpoint of coolant temperature factor during pr"
		0x8004dad8
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_rps_tco_fac_rij
		"Coolant temperature breakpoint of coolant temperature factor"
		0x8004e9a8
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_rps_tia_tco_fac_rij
		"Coolant temperature breakpoint of atmospheric temperature factor for rail pressure set point"
		0x8004e9a0
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		3
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_tceauxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tco_sp
		"Bkpt of Water temperature setpoint table."
		0x8004013e
		Vxx_tco_sp
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		7
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tco_thpl
		"4 engine coolant temperature breakpoints"
		0x8005cffc
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		4
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_tsp_tp1_amp_cor_sta
		"Coolant temperature breakpoints for starting set point tables correction"
		0x8006af6e
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2sta_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tco_tsp_tp2_amp_cor_sta
		"Coolant temperature breakpoints for starting set point tables correction for pre injection 2 separation"
		0x8006b050
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'vfemgctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'vfemgctl_chgovxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_thpl_alt_n
		"Breakpoints of engine speed for the calculation of the alternator speed"
		0x8005cfea
		Vxx_VfEmgCtl_thpl_alt_n
		RSA_RecordLayout_Axis_UWORD
		65535
		ryhzxDd_bDsnzFa_Ehryxwb_r_A_1oa
		8
		0.
		65535.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'ouclocoo.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'ouclocoo_diagthp_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_thpl_diag_n
		"Breakpoints of engine speed for THP diag"
		0x800590ac
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		10
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqsetacs.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqsetacs_tqreqxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_thpl_n
		"Tunable breakpoints of engine speed for particle filter request of torque"
		0x800432e4
		Vxx_n_mv
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_ex_prs_sp_cor_pr
		"Breakpoints y for basic air temperature correction of exhaust pressure setpoint in pft regeneration mode"
		0x80060a52
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_ex_prs_sp_cor_rij
		"Breakpoints y for basic air temperature correction of exhaust pressure setpoint in regular injection mode"
		0x8006132e
		Vxx_tia_ex_sp_rij
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_ex_prs_sp_tkof_pr
		"Breakpoints y for basic air temperature correction of exhaust pressure setpoint for take off assistance in pft regeneration mode"
		0x80060a40
		Vxx_tia_ex_sp_pr
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_ex_prs_sp_tkof_rij
		"Breakpoints y for basic air temperature correction of exhaust pressure setpoint for take off assistance in regular injection mode"
		0x8006131c
		Vxx_tia_ex_sp_rij
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_adv_tia_fac_pr
		"Atmospheric temperature breakpoint of atmospheric pressure factor for main advance set point"
		0x8006ac84
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_adv_tia_tco_fac_rij
		"Atmospheric temperature breakpoint of atmospheric pressure factor for main advance set point"
		0x80050e06
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_fp1_tia_fac_rij
		"Intake air temperature breakpoint of tia factor for quantity of pre injection 1 during rij"
		0x8004a8c0
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_fp2_tia_fac_rij
		"Intake air temperature breakpoint of tia factor for quantity of pre injection 2 during rij"
		0x8004b378
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinjcut_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_pinj_cut
		"Intake air temperature breakpoint for pre injection cut off"
		0x8004c9cc
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_tlp_fac_pr
		""
		0x8004f2bc
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_tp1_tia_fac_rij
		"Intake air temperature breakpoint of tia factor for separation of pre injection 1 during rij"
		0x80052156
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pin2rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_fms_tp2_tia_fac_rij
		"Intake air temperature breakpoint of tia factor for separation of pre injection 2 during rij"
		0x80053324
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_oil_dil_spd
		"Ctp_pft_tia_oil_dil_spd_cor breakpoints"
		0x80055368
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_tia_oil_dil_spd 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_oil_dil_spd_rij
		"Ctp_pft_tia_oil_dil_spd_rij breakpoints"
		0x80055356
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_tia_oil_dil_spd_rij 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregfms_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_pft_fms_cor
		"Programmable intake air temperature breakpoints for basic injected fuel mass flow settings correction."
		0x80045736
		Vxx_tia_reg
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregspx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_pft_utp_sp_cor
		"Programmable intake air temperature breakpoints for CSF up temp setpoint correction"
		0x80045c50
		Vxx_tia_reg
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_rgn
		"Programmable manifold temperature breakpoints map"
		0x800680b8
		Vxx_tia_ena
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_rgn_ena
		"Programmable manifold temperature breakpoints map"
		0x800680aa
		Vxx_tia_ena
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsprxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_rps_tia_fac_pr
		"Atmospheric temperature breakpoint of tia factor for rail pressure during pr"
		0x8004dac6
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbrapspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbrapspt_rpsrijx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_rps_tia_tco_fac_rij
		"Atmospheric temperature breakpoint of atmospheric pressure factor for rail pressure set point"
		0x8004e98e
		Vxx_tia
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		8
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asbstspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asbstspt_bpscoxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tia_spg_sp_max_fac
		"Breakpoints y for setpoint limitation factor depending on intake air temperature"
		0x80043a80
		Vxx_tia_spg_sp_max
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		10
		-40.
		200.
    FORMAT "%6.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tkof_amp
		"Atmospheric pressure breakpoints for atmospheric pressure factor"
		0x80040234
		Vxx_amp
		RSA_RecordLayout_Axis_UWORD
		20000
		fikncub_fAjCpia_Evxyxob_h_A_1oa
		6
		0.
		20000.
    FORMAT "%5.0" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tkof_ass_h_vs_mv
		"High average vehicle speed breakpoints for high vehicle speed average"
		0x80040226
		Vxx_tkof_ass_h_vs_mv
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		6
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tkof_ass_l_vs_mv
		"Low average vehicle speed breakpoints for low vehicle speed average"
		0x80040218
		Vxx_tkof_ass_l_vs_mv
		RSA_RecordLayout_Axis_UWORD
		655.35
		uEardjb_BFoibqb_vkamstb_khA_00a
		6
		0.
		655.35
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrctko.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrctko_tkofxxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tkof_tenv
		"Environmental temperature breakpoints for environmental temperature factor"
		0x8004020a
		Vxx_tenv
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inclilui.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inclilui_toilxcs_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_toil
		"engine oil temperature breakpoints"
		0x80058506
		Vxx_toil
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		16
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_toil_oil_2
		"Ctp_pft_toil_eva_kin_fac_cor breakpoints"
		0x80055344
		Vxx_pft_toil_clc
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_toil_oil_2 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cllubwea.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cllubwea_oildilx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_toil_oil_3
		"Ctp_pft_toil_oil_eva_cor breakpoints"
		0x80055332
		Vxx_pft_toil_clc
		RSA_RecordLayout_Axis_UWORD
		240
		RB_CONV_DegC
		8
		-40
		200
    DISPLAY_IDENTIFIER Ctb_toil_oil_3 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpftmng.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpftmng_rgntpxx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_toil_rgn_err
		"Programmable oil temperature breakpoints map for evaporation factor on dist and time since last rgn failure"
		0x8006809c
		Vxx_pft_toil_clc
		RSA_RecordLayout_Axis_UWORD
		240
		vbwtgvc_iBjqEia_piCzsea_qCRao0a
		6
		-40.
		200.
    FORMAT "%5.1" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tq_dif_tco
		"Ctb_tq_dif_tco"
		0x800597b2
		Vxx_tco
		RSA_RecordLayout_Axis_UWORD
		240
		VA_F_0v1_m40_2
		6
		-40
		200
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'pcdrcrds.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'pcdrcrds_fstqdxx_xxxxxx_data.c' */
/begin AXIS_PTS
		Ctb_tq_dif_vs
		"Ctb_tq_dif_vs"
		0x8005979c
		Vxx_vs
		RSA_RecordLayout_Axis_UWORD
		655.35
		VA_F_0v01_p0_3
		10
		0
		655.35
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_adv_cor_n_pr
		"Engine speed breakpoints for advance correction of main torque model in pr mode"
		0x8005c380
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_adv_cor_n_rij
		"Engine speed breakpoints for advance correction of main torque model in rij mode"
		0x8005caf4
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		12
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_adv_cor_tqi_pr
		"Torque breakpoints for advance correction of main torque model in pr mode"
		0x8005c366
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_adv_cor_tqi_rij
		"Torque breakpoints for advance correction of main torque model in rij mode"
		0x8005cada
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_adv_fac_pr
		"Advance breakpoints of main torque model correction in pr mode"
		0x8005c34c
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		12
		-360.
		360.
    FORMAT "%7.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : No RefInputQuantity specified: assume 'NO_INPUT_QUANTITY' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_adv_fac_rij
		"Advance breakpoints of main torque model correction in rij mode"
		0x8005cac0
		NO_INPUT_QUANTITY
		RSA_RecordLayout_Axis_UWORD
		720
		dkcyncd_nblDwgd_fhtbmxa_q__0a00
		12
		-360.
		360.
    FORMAT "%7.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_fim_tot_inv_pr
		"Torque breakpoints of main torque model in rij mode"
		0x8005c326
		Vxx_smk_fim
		RSA_RecordLayout_Axis_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		18
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_fim_tot_inv_rij
		"Torque breakpoints of main torque model in rij mode"
		0x8005ca9a
		Vxx_smk_fim
		RSA_RecordLayout_Axis_UWORD
		100
		hcbCBdc_eypFcyc_nbBriqd_mt__1a0
		18
		0.
		100.
    FORMAT "%6.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_fim_tot_n_pr
		"Engine speed breakpoints of main torque model in pr mode"
		0x8005c300
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		18
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_fim_tot_n_rij
		"Engine breakpoints of main torque model (torque to quantity conversion) in RIJ mode"
		0x8005ca74
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		18
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_fim_tot_tqi_pr
		"Torque breakpoints of main torque model in pr mode"
		0x8005c2da
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		18
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_fim_tot_tqi_rij
		"Torque breakpoints of main torque model in rij mode"
		0x8005ca4e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		18
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_lp_n_ocd
		"Engine breakpoints of late post torque compensation in ocd mode"
		0x8005bc16
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		8
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_mainocd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_lp_tqi_ocd
		"Torque breakpoints of late post torque compensation in ocd mode"
		0x8005bc04
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_post_efy_n_pr
		"Engine speed breakpoints for post injection torque model in pr mode"
		0x8005cd3c
		Vxx_n
		RSA_RecordLayout_Axis_UWORD
		16383.75
		tAmwcfc_DapEvdb_Ehzzxwb_r_A_4oa
		16
		0.
		16383.75
    FORMAT "%8.2" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'tqmdlfsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'tqmdlfsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_bas_post_efy_tqi_pr
		"Torque breakpoints for post injection torque model in pr mode"
		0x8005cd1a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_ex_prs_sp_bas_pr
		"Y breakpoint of exhaust pressure basic setpoint in pft regeneration mode"
		0x80060a1e
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_ex_prs_sp_bas_rij
		"Y breakpoint of exhaust pressure basic setpoint in regular injection mode"
		0x800612fa
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_ex_prs_sp_pft_cor_pr
		"Y breakpoint of exhaust pressure setpoint correction in pft regeneration mode"
		0x80060a08
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'asexpspt.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'asexpspt_eplsrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_ex_prs_sp_pft_cor_rij
		"Y breakpoint of exhaust pressure setpoint correction in regular injection mode"
		0x800612e4
		Vxx_tqi_raw
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'inasiiat.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'inasiiat_uitxxmd_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fil
		"X-breakpoints for filter value for dowstream compressor temperature"
		0x80057cc2
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_0p_rij
		"Engine torque breakpoint of main advance for cold coolant temperatrure without pre-injection"
		0x80050de4
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_1p_rij
		"Engine torque breakpoint of main advance for cold coolant temperatrure with 1 pre-injection"
		0x80050dc2
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_2p_rij
		"Engine torque breakpoint of main advance for cold coolant temperatrure with 1 pre-injection"
		0x80050da0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_amp_tco_cor_pr
		"Engine torque breakpoint of atmospheric pressure correction for main advance during pr"
		0x8006ac6a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_amp_tco_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction for main advance"
		0x80050d86
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_aut_eng_cor_rij
		"Engine torque breakpoint of autonomous engine correction for main advance during rij"
		0x80050d6c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_dp_map_cor_rij
		"Engine torque breakpoint of delta mass air pressure factor for main advance during rij"
		0x80050d52
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_dp_rps_cor_pr
		"Engine torque breakpoint of delta rail pressure correction for main advance during pr"
		0x8006ac50
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_dp_rps_cor_rij
		"Engine torque breakpoint of delta rail pressure factor for main advance during rij"
		0x80050d38
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_gear_rij
		"Engine torque breakpoint of main advance with specific gearbox ratio."
		0x80050d16
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_max_pr
		"Engine torque breakpoint of maximun for main advance during pr"
		0x8006ac3a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_max_rij
		"Engine torque breakpoint of maximun for main advance"
		0x80050d00
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_min_pr
		"Engine torque breakpoint of minimum for main advance during pr"
		0x8006ac24
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_min_rij
		"Engine torque breakpoint of minimum for main advance"
		0x80050cea
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_ms_dp_cor_pr
		"Engine torque breakpoint of soot mass correction for main advance during pr"
		0x8006ac0a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_tco_cor_pr
		"Engine torque breakpoint of coolant temperature correction for main advance during pr"
		0x8006abf0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_tia_tco_cor_pr
		"Engine torque breakpoint of atmospheric temperature correction for main advance during pr"
		0x8006abd6
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_adv_tia_tco_cor_rij
		"Engine torque breakpoint of atmospheric temperature correction for main advance"
		0x80050cd0
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_amp_cor_pr
		"Programmable indicated torque breakpoints for atmospheric pressure correction of global fuel injection during pft rgn"
		0x80044aa8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_adv_0p_pr
		"Engine torque breakpoint of base main advance without pre-injection during pr"
		0x8006abb4
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_adv_1p_pr
		"Engine torque breakpoint of base main advance with 1 pre-injection during pr"
		0x8006ab92
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_mainprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_adv_2p_pr
		"Engine torque breakpoint of base main advance with 2 pre-injections during pr"
		0x8006ab70
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_fp1_2p_pr
		"Engine speed breakpoint of basic quantity of pre-injection 1 with 2 pre-injection during pft rgn"
		0x8004bd0a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_fp1_pr
		"Engine torque breakpoint of basic quantity of pre-injection 1 during pft regeneration"
		0x8004bce8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_fp2_pr
		"Engine torque breakpoint of basic quantity of pre-injection 2 during pft regeneration"
		0x8004c4c8
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_fpo_pr
		"Engine torque breakpoint of basic quantity of post injection during pft regeneration"
		0x8004d108
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_lpostpr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_tlp_pr
		"Engine torque breakpoint of basic angle of late post injection during pft regeneration"
		0x8004f29a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_tp1_2p_pr
		"Engine speed breakpoint of basic separation of pre-injection 1 with 2 pre-injection during pft rgn"
		0x80053dcc
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj1pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_tp1_pr
		"Engine torque breakpoint of basic separation of pre-injection 1 during pft regeneration"
		0x80053daa
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_tp2_2p_pr
		"Engine speed breakpoint of basic separation of pre-injection 2 with 2 pre-injection during pft rgn"
		0x800548a4
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_pinj2pr_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_tp2_pr
		"Engine torque breakpoint of basic separation of pre-injection 2 during pft regeneration"
		0x80054882
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbtimtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbtimtsp_postprx_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_bas_tpo_pr
		"Engine torque breakpoint of basic angle of post injection during pft regeneration"
		0x8005515a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_efi_max_pr
		"Programmable indicated torque breakpoints for maximum quantity of exhaust fuel injection during pft regeneration"
		0x80044a86
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_efi_min_pr
		"Programmable indicated torque breakpoints for minimum quantity of exhaust fuel injection during pft regeneration"
		0x80044a70
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_faf_amp_cor_rij
		"Engine torque breakpoint of atmospheric pressure correction during regular injection"
		0x80068b72
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_faf_max_rij
		"Engine torque breakpoint of maximum quantity of after injection during regular injection"
		0x80068b5c
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_faf_rij
		"Engine torque breakpoint of quantity of after injection for cold coolant temperature"
		0x80068b3a
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_aftrrij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_faf_tia_cor_rij
		"Engine torque breakpoint of intake air temperature correction during regular injection"
		0x80068b20
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		12
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwsck.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwsck_lpostsc_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_flp2_wish_h
		"Torque setpoint breakpoint for high level of activation of split late post injection"
		0x80049890
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		8
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_flp_max_pr
		"Programmable indicated torque breakpoints for maximum quantity of late post injection during pft regeneration"
		0x80044a4e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'atpcbctl.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'atpcbctl_tregcnf_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_flp_min_pr
		"Programmable indicated torque breakpoints for minimum quantity of late post injection during pft regeneration"
		0x80044a38
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		10
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
/* RSA::SAXHandler : deposit 'RSA_RecordLayout_Axis_UWORD' automatically added */
/* XmlToolChain::L2::FindAddresses : Src = 'cbffwtsp_pin1rij_xxxxxd_data.c' */
/begin AXIS_PTS
		Ctb_tqi_fms_fp1_2p_rij
		"Engine torque breakpoint for quantity of pre-injection 1 with 2 preinjection for cold tco during rij"
		0x8004a89e
		Vxx_tqi_sp
		RSA_RecordLayout_Axis_UWORD
		2047.96875
		zbBngEa_hiajkdc_Fvwbcrc_NC_02oa
		16
		0.
		2047.96875
    FORMAT "%10.5" 
/end AXIS_PTS
/* RSA::SAXHandler : Converted from 'cbffwtsp.xml' */
/* RSA::SAXHandler : MaxDiff automatically computed using 'PhysicalUpperLimit - PhysicalLowerLimit' */
