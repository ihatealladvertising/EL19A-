		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_bgin_clu_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007242 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007244 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007244 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007244 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_brk_pdl_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_brk_pdl_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007244 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cata_nok_cge.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cata_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000718e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007190 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007190 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007190 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_clu_cnt_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_clu_cnt_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007190 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007298 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007298 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007298 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_crk_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007298 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007302 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007302 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007302 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007302 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_cyc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_crk_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_no_sig.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_crk_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007306 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007306 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007306 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_crk_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007306 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007304 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007304 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007304 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_crk_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_crk_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007304 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007246 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007246 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007246 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cru_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007246 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007248 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007248 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007248 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_swi_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cru_sl_swi_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007248 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_sl_tot.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cru_sl_tot 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_vs_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cru_vs_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cru_whl_cmd_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000724e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007250 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007250 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007250 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oc_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cru_whl_cmd_oc_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007250 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007252 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007252 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007252 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_cru_whl_cmd_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_cru_whl_cmd_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007252 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007192 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007192 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007192 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_doc1_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007192 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007194 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007194 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007194 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_doc1_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007194 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007196 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007196 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007196 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_doc1_utp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_doc1_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007196 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_itl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ecm_err_itl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007320 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007320 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007320 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_err_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ecm_err_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007320 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_bus_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ecm_inj_bus_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ecm_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_inj_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ecm_inj_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_1.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ecm_mon_secu_1 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ecm_mon_secu_2.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ecm_mon_secu_2 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000730e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007198 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007198 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007198 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_efi_inj_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007198 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_efi_inj_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_inj_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_efi_inj_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007254 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007254 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007254 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_efi_sldv_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007254 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007256 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007256 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007256 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_efi_sldv_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007256 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007258 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007258 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007258 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_efi_sldv_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_efi_sldv_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007258 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007350 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007350 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007350 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_egr_byp_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007350 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_egr_byp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_egr_byp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_egr_byp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_flow_meca.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_emtv_flow_meca 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000719e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_emtv_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_hbdg_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_emtv_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_ofs_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_emtv_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_emtv_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_emtv_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071a8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_emtv_reg_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_emtv_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071aa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_esp_data_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_data_seq_ctr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_esp_data_seq_ctr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_esp_no_frm.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_esp_no_frm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_no_lk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ex_prs_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ex_prs_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ex_prs_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_crt_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000725e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_actr_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000731a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007260 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007260 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007260 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007260 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007262 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007262 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007262 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007262 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007264 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007264 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007264 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007264 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007266 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007266 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007266 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ff_fct_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ff_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007266 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007268 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007268 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007268 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_actr_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007268 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_actr_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_actr_crt_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_crt_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_actr_crt_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007330 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007330 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007330 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_actr_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_actr_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007330 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_fct_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_fct_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000726e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007270 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007270 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007270 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_fct_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007270 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007272 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007272 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007272 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_fct_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007272 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007274 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007274 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007274 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_fct_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007274 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007276 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007276 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007276 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fprs_fct_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fprs_fct_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007276 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007314 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007314 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007314 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fsys_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007314 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007316 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007316 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007316 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fsys_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007316 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007318 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007318 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007318 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fsys_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fsys_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007318 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007234 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007234 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007234 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fuel_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007234 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007232 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007232 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007232 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_fuel_temp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_fuel_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007232 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_fail.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_glow_cmd_fail 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_glow_cmd_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_glow_cmd_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071b8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_glow_cmd_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_glow_cmd_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ba 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_in_cam_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_crk_cmp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_in_cam_crk_cmp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000729e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007300 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007300 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007300 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_cyc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_in_cam_cyc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007300 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_no_sig.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_in_cam_no_sig 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072a0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_in_cam_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_in_cam_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007278 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007278 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007278 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007278 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071bc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj1_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj1_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000727e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071be 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj2_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj2_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007280 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007280 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007280 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007280 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007282 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007282 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007282 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007282 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj3_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj3_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007284 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007284 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007284 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_chk_sum.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_chk_sum 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007284 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007286 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007286 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007286 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_crt_intv.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_crt_intv 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007286 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_h_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_h_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_l_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_l_puls.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_l_puls 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj4_shp.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj4_shp 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_cpt_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj_cpt_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007308 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007308 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007308 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_inj_oor.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_inj_oor 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007308 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_ip_lght_tco_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_ip_lght_tco_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_el.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_it_hbdg_el 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_hbdg_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_it_hbdg_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_ofs_no_norm.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_it_ofs_no_norm 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071c8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_it_reg_blk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ca 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_clos.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_it_reg_blk_clos 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071cc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_blk_open.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_it_reg_blk_open 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ce 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_it_reg_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_it_reg_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_maf_reg_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_maf_reg_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_down.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_mafs_apl_down 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_mafs_apl_up.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_mafs_apl_up 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_map_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_map_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_oil_dil_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_oil_dil_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000735e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_no_lk.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_no_lk 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071d8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007310 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007310 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007310 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_nok_cge.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_nok_cge 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007310 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007360 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007360 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007360 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_rgn_dirt.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_rgn_dirt 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007360 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_chr.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_utp_chr 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071da 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_utp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071dc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_utp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071de 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_neg_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_utp_neg_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pft_utp_pos_err.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pft_utp_pos_err 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pws_1_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_1_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pws_1_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pws_2_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071e8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_2_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pws_2_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ea 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pws_3_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ec 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_pws_3_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_pws_3_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071ee 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_rail_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723c 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007238 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007238 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007238 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_h_lvl.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_rail_prs_h_lvl 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007238 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_rail_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007236 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007236 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007236 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_plaus.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_rail_prs_plaus 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007236 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rail_prs_sig_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_rail_prs_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000723e 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_dirt_lkg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_rup_dirt_lkg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_rup_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_rup_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072b2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_amp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f0 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_amp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_amp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f2 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007356 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007356 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007356 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_egr_temp_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007356 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007358 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007358 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007358 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_egr_temp_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_egr_temp_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007358 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_emtv_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_emtv_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f4 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ex_prs_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f6 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ex_prs_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ex_prs_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071f8 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_it_nok.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_it_nok 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fa 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_maf_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fc 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_maf_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_maf_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00071fe 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007200 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007200 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007200 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_map_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007200 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007202 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007202 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007202 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_map_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_map_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007202 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_rup_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ae 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_rup_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_rup_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd00072ac 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007204 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007204 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007204 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_tco_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007204 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007206 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007206 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007206 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_tco_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007206 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tco_sig_mcut.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_tco_sig_mcut 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000732a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007208 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007208 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007208 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_h.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_tia_h 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007208 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_tia_l.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_tia_l 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000720a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007344 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007344 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007344 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_heat_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007344 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007346 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007346 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007346 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_ovh.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_heat_ovh 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007346 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007348 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007348 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007348 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scg.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_heat_scg 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007348 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_heat_scw.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_heat_scw 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd000734a 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007342 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007342 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x20 
    DISPLAY_IDENTIFIER Sbx_mf_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007342 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_lamb_oc.fm_static_eprm_bitfield.Sbx_rdn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x10 
    DISPLAY_IDENTIFIER Sbx_rdn_sens_ups_lamb_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007342 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_cf_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x80 
    DISPLAY_IDENTIFIER Sbx_cf_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007340 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_dyn_xxx
		""
		UBYTE
		hdvlAid_gAgipka_Fqnyxmd__A_aaa0
		1
		100
		0.
		255.
    BIT_MASK 0x08 
    DISPLAY_IDENTIFIER Sbx_dyn_sens_ups_pump_oc 
    FORMAT "%6.3" 
    ECU_ADDRESS 0xd0007340 
/end MEASUREMENT
/* RSA::SAXHandler : Converted from 'dgdftmng.xml' */
/* RSA::SAXHandler : 'Resolution' unspecified: use default '1' */
/* RSA::SAXHandler : 'Accuracy' automatically inserted: use default '100' */
/* XmlToolChain::L2::FindAddresses : Src = 'dgdftmng_failxxx_xxxxxx_data.c' */
/begin MEASUREMENT
		fm_sta_eprm_sens_ups_pump_oc.fm_static_eprm_bitfield.Sbx_mf_xxx
		""
		UBYTE
